# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_LED: length 20.1
  TOP w0.356: 230.26,190.2 LQ803.1 ; LQ803.1 v2(231.86,190.2) ; LQ803.1 230.98,189.77 ; LQ803.4 v2(229.44,191.5)
  TOP w0.432: v2(242.47,190.57) LC801.2 242.98,189.99 ; v2(231.04,188.35) LC802.2 230.54,187.77 ; LC800.2 243.08,191.15 ; v2(226.52,192.59) LC803.2
  TOP w0.508: CON1.9 232.85,186.84 ; CON1.9 v2(233.74,188.1) ; CON1.9 232.85,189.36 ; CON1.9 232.12,188.1 ; v2(244.05,187.6) LQ801.2 ; LQ801.2 244.05,186.29 ; LQ801.2 243.16,186.89 ; v2(245.27,190.12) 245.27,190.12 LQ800.2 244.05,190.12 ; 244.05,190.12 244.05,189.52 ; 244.05,190.12 244.05,190.72 ; 229.36,189.4 LQ802.2 ; LQ802.2 230.25,188.8 ; LQ802.2 v2(228.3,188.8) ; LQ802.2 229.36,188.21 ; 240.55,186.84 CON1.10 239.8,188.1
  vias: v1(224.01,191.88) v2(223.61,192.93) v2(223.77,185.97) v2(225.52,192.93) v2(226.94,185.97) v2(228.06,192.93) v2(229.48,185.97) v2(230.6,192.93) v2(230.71,189.26) v2(231.68,192.26) v2(232.02,185.97) v2(232.85,186.62) v2(233.14,192.93) v2(234.07,192.36) v2(234.56,185.97) v2(234.9,192.93) v2(234.95,191.96) v2(237.1,185.97) v2(237.22,192.92) v2(239.64,185.97) v2(239.74,192.93) v2(239.69,188.6) v2(239.69,187.47) v2(242.18,185.97) v2(242.28,192.93) v2(243.19,191.14) v2(244.72,185.97) v2(244.82,192.93) v2(247.12,189.03) v2(247.26,185.97) v2(247.36,192.93) v2(249.8,185.97) v2(249.9,192.93)
GND_RT8812A: length 9.2
  TOP w0.254: R8901.1 v2(253.57,81.03) ; R8910.2 252.66,83.83 SR8906.1 252.33,84.41 251.73,84.41 251.57,84.57 v2(251.57,85.01)
  TOP w0.508: v1(253.78,80.37) 253.78,80.83 v2(253.57,81.03)
  IN3 w0.254: v2(251.57,85.01) 251.57,83.02 253.55,81.03 v2(253.57,81.03)
GND_RT8813A: length 21.8
  TOP w0.254: v1(209.51,188.91) 208.41,188.91 v2(207.88,189.44) 207.52,189.8 R9736.1 C9720.1
  TOP w0.432: v2(193.24,190.14) 193.12,190.25 193.12,191.14 193.3,191.32 SR9705.1
  IN1 w0.254: v2(207.88,189.44) 207.88,190.1 207.02,190.96 203.54,190.96 202.57,190 200.82,190 200.34,190.48 193.58,190.48 v2(193.24,190.14)
GND_SIGNAL: length 7.9
  TOP w0.381: C8824.2 277.86,29.83 v2(278.11,30.08) 278.36,30.08 278.75,29.7 R8813.1 ; R8807.1 266.2,36.53 v2(266.22,36.51)
  TOP w0.432: C8814.1 v2(269.5,34.24)
  TOP w0.508: C8825.1 285.53,28.64 v2(285.6,28.56) ; v2(280.97,34.22) C8816.1 ; C8826.1 285.48,27.24 v2(285.6,27.11) ; R8808.1 275.4,36.3 v2(275.72,36.62) ; C8808.1 278.54,36.38 v2(278.21,36.05) ; C8809.1 v2(279.94,36.05)
  vias: v1(282.63,36.25) v2(282.09,35.91) v2(282.54,35.44)
VCC: length 5.4
  BOTTOM w0.203: C80108.1 55.53,187.79 55.53,187.48 56.17,186.85 U8000.42
  BOTTOM w0.432: v1(56.14,190.51) 55.53,190.51 55.09,190.08 SR8000.1 C80108.1
VCC0P9_CIO: length 3.1
  TOP w0.254: U1101.R11 293.15,41.36 v5(292.84,41.05) U1101.R12 ; U1101.R9 293.15,42.05 v5(293.47,42.37) 293.15,42.7 U1101.R8
  BOTTOM w0.102: 292.64,40.75 292,40.75 291.7,40.44 v1(291.52,40.44)
VCC0P9_DP: length 7.5
  TOP w0.254: U1101.L12 295.1,40.75 v5(295.42,41.07) 295.1,41.4 U1101.L11
  BOTTOM w0.102: 289.13,42.17 289.4,42.44 v1(289.4,42.65)
  BOTTOM w0.254: v5(292.17,40.39) 292.17,40.37 291.66,39.86 290.56,39.86 C1170.1 ; v2(288.27,41.66) 288.27,41.76 288.68,42.17 289.13,42.17 C1172.1 C1169.1 ; v5(292.17,41.1) 292.17,41.32 292.06,41.43 C1171.1
  BOTTOM w0.305: v5(294.77,43.01) 294.67,42.91 C1167.1
VCC0P9_LVR: length 16.1
  TOP w0.254: U1101.H11 296.4,41.4 v5(296.07,41.07) 295.75,41.4 U1101.J11 ; 296.72,38.47 296.4,38.15 U1101.H18 ; 296.72,38.47 297.02,38.18 297.02,38.18 U1101.F18 ; 296.72,38.47 v5(296.72,38.47)
  IN2 w0.305: v2(297.99,34.69) 298.71,35.4 298.71,41.81 298.31,42.2 297.83,42.2 296.7,41.07 v5(296.07,41.07)
  BOTTOM w0.305: v1(297.31,38.51) 297.27,38.47 v5(296.72,38.47) 296.72,39.58 C1165.1 C1166.1 296.41,40.91 296.25,41.07 v5(296.07,41.07)
VCC0P9_PCIE: length 1.2
  BOTTOM w0.102: 294.54,35.97 294.54,34.79 v1(294.53,34.78)
  vias: v5(294.14,39.12) v5(294.13,38.46) v5(294.11,37.85) v5(294.12,37.2)
VCC0P9_SVR:
  vias: v1(303.87,49.26) v2(301.61,51.42) v2(302.24,50.49) v2(302.24,49.89) v2(302.25,49.28) v5(297.37,41.07) v5(297.37,40.42) v5(297.37,39.77)
VCC0P9_USB: length 2.3
  TOP w0.254: U1101.R16 293.15,38.8 v5(293.47,39.12) 293.15,39.45 U1101.R15
  BOTTOM w0.305: v5(293.47,39.12) 293.19,38.84 C1181.1 292.92,38.11 C1182.1
VCCGT_VCCSENSE: length 114.9
  TOP w0.254: R0903.1 64.75,183.67 v2(64.88,183.54) ; v3(95.09,130.64) 94.82,130.37 v1(94.82,129.67)
  IN3 w0.254: v2(64.88,183.54) 64.35,183.01 63.97,183.01 62.59,184.39 60.31,184.39 58.27,182.35 49.26,182.35 45.83,178.92 45.83,172.19 47.05,170.97 47.05,156.71 49.51,154.24 71.06,154.24 73.75,151.55 82.37,151.55 85.67,148.25 90.15,143.77 90.15,135.2 92.08,133.27 93.11,133.27 95.09,131.29 v3(95.09,130.64)
  BOTTOM w0.203: v2(64.88,183.54) 65.12,183.3 C8023.1 65.17,182.86 R8020.1 C8013.1 R8019.2 ; U0300.AH38 v3(95.09,130.64)
VCCGT_VSSSENSE: length 115.4
  TOP w0.254: R8089.1 63.94,182.94 64.19,183.19 v2(64.19,183.54) 64.19,183.64 R0902.1 ; v1(94.91,131.41) 94.51,131.01 v3(94.51,130.83)
  IN3 w0.254: v3(94.51,130.83) 94.51,131.32 92.92,132.91 91.93,132.91 89.72,135.13 89.72,143.51 82.06,151.17 73.59,151.17 70.9,153.87 49.39,153.87 46.69,156.56 46.69,170.79 45.47,172.02 45.47,179.07 49.13,182.73 58.15,182.73 60.16,184.74 63,184.74 v2(64.19,183.54)
  BOTTOM w0.203: U0300.AH37 94.69,129.76 94.69,130.29 94.51,130.47 v3(94.51,130.83) ; v2(64.19,183.54) 64.26,183.48 C8023.2 C8022.1 R8027.1
VCCIO_EN: length 7.2
  BOTTOM w0.102: U9400.15 102.86,166.52 103.08,166.3 103.25,166.3 103.69,165.86 103.69,165.52 103.45,165.28 v1(101.89,165.28) 101.63,165.03 C9411.1 R9403.2 101.63,162.85 101.45,162.67 D9400.1
VCCIO_FB: length 5.2
  BOTTOM w0.254: R9407.2 R9405.2 R9406.1 104.3,164.8 v1(104.17,164.93) 104.17,166.1 103.86,166.41 U9400.13
VCCIO_FB_R: length 4.6
  BOTTOM w0.203: R9405.1 103.44,162.29 v1(103.87,161.86) 105.06,161.86 105.76,161.16 106.27,161.16 106.6,160.83 JP9401.1
VCCIO_LX: length 1
  BOTTOM w0.432: 107.85,165.1 R9408.1
VCCIO_O: length 10.7
  IN3 w0.254: v2(103.97,170.44) 103.97,169.17 107.74,165.4 v2(107.74,163.41)
  BOTTOM w0.254: v2(103.97,170.44) 103.86,170.34 U9400.6 ; 108.52,162.8 C9416.1 107.85,163.29 v2(107.74,163.41)
  vias: v1(113.26,159.49)
VCCIO_RC:
  vias: v1(106.48,171.79)
VCCSA_VCCSENSE: length 110.7
  TOP w0.254: C8006.2 R8075.1 48.93,180.63 v2(48.77,180.47) 48.62,180.32 48.62,179.79 v1(48.47,179.64) ; C8006.2 C8001.1 ; C8006.2 SR8014.2
  IN1 w0.254: v2(99.45,153.7) 99.45,153.96 99.12,154.29 97.36,154.29 95.41,156.24 95.41,170.62 94.82,171.2 94.82,176.73 92.15,179.41 89.45,179.41 88.4,180.45 84.92,180.45 83.93,181.44 79.25,181.44 77.82,180.02 76.7,180.02 76.58,180.14 68.76,180.14 66.43,177.81 52.15,177.81 50.54,179.42 50.26,179.42 49.23,180.45 48.8,180.45 v2(48.77,180.47)
  BOTTOM w0.203: U0300.M38 107.69,130.94
  BOTTOM w0.254: v2(99.45,153.7) 99.45,153.91 99.75,154.21 100.26,154.21 100.67,153.8 100.67,153.62 102.34,151.94 102.34,151.92 102.38,151.88 102.38,142.71 103.89,141.2 104.87,141.2 107.65,138.42 107.65,130.98 107.69,130.94
VCCSA_VSSSENSE: length 112.8
  TOP w0.254: v1(52.25,182.71) 52.03,182.94 R8033.1 ; R8033.1 51.34,183.57 v2(51.29,183.62) ; R8033.1 C8001.2 C8003.2
  IN1 w0.254: v2(51.29,183.62) 51.16,183.49 51.16,179.33 52.33,178.16 66.28,178.16 68.62,180.5 76.72,180.5 76.85,180.37 77.68,180.37 79.1,181.79 84.08,181.79 85.07,180.8 88.35,180.8 88.54,180.81 88.55,180.8 89.51,179.85 89.6,179.76 92.3,179.76 95.21,176.85 95.21,171.33 95.76,170.77 95.76,156.39 97.52,154.64 99.27,154.64 100.09,153.82 v2(100.09,153.69)
  BOTTOM w0.152: v2(51.29,183.62) 51.64,183.98 52.83,183.98 53.06,183.74 U8000.31
  BOTTOM w0.203: U0300.M37 107.3,129.75 107.3,130.94
  BOTTOM w0.254: 107.3,130.94 107.3,138.28 104.72,140.85 103.74,140.85 102.03,142.56 102.03,151.73 101.99,151.77 101.99,151.79 v2(100.09,153.69)
VCCST_PG: length 282.9
  TOP w0.121: v2(119.54,80.77) 117.43,78.66 117.43,69.48 115.13,67.17 115.13,62.62 117.08,60.66 117.08,59.57 118.19,58.47 118.19,56.28 120.55,53.91 120.55,50.48 123.52,47.51 123.52,40.25 126.52,37.24 v1(126.52,33.76) 126.52,32.68 v2(126.9,32.3)
  IN1 w0.083: v2(126.9,32.3) 126.36,32.85 124.64,32.85 123.94,32.15 113.64,32.15 108.15,26.65 45.63,26.65 43.71,28.57 39.65,28.57 32.8,35.42 32.8,37.01 32.15,37.66 31.86,37.66 31.36,38.16 31.36,45.99 33.89,48.52 33.89,58.38 35,59.48 35,87.52 43.57,96.09 43.57,101.65 50.14,108.22 52.31,108.22 v2(59.75,115.65)
  BOTTOM w0.121: R0729.1 R0730.1 124.8,100.03 124.8,84.79 120.77,80.77 U0702.4 v2(119.54,80.77) ; R4405.2 57.61,123.53 58.65,122.49 58.65,116.75 v2(59.75,115.65)
VCCST_PG_R: length 23.8
  IN1 w0.083: v2(123.55,99.52) 122.23,99.52 120.45,101.3 119.51,101.3 117.71,103.11 117.71,104.76 v3(117.58,104.88)
  IN3 w0.083: v3(117.58,104.88) 116.57,105.9 115.78,105.9 114.53,107.14 114.53,109.84 113.52,110.85 111.73,110.85 110.69,111.89 v3(109.88,111.89)
  BOTTOM w0.102: U0300.H13 110.16,111.89 v3(109.88,111.89)
  BOTTOM w0.121: v1(124.31,98.94) 124.14,98.94 v2(123.55,99.52) 123.75,99.72 R0730.2
VCCST_PWRGD: length 100.9
  IN2 w0.102: v2(143.59,27.52) 134.26,27.52 129.92,31.86 128.95,31.86 126.94,33.87 115.08,33.87 114.2,32.99 v2(109.86,32.99)
  BOTTOM w0.102: v2(143.59,27.52) 143.59,27.14 143.74,26.98 R0751.1 146.41,26.36 146.4,26.35 U0703.4 ; U0702.2 SR0703.1 116.85,78.77 R0756.2 117.47,78.15 117.47,77.46 v1(117.79,77.15) 119.13,75.8 119.99,75.8 120.28,75.51 120.28,75.18 120.01,74.91 118.94,74.91 116.06,72.04 116.06,69.84 115.11,68.88 115.11,68.44 116.06,67.49 116.06,66.02 116.15,65.93 116.15,60.82 118.07,58.9 118.07,53.42 119.64,51.85 119.64,48.35 118.39,47.1 118.39,41.84 118.65,41.57 118.65,41.04 112.18,34.57 111.44,34.57 v2(109.86,32.99)
VDD18: length 5.2
  BOTTOM w0.254: v3(153.89,82.69) U7000.AV10 ; v3(154.57,83.45) 154.67,83.45 154.95,83.16 U7000.AT11 ; U7000.AV11 153.55,83.17 153.8,83.42 v3(153.9,83.42) ; U7000.AT10 v3(154.6,82.7)
  BOTTOM w0.3: U7000.AR11 155.94,83.34 v3(156.06,83.34) ; v3(155.98,82.7) 155.98,82.7 155.98,82.68 U7000.AR10 ; U7000.AW10 152.5,82.7 v3(152.5,82.71) ; U7000.AN11 156.76,83.34 v3(156.62,83.34) ; v3(156.72,82.7) 156.72,82.68 U7000.AN10 ; U7000.AW11 v3(152.5,83.4)
  vias: v1(151.16,75.34) v3(152.51,82) v5(158.05,82.7)
VDD_1P2V: length 36.9
  TOP w0.203: C1317.1 298.56,80.82 298.4,80.98 U1301.19 ; C1319.1 294.24,79.61 295.6,80.97 U1301.12 ; U1301.40 294.57,86.05 C1322.1 ; U1301.20 299.14,81.01 C1313.1
  TOP w0.381: C1313.1 299.14,79.79 299.19,79.74 v2(299.19,79.31) 299.04,79.15 C1317.1
  TOP w0.432: v2(294.87,79.15) C1319.1 ; C1322.1 v2(294.49,86.85)
  TOP w0.508: U1302.6 v2(280.71,87.04)
  IN1 w0.508: v2(294.49,86.85) 293.99,87.36 289.03,87.36 286.72,89.67 281.59,89.67 280.68,88.75 280.68,87.07 v2(280.71,87.04)
  BOTTOM w0.432: v2(299.95,86.85) 300.46,86.85 300.72,87.1 C1302.1 C1301.1 299.52,87.43 299.32,87.23 v2(299.32,86.85) ; R1302.2 C1304.1 C1303.1 293.86,86.21 v2(294.49,86.85)
  vias: v1(300.13,86.04)
VIN: length 2.7
  TOP w0.102: SR8001.1 55.19,189.86 v1(54.51,190.53)
  BOTTOM w0.203: v2(55.02,187.55) 55.77,186.8 U8000.41
15_17_ID: length 443.8
  TOP w0.102: v2(233.79,52.01) 233.17,51.39 233.17,49.7 232.39,48.93 232.39,48.71 231.63,47.94 231.63,45.69 231.17,45.23 231.17,44.51 231.48,44.2 231.48,42.12 231.13,41.77 231.13,41.28 R2309.2 230.43,40.58 230.43,39.09 v1(230.23,38.89) v2(229.71,38.37)
  IN2 w0.102: v2(94.98,182.66) 93.55,184.08 86.98,184.08 84.55,181.66 81.67,181.66 75.5,175.49 75.5,171.25 75.09,170.85 75.09,157.7 74.38,156.99 74.38,152.21 73,150.83 73,144.86 71.05,142.91 67.33,142.91 66.22,141.8 66.22,135.31 66.88,134.65 66.88,128.69 69.63,125.95 69.63,122.55 69.91,122.27 69.91,114.99 70.4,114.5 70.4,112.63 69.08,111.3 64.42,111.3 59.38,106.26 53.36,106.26 47.29,100.19 47.29,92.42 v2(47.58,92.13)
  IN3 w0.102: v2(229.71,38.37) 229.06,37.72 226.02,37.72 224.97,38.77 217.23,38.77 212.66,34.2 205.77,34.2 203.71,32.14 199.24,32.14 195.9,28.8 187.41,28.8 186.86,29.34 185.8,29.34 185.53,29.61 171.65,29.61 171.51,29.47 168.25,29.47 167.42,28.65 159.15,28.65 158.6,29.19 146.84,29.19 142.7,33.33 134.37,33.33 132.09,31.05 126.39,31.05 125.87,31.57 125.44,31.57 125.03,31.15 121.26,31.15 115.95,25.84 109.1,25.84 105.75,22.49 98.3,22.49 97.16,23.63 63.07,23.63 60.71,21.27 51.21,21.27 50.5,20.56 41.33,20.56 38.99,22.9 32.71,22.9 31.35,24.26 31.35,26.37 30.52,27.21 30.52,45.39 29.09,46.82 28.28,46.82 26.85,48.24 25.91,48.24 24.87,49.27 24.87,55.84 29.5,60.46 29.5,68.24 47.2,85.94 47.2,91.75 v2(47.58,92.13)
  BOTTOM w0.102: CON5602.28 95.25,182.88 95.03,182.66 v2(94.98,182.66) ; U2000.AN36 233.49,52.28 233.51,52.28 v2(233.79,52.01)
+1P2V: length 271.2
  TOP w0.254: v2(244.43,72.42) 244.43,71.99 244.97,71.45 R2452.2
  TOP w0.432: v2(273.97,84.67) 273.79,84.84 C1323.1 C1324.1 273.64,86.09 U1302.2
  IN1 w0.508: 136.63,33.48 137.57,32.54 140.01,32.54 140.01,32.54 140.35,32.54 143.7,29.19 161.3,29.19 161.85,28.63 164.97,28.63 165.58,29.24 196.22,29.24 203.07,36.09 203.07,37.88 207.54,42.35 207.54,43.28 211.16,46.9 219.18,46.9
  IN2 w1.016: 137.39,35.29 131.88,40.8 123.04,40.8 120.63,43.21 120.63,54.34 118.73,56.24 118.73,58.73 114.61,62.84 114.61,74.23 117.07,76.69 117.07,81.52
  IN4 w0.508: v2(244.43,72.42) 245.11,72.42 245.95,73.26 249.46,73.26 249.89,73.69 258.78,73.69 262.21,70.26 267.94,70.26 270.66,67.55 272.93,67.55 272.93,67.55 273.44,67.55 273.44,67.55 276.74,67.55 284.56,75.37 284.56,82.38 ; v2(287.69,84.18) 286.37,84.18 284.56,82.38 ; 284.56,82.38 281.71,85.24 280.05,85.24 279.5,84.68 277,84.68 276.36,85.33 274,85.33 273.97,85.3 v2(273.97,84.67) ; v2(57.23,99.27) 53.73,99.27 51.21,101.78 46.79,101.78 v2(46.31,102.27)
  BOTTOM w0.356: C0701.1 67.26,104.98 67.06,104.78 U0701.5
  BOTTOM w0.381: U0701.5 66.98,104.12 66.38,104.73 65.79,104.73 v2(63.89,106.64)
  BOTTOM w0.432: R1302.1 290.84,84.61 290.43,84.61 290.24,84.81 289.05,84.81 288.42,84.18 v2(287.69,84.18)
  BOTTOM w0.508: R5710.1 v2(136.63,34.3) ; v3(77.56,100.08) 77.28,99.8 69.96,99.8 68.71,101.05 68.71,103 69.56,103.85 C0701.1
  vias: v1(44.74,112.38) v2(118.85,81.39) v2(119.49,81.39) v2(136,34.3)
+1P2V_CPU: length 9.9
  IN2 w0.102: 111.18,108.5 110.33,108.5 ; 111.94,108.5 113.01,108.5
  IN2 w0.127: 113.06,106.92 112.53,106.92 ; 113.01,107.71 111.84,107.71
  BOTTOM w0.254: v3(96.35,108.9) 96.24,108.9 U0300.AG9 ; v3(94.52,110.85) 94.22,110.55 U0300.AJ12 93.9,110.55 v3(93.61,110.26) U0300.AL11 ; SR1001.2 122.49,102.95 v2(122.66,102.78) ; U0300.AE12 97.39,110.22 v3(97.25,110.22)
  BOTTOM w0.305: U0300.AA6 101.37,106.31 v3(101.44,106.31) 101.77,106.64 U0300.W6 ; U0300.L12 108.87,110.72 109.36,110.72 U0300.K12
  BOTTOM w0.33: v3(109.94,110.24) 109.64,110.55 U0300.K12
  vias: v1(102.85,103.36) v2(78.49,97.06) v2(78.92,97.49) v2(79.36,97.92) v3(86.3,107.67) v3(86.3,107.02) v3(88.1,110.29) v3(88.84,106.28) v3(89.04,110.82) v3(96.4,106.26) v3(104.87,106.28) v3(104.88,105.64) v3(108.97,106.26) v3(110.67,106.3)
+1P2V_DUAL: length 251.3
  TOP w0.305: CON1700.12 45.37,54.09 45.42,54.13 C1837.1 ; C1839.1 66.39,54.13 66.37,54.11 CON1700.96 ; v2(94.03,46.11) 94.12,46.02 CON1700.199 ; CON1600.178 88.87,66.3 89.43,66.85 v2(89.72,66.85) ; C1833.1 50.55,55.15 50.62,55.22 CON1600.33 ; v2(69.46,54.7) 69.47,54.7 C1838.1 70.03,55.18 70.12,55.27 CON1600.111 ; CON1700.124 73.37,53.92 v2(73.56,54.11) ; C1825.1 81.37,54.04 81.37,54.03 CON1700.148 ; C1825.1 82.06,54.7 v2(82.06,54.7) ; C1825.1 81.37,54.69 ; CON1700.163 85.12,42.99 v2(85.17,42.94) ; v2(82.06,54.06) 82.63,54.06 82.87,53.82 CON1700.154 ; CON1600.12 45.37,65.97 44.99,66.35 44.99,67.37 45.45,67.83 v2(45.62,67.83) ; CON1600.147 81.12,55.65 81.47,55.31 82.04,55.31 v2(82.06,55.33) 82.4,55.33 82.62,55.55 CON1600.153 ; v2(72.93,43.12) 73.1,43.28 73.12,43.28 CON1700.123 ; CON1600.135 76.12,55.56 75.91,55.35 v2(75.91,55.33) 74.93,55.33 74.62,55.64 CON1600.129 ; CON1600.54 55.87,67.63 ; v2(84.08,42.94) 84.12,42.98 CON1700.159 ; CON1700.220 99.37,54.48 C1617.1 ; CON1600.199 94.12,55.21 94.12,55.21 C1835.1 94.8,54.7 v2(95.13,54.36) ; CON1600.96 66.37,67.73 ; CON1700.112 70.37,53.73 70.73,54.09 v2(71.56,54.09) 71.87,53.77 CON1700.118 ; CON1600.124 73.37,65.76 73.82,66.2 v2(74.02,66.2) 74.46,66.2 74.87,65.79 CON1600.130 ; v2(105.19,42.88) 104.62,43.45 CON1700.241 ; CON1600.154 82.87,65.88 v2(83.29,66.3) ; 99.37,66.48 CON1600.220 ; v2(75.5,43.17) 74.83,43.17 74.62,43.37 CON1700.129 ; CON1600.117 71.62,55.45 v2(71.54,55.36) 71.56,55.33 72.78,55.33 73.12,55.68 CON1600.123 ; CON1600.141 77.62,55.63 77.93,55.33 v2(79.27,55.33) ; CON1700.130 74.87,54.17 C1823.1 ; CON1600.163 85.12,54.76 C1828.1 85.07,54.46 84.37,53.77 CON1700.160 ; CON1700.75 61.12,45.6 v2(60.82,45.91) ; v2(104.02,54.7) 104.05,54.7 104.05,54.7 C1834.1 104.62,55.32 104.63,55.33 104.63,56.52 104.62,56.53 CON1600.241 ; CON1700.153 82.62,43.49 v2(82.37,43.24) ; v2(84.38,54.65) 84.12,54.9 CON1600.159 ; CON1600.112 70.37,65.81 70.82,66.25 v2(71.18,66.25) 71.57,66.25 71.87,65.95 CON1600.118 ; v2(76.28,43.19) 76.12,43.35 CON1700.135 ; v2(76.74,66.41) 76.37,66.04 CON1600.136 ; CON1700.111 70.12,43.41 v2(70.39,43.14) ; CON1700.142 77.87,53.72 78.21,54.06 v2(79.27,54.06) ; CON1600.160 84.37,66.51 ; v2(71.35,43.14) 71.62,43.41 CON1700.117 ; CON1600.142 77.87,66.5 ; v2(80.88,45.97) 81.12,45.72 CON1700.147 ; v2(75.91,54.06) 76,54.06 76.11,54.18 76.12,54.18 76.42,54.47 76.42,54.48 C1824.1 76.64,54.69 76.64,54.03 76.37,53.77 CON1700.136 ; v2(88.27,54.42) 88.48,54.42 88.76,54.7 C1616.1 89.03,54.16 88.87,54 CON1700.178 ; v2(77.38,43.21) 77.62,43.45 CON1700.141 ; 81.37,66.44 CON1600.148 ; CON1600.75 61.12,55.44 60.79,55.1 60.79,54.7 ; CON1700.54 55.87,54.35 C1832.1 ; CON1700.33 50.62,45.53 50.28,45.88 v2(50.25,45.88)
  TOP w0.432: R1710.1 59.49,103.33 59.29,103.54 59.29,104.81 ; v2(65.71,54.72) 65.74,54.7 C1839.1 ; C1843.1 51.55,54.68 v2(51.52,54.7) ; C1832.1 57.12,54.7 v2(57.14,54.71) ; C1836.1 60.79,54.7 v2(61.65,54.7) ; C1837.1 46.49,54.7 v2(46.52,54.72) ; C1617.1 100.24,54.7 100.26,54.67 v2(101,54.67)
  TOP w0.508: C1833.1 v2(51.52,54.7)
  IN4 w0.381: v2(60.82,45.91) 60.82,45.32
  BOTTOM w0.254: CON1601.141 75.63,66.27 75.62,66.28 ; 75.7,70.59 R1601.1 75.01,71.28 ; 74.73,70.24 R1600.1 74,69.58
  BOTTOM w0.305: CON1701.178 86.88,45.61 v2(87.13,45.86) ; CON1701.141 75.63,53.76 75.9,54.03 75.9,54.05 v2(75.91,54.06) ; CON1701.159 82.13,54 v2(82.06,54.06) ; CON1701.130 72.88,43.2 ; CON1701.12 v2(43.38,43.31) ; CON1701.117 69.63,53.9 v2(69.46,54.07) 69.38,54.15 69.24,54.15 69.23,54.14 68.46,54.14 68.13,53.8 CON1701.111 ; CON1701.163 83.13,53.78 82.84,54.06 v2(82.06,54.06) ; CON1701.160 v2(82.37,43.24) ; v2(63.81,57.97) 63.92,57.97 64.38,57.52 CON1601.96 ; v2(74.02,66.2) 74.13,66.1 CON1601.135 ; CON1701.147 79.13,53.94 79.24,54.06 v2(79.27,54.06) ; CON1601.75 59.13,67.46 C1804.1 ; CON1701.129 72.63,53.76 72.3,54.09 v2(71.56,54.09) 71.28,54.09 71.13,53.93 CON1701.123 ; CON1701.118 69.88,43.32 ; CON1701.154 v2(80.88,45.97) ; v2(95.13,54.36) 94.8,54.7 92.92,54.7 92.13,53.9 CON1701.199 ; v2(88.27,54.42) 88.14,54.55 87.33,54.55 86.88,55.01 CON1601.178 ; CON1601.117 69.63,65.89 69.75,66.02 ; CON1601.112 68.38,55.15 68.82,54.7 v2(69.46,54.7) 69.64,54.7 70.02,55.08 70.02,55.54 69.88,55.68 CON1601.118 ; CON1601.241 102.63,63.78 102.7,63.71 102.7,61.22 101.94,60.46 100.31,60.46 v2(100.13,60.28) 99.88,60.28 97.77,58.17 97.77,58.02 97.38,57.62 CON1601.220 ; v2(73.56,54.11) 73.82,54.11 74.13,53.81 CON1701.135 ; CON1601.153 80.63,66.15 ; CON1601.54 53.88,55.5 53.07,54.7 v2(51.52,54.7) ; 74.63,43.31 74.38,43.57 CON1701.136 ; v2(97.14,42.93) 97.38,43.17 CON1701.220 97.38,45.65 97.51,45.78 97.51,47.16 v2(97.36,47.3) ; v2(79.27,55.33) 79.27,55.35 79.38,55.46 CON1601.148 ; v2(91.98,66.28) 92.13,66.13 CON1601.199 ; CON1701.124 71.38,43.18 ; 68.38,43.17 CON1701.112 68.38,45.96 v2(68.17,46.17) ; CON1601.154 80.88,55.54 81.09,55.33 v2(82.06,55.33) 82.37,55.64 CON1601.160 ; CON1701.96 64.38,43.42 64.17,43.21 64.17,42.63 ; CON1601.136 74.38,55.64 74.68,55.33 v2(75.91,55.33) 75.9,55.35 75.9,55.37 75.88,55.39 CON1601.142 ; v2(82.06,54.06) 80.83,54.06 80.63,53.86 CON1701.153 ; CON1601.12 43.38,58.04 42.58,58.83 v2(42.02,58.83) ; CON1601.123 71.13,66.2 v2(71.18,66.25) ; v2(57.14,54.71) 58.88,54.71 59.13,54.47 CON1701.75 ; v2(46.52,54.72) v2(47.15,54.72) 48.01,54.72 48.49,54.25 48.49,53.87 48.62,53.74 CON1701.33 ; CON1701.54 53.88,45.57 v2(54.18,45.88) ; CON1601.159 82.13,66.12 82.12,66.12 ; CON1601.147 79.13,66.12 ; CON1701.142 75.88,43.24 ; CON1601.130 72.88,55.48 72.75,55.36 v2(71.54,55.36) 71.38,55.52 CON1601.124 ; CON1601.111 68.13,66.07 ; v2(79.03,46.11) 79.38,45.77 CON1701.148 79.38,43.56 79.1,43.29 ; CON1701.241 102.63,54.11 103.21,54.7 v2(104.02,54.7) ; CON1601.33 48.62,67.8 ; 72.62,66.15 72.63,66.15 CON1601.129 ; CON1601.163 83.13,65.99
  BOTTOM w0.381: v2(105.19,42.88) C1826.1 C1840.1 v2(105.98,41.51)
  BOTTOM w0.432: R1700.1 78.04,42.88 ; v2(89.03,41.49) 88.83,41.69 C1822.1 ; R1701.1 v2(113.77,47.35) ; 84.26,72.73 R1610.1
  vias: v1(43.06,94.77) v2(50.12,69.53) v2(50.12,68.89) v2(50.12,68.26) v2(50.12,67.62) v2(54.13,42.88) v2(56.72,68.74) v2(56.72,68.12) v2(56.72,67.51) v2(58.55,68.18) v2(58.55,67.57) v2(65.77,68.16) v2(65.77,67.52) v2(67.75,42.91) v2(68.99,67.8) v2(71.18,66.89) v2(72.93,42.48) v2(74.02,66.84) v2(76.74,67.02) v2(83.32,66.99) v2(98.28,67.29) v2(98.57,67.85) v4(52.05,103.36) v4(52.05,102.34) v4(52.81,103.87) v4(52.81,102.85) v4(52.81,101.71) v4(53.83,105.01) v4(53.83,103.87) v4(53.83,102.85) v4(53.83,101.71) v4(53.83,100.69) v4(54.72,105.01) v4(54.72,103.36) v4(54.72,102.22) v4(54.72,101.2) v4(54.72,100.31) v4(55.61,105.01) v4(55.61,104.12) v4(56.62,105.01) v4(57.64,105.01) v4(58.65,105.01)
+2P5_3VS_DIM: length 244.2
  TOP w0.305: v2(106.84,54.05) 107.14,54.35 C1709.1 107.14,54.77 107.78,55.4 107.91,55.4 108.12,55.62 CON1600.255
  TOP w0.432: v2(49.66,128.86) 49.38,129.14 R3103.2 ; 115.14,51.06 115.43,50.78 R1708.1 R1707.1 117.2,50.03 C1708.1 C1707.2
  TOP w0.508: 98.57,71.11 98.09,71.11 97.14,72.07 92.46,72.07 91.6,71.21 v2(91.04,71.21) 90.63,71.21 82.45,79.39 39.65,79.39 v2(39.35,79.69) ; 98.57,71.11 v2(98.58,71.11) ; 98.57,71.11 98.57,71.45 99.03,71.91 101.15,71.91 102.62,73.39 102.62,74.4 105.04,76.82 113.5,76.82 116.72,73.6 116.72,71.25 114.51,69.04 114.51,62.36 116.47,60.41 116.47,59.32 117.28,58.5 117.28,55.66 116.69,55.07 115.22,55.07 114.87,54.72 114.87,51.34 115.14,51.06
  IN3 w0.508: v2(39.35,79.69) 39.51,79.69 46.11,86.29 46.11,90.94 43.54,93.51 43.54,114.66 44.89,116.01 44.89,117.69 43.95,118.63 43.95,124.06 48.75,128.86 v2(49.66,128.86) ; 103.64,69.63 99.37,69.63 98.58,70.42 v2(98.58,71.11) ; v2(106.84,54.05) 106.97,54.18 106.97,65.97 105.06,67.88 105.06,69.53
  BOTTOM w0.305: 112.93,41.49 114.59,41.49 114.84,41.74 R1705.1 115.35,43.54 R1709.1 ; CON1601.255 106.13,65.78 104.63,67.27 103.71,67.27 103.28,67.7 C1705.2 C1706.1 C1704.1 103.46,70.52 103.46,71.52 102.84,72.14 102.84,72.88 101.19,74.53 ; CON1701.255 106.13,53.75 106.43,54.05 v2(106.84,54.05) ; R1704.1 100.34,42.15
  BOTTOM w0.381: R1604.1 R1605.1 103.51,76.94 103.26,77.2 101.96,77.2 100.82,76.05 100.82,74.15 ; 100.18,74.15 98.66,74.15 97.95,73.44 C1604.1 98.47,71.23 v2(98.58,71.11)
  BOTTOM w0.432: C1605.2 99.22,70.16 98.58,70.8 v2(98.58,71.11) ; C1605.2 C1606.1 ; C1605.2 R1607.1 100.13,69.88 R1608.1 ; 90.86,40.49 89.03,40.49 87.92,41.61 R1706.1 ; R1606.1 91.91,70.72 91.42,71.21 v2(91.04,71.21) 90.79,70.95 R1609.1
  vias: v1(80.19,11.97) v2(108.26,41.43) v2(108.9,41.43) v2(109.53,41.43)
+2P5VPP: length 2
  TOP w0.508: R5714.1 115.8,8.62 114.92,9.51
  vias: v2(113.16,63.43) v2(113.16,62.82) v2(113.37,53.12) v2(113.37,52.48)
+A/D_DOCK_IN: length 364.5
  TOP w0.381: R8805.2 263.61,36.41 v2(263.71,36.51)
  TOP w0.508: v2(4.07,62.28) D8801.1 1.68,63.57 1.68,70.06 2.43,70.81
  IN3 w0.508: v2(263.71,36.51) 263.99,36.51 264.62,35.87 264.62,34.86 263.68,33.92 262.06,33.92 261.08,32.94 256.39,32.94 256.2,32.75 255.34,32.75 254.14,31.55 247.28,31.55 244.11,28.39 232.37,28.39 231.88,27.9 230.87,27.9 229.27,26.29 229.27,25.77 226.36,22.87 224.02,22.87 221.42,25.46 v2(215.5,25.46) 214.33,26.63 205.29,26.63 202.33,23.67 201.91,23.67 199.77,21.52 188.43,21.52 187.6,20.68 185.65,20.68 184.79,19.82 178.77,19.82 178.37,20.23 172.93,20.23 172.61,19.9 172.56,19.87 172.52,19.82 172.28,19.58 143.78,19.58 141.08,16.87 112.63,16.87 111.61,15.86 70.77,15.86 67.49,12.57 64.74,12.57 64.12,13.19 60.56,13.19 59.95,13.8 57.12,13.8 56.38,13.06 55.51,13.06 55.44,13.13 51.8,13.13 48.68,10.01 40.24,10.01 40.14,9.91 34.88,9.91 34.02,10.78 33.78,10.78 28.32,16.24 24.43,16.24 22.11,18.56 22.11,23.81 22.89,24.59 22.89,28.71 22.03,29.57 22.03,35.72 20.96,36.79 20.96,47.53 13.82,54.67 13.82,56.75 13.06,57.51 10.62,57.51 7.55,60.59 5.62,60.59 4.07,62.14 v2(4.07,62.28)
  BOTTOM w0.432: v2(215.5,25.46) 217.29,23.67 227.76,23.67 228.36,24.27 235.44,24.27 236.34,23.38 237.23,23.38 239.72,20.89 239.72,15.89 239.25,15.42 239.25,13.95 240.26,12.94 R8835.2
+A/D_DOCK_IN_CON:
  vias: v1(9.23,66.38) v4(4.55,66.66) v4(4.55,65.39) v4(4.55,64.12) v4(5.19,64.75) v4(5.19,63.48) v4(5.82,66.66) v4(5.82,65.39) v4(5.82,64.12) v4(6.46,64.75) v4(6.46,63.48) v4(7.09,66.66) v4(7.09,65.39) v4(7.09,64.12) v4(7.73,64.75) v4(8.36,66.66) v4(8.36,65.39) v4(8.36,64.12)
+A/D_DOCK_IN_Q: length 362.9
  TOP w0.381: v2(277.88,38.85) 277.88,38.49 R8804.2
  IN1 w0.508: v2(277.88,38.85) 277.88,38.62 278.82,37.68 278.82,35.76 278.09,35.02 278.09,31.33 277.02,30.26 277.02,27.06 276.08,26.12 273.72,26.12 273.01,26.83 263.73,26.83 262.11,25.2 257.87,25.2 257.21,25.86 257.21,27.13 255.95,28.39 249.73,28.39 245.07,23.73 245.07,21.9 244.41,21.24 243.67,21.24 242.47,20.05 242.47,16.69 241.48,15.7 239.68,15.7 236.36,12.38 235.28,12.38 233.07,10.17 210.14,10.17 209.35,10.95 181.41,10.95 180,12.36 153.18,12.36 145.4,4.58 118.64,4.58 107.23,15.98 64.75,15.98 63.99,15.22 59.92,15.22 58.4,16.75 54.01,16.75 53.78,16.97 48.8,16.97 48.2,16.38 48.2,16.19 47.16,15.15 39.58,15.15 38.41,16.31 33.38,16.31 32.85,15.78 28.76,15.78 28.3,16.24 25.05,16.24 22.1,19.18 22.1,23.81 22.89,24.59 22.89,28.3 22.03,29.17 22.03,35.72 20.96,36.79 20.96,45.75 13.16,53.55 13.16,58.81 10.55,61.42 10.55,76.27 13.04,78.76 v2(14.31,78.76)
  vias: v1(12.91,77.78)
+A/D_DOCK_IN_Q_Q:
  vias: v1(20.73,84.72)
+AC_BAT_SYS: length 2045.5
  TOP w0.216: U8100.12 262.61,59.27 263.05,58.83 263.32,58.83
  TOP w0.432: R8300.1 32.9,46.34 33.38,46.82
  TOP w0.508: v2(265.28,56.3) 265.28,57.36 C8101.1 263.8,58.83 263.32,58.83 ; 33.38,46.82 33.38,47.28 34.68,48.57 34.68,52.51 31.84,55.35 v2(30.84,55.35)
  IN1 w0.762: 97.64,190.99 78.21,190.99 77.2,192.01 v4(55.48,192.01)
  IN1 w1.524: 43.67,156.06 43.67,153.15 52.3,144.52 52.3,137.4 41.13,126.22 41.13,111.23 35.54,105.65 35.54,102.6 23.35,90.41 23.35,81.03
  IN1 w1.905: 18.52,45.76 14.26,50.02 12.35,50.02 8.49,53.88 8.49,54.67 4.48,58.68 v2(4.48,59.03) 2.14,61.37 2.14,75.75 6.43,80.04 11.87,80.04 12.3,80.47 20.45,80.47 ; 235.12,8.42 239.04,8.42 240.69,10.07 240.69,12.47 242.3,14.08 281.92,14.08 ; 19.23,42.4 19.23,33.56 20.15,32.65 20.15,14.87 23.86,11.16 23.86,8.35 25.52,6.69 50.05,6.69 51.26,7.91 51.26,10.11 52.57,11.41 54.46,11.41 55.78,10.09 66.58,10.09 74.48,2.19 80.5,2.19 ; 222.7,8.43 180.82,8.43 178.59,10.65 161.09,10.65 159.37,8.92 159.37,3.79 157.71,2.14 82.71,2.14
  IN2 w1.524: 43.67,155.81 43.69,155.79 43.69,153.13 52.31,144.52 52.31,137.35 41.13,126.17 41.13,111.23 35.54,105.65 35.54,102.6 23.35,90.41 23.35,80.93
  IN2 w1.905: 18.52,45.76 14.26,50.02 12.35,50.02 8.49,53.88 8.49,54.67 4.48,58.68 v2(4.48,59.03) 2.14,61.37 2.14,75.75 6.43,80.04 11.87,80.04 12.3,80.47 20.45,80.47 ; 235.12,8.42 239.04,8.42 240.69,10.07 240.69,12.47 242.3,14.08 281.92,14.08 ; 80.5,2.19 74.48,2.19 66.58,10.09 55.78,10.09 54.46,11.41 52.56,11.41 51.26,10.12 51.26,7.93 50.04,6.71 25.5,6.71 23.86,8.35 23.86,11.16 20.15,14.87 20.15,32.65 19.23,33.56 19.23,42.4 ; 222.7,8.43 180.82,8.43 178.65,10.59 161.04,10.59 159.37,8.92 159.37,3.79 157.72,2.14 82.96,2.14
  IN3 w0.762: 97.64,190.99 78.21,190.99 77.2,192.01 v4(55.48,192.01)
  IN3 w1.524: 43.64,155.71 43.64,153.18 52.3,144.52 52.3,137.37 41.13,126.19 41.13,111.23 35.54,105.65 35.54,102.6 23.35,90.41 23.35,80.73
  IN3 w1.905: 281.92,14.08 242.3,14.08 240.69,12.47 240.69,10.07 239.04,8.42 235.12,8.42 ; 80.5,2.19 74.48,2.19 66.58,10.09 55.78,10.09 54.46,11.41 52.56,11.41 51.26,10.12 51.26,7.93 50.02,6.69 25.52,6.69 23.86,8.35 23.86,11.16 20.15,14.87 20.15,32.65 19.23,33.56 19.23,42.4 ; 18.52,45.86 18.52,45.96 14.47,50.02 12.35,50.02 8.52,53.86 8.52,54.62 4.48,58.66 v2(4.48,59.03) 2.14,61.37 2.14,75.75 6.43,80.04 11.87,80.04 12.3,80.47 20.45,80.47 ; 83.12,2.14 157.71,2.14 159.37,3.79 159.37,8.87 161.09,10.59 178.65,10.59 180.82,8.43 222.7,8.43
  IN4 w0.762: 97.64,190.99 78.21,190.99 77.2,192.01 v4(55.48,192.01)
  IN4 w1.524: 23.35,80.96 23.35,90.41 35.54,102.6 35.54,105.65 41.13,111.23 41.13,126.22 52.3,137.4 52.3,144.52 43.7,153.12 43.7,155.65 43.67,155.68 ; 114.41,153.14 104.63,153.14 99.93,148.44 75.61,148.44 70.06,154 70.06,155.61
  IN4 w1.905: 20.45,80.47 12.27,80.47 11.84,80.04 6.43,80.04 2.14,75.75 2.14,61.37 v2(4.48,59.03) 4.48,58.66 8.49,54.64 8.49,53.88 12.35,50.02 14.26,50.02 18.52,45.76 ; 222.7,8.43 180.82,8.43 178.59,10.65 161.09,10.65 159.37,8.92 159.37,3.79 157.74,2.17 82.78,2.17 ; 30.65,6.69 50.05,6.69 51.27,7.92 51.27,10.11 52.56,11.41 54.48,11.41 55.77,10.12 66.55,10.12 74.45,2.22 80.45,2.22 ; 281.92,14.08 242.3,14.08 240.69,12.47 240.69,10.07 239.04,8.42 235.12,8.42
  BOTTOM w0.508: v2(4.48,59.03) 4.48,59.64 5.29,60.46 12.68,60.46 13.32,59.82 16.49,59.82 17.86,61.2 20.08,61.2 20.76,60.52 20.76,57.47 22.37,55.86 24.34,55.86 24.67,55.53 30.66,55.53 v2(30.84,55.35)
  BOTTOM w1.016: 121.12,51.5 121.12,48.32 119.46,46.66 119.46,42.28 119.72,42.01 119.72,40.6 108.06,28.94 102.85,28.94 90.66,16.75
  BOTTOM w2.032: 49.26,168.66 44.56,173.36 44.56,190.1
  vias: v2(19.97,74.47) v2(21.63,78.49) v2(22.32,78.49) v2(22.97,78.49) v2(29.6,9.07) v2(30.23,9.07) v2(30.87,9.07) v2(31.5,9.07) v2(56.24,172.96) v2(61.19,171.94) v2(67.93,161.17) v2(69.83,177.15) v2(84,179.23) v2(89.21,173.67) v2(89.97,173.46) v2(90.96,164.78) v2(90.96,164.14) v2(90.96,163.51) v2(90.96,162.9) v2(90.96,162.26) v2(90.96,161.65) v2(90.96,161.02) v2(90.96,160.38) v2(98.41,191.27) v2(99.04,191.27) v2(99.68,191.27) v4(18.65,45.07) v4(18.65,44.2) v4(19.54,45.07) v4(19.54,44.2) v4(20.49,76.12) v4(20.75,75.29) v4(20.75,74.43) v4(21.06,78.98) v4(21.2,79.86) v4(21.32,80.75) v4(21.38,76.12) v4(21.63,75.25) v4(21.61,74.39) v4(21.9,79.27) v4(22.08,80.12) v4(22.27,76.13) v4(22.52,75.25) v4(22.47,74.39) v4(22.83,79.26) v4(22.97,80.12) v4(23.16,76.14) v4(23.73,80.75) v4(23.73,79.61) v4(23.73,78.62) v4(40.87,160.26) v4(40.87,159.11) v4(40.87,157.97) v4(40.87,156.83) v4(40.87,155.68) v4(42.02,160.26) v4(42.02,159.11) v4(42.02,157.97) v4(42.02,156.83) v4(42.02,155.68) v4(43.16,160.26) v4(43.16,159.11) v4(43.16,157.97) v4(43.16,156.83) v4(43.16,155.68) v4(44.18,191.88) v4(44.3,160.26) v4(44.3,159.11) v4(44.3,157.97) v4(44.3,156.83) v4(44.3,155.68) v4(45.07,191.88) v4(54.59,192.01) v4(55.23,172.07) v4(55.48,172.96) v4(56.11,172.07) v4(61.19,174.48) v4(61.19,173.59) v4(61.19,172.7) v4(67.93,160.38) v4(67.93,159.49) v4(67.93,158.6) v4(67.93,157.72) v4(67.93,156.83) v4(67.93,155.94) v4(69.24,173.98) v4(70.08,176.42) v4(70.08,175.55) v4(70.08,174.69) v4(70.08,173.83) v4(70.08,172.96) v4(70.08,172.07) v4(70.08,171.18) v4(70.59,177.15) v4(81.64,4.55) v4(81.64,3.66) v4(82.53,4.55) v4(82.53,3.66) v4(84.74,179.23) v4(85.6,179.25) v4(86.47,179.25) v4(87.36,179.25) v4(88.7,174.35) v4(89.57,174.35) v4(89.64,14.71) v4(89.74,172.63) v4(89.74,171.74) v4(89.74,170.85) v4(90.53,14.71) v4(90.63,172.63) v4(90.63,171.74) v4(90.63,170.85) v4(92.92,164.17) v4(92.94,163.28) v4(92.94,162.39) v4(92.94,161.5) v4(93.83,162.39) v4(93.83,161.5) v4(93.88,164.17) v4(93.86,163.3) v4(97.69,165.31) v4(97.69,164.42) v4(97.69,163.53) v4(115.68,153.02) v4(115.68,152.13) v4(122.04,52.05) v4(122.04,51.16) v4(229.01,8.87) v4(229.01,7.98) v4(229.9,8.87) v4(229.9,7.98) v4(283.01,15.22) v4(282.98,14.33) v4(282.98,13.47) v4(283.87,15.22) v4(283.87,14.33) v4(283.87,13.47) v4(284.33,16.31) v4(285.01,15.22) v4(285.01,14.33) v4(285.01,13.47) v4(285.9,15.22) v4(285.9,14.33) v4(285.9,13.47) v4(286.32,16.27) v4(287.02,15.22) v4(287.02,14.33) v4(287.02,13.47)
+AC_BAT_SYS_FBVDDQ: length 147.2
  TOP w0.381: R8912.2 248.29,89.19 248.27,89.16
  TOP w0.635: 248.27,89.16 245.57,89.16 241.53,93.2
  IN2 w0.635: 105.37,178.67 105.37,180.96
  IN2 w0.762: 107.85,179.15 107.85,181.06 ; 110.6,181.39 110.95,181.03
  IN2 w1.016: 102.34,178.04 102.34,180.45
  IN2 w1.27: 212.96,115.55 211.05,122.03 210.04,126.34 210.04,168.76 205.85,172.96 205.85,179.56 205.09,180.32 190.23,180.32 ; 222.61,101.07 227.56,96.12 229.98,96.12 ; 213.32,112.47 arc(211.28,104.02) 219.69,101.84
  IN2 w1.397: 111.23,179.81 116.06,184.64
  IN2 w2.032: 130.99,185.81 127.44,185.81 125.3,187.94 118.6,187.94
  vias: v1(227.92,88.42) v2(231.27,96.1) v2(231.81,95.51) v2(232.42,95.36) v2(233.03,95.36) v4(112.15,176.11) v4(112.15,175.19) v4(112.15,174.3) v4(113.11,176.11) v4(113.11,175.19) v4(113.11,174.3) v4(114.08,176.11) v4(114.08,175.19) v4(114.08,174.3) v4(115.04,176.11) v4(115.04,175.19) v4(115.04,174.3) v4(116.01,176.11) v4(116.01,175.19) v4(116.01,174.3) v4(185.02,184) v4(185.53,182.99) v4(186.16,184) v4(186.67,182.99) v4(187.31,184) v4(187.81,182.99) v4(231.35,96.83) v4(232.01,96.25) v4(232.9,96.12)
+AC_BAT_SYS_NVVDD: length 10.4
  TOP w0.432: 129.11,166.25 129.27,166.1 R8710.1
  TOP w0.508: 124.29,173.44 125.51,172.22 125.51,169.86 129.11,166.25
  vias: v1(143.97,177.15) v4(121.55,177.55) v4(121.55,176.66) v4(121.57,175.8) v4(121.57,174.91) v4(121.57,174.02) v4(122.51,177.55) v4(122.51,176.66) v4(122.54,175.8) v4(122.54,174.91) v4(122.54,174.02) v4(123.48,177.55) v4(123.48,176.66) v4(123.5,175.8) v4(123.5,174.91) v4(123.5,174.02) v4(142.47,186.24) v4(143.24,186.67) v4(143.24,185.78) v4(152.79,185.81) v4(152.99,186.7) v4(153.63,186.09) v4(165.21,186.67) v4(165.21,185.78) v4(165.51,187.48) v4(176.84,187.46) v4(176.79,186.57) v4(176.79,185.68)
+AC_BAT_SYS_NVVDDS: length 10.8
  TOP w0.432: R9700.2 v2(197.99,191.88)
  IN2 w0.508: v2(197.99,191.88) 196.25,190.14 196.25,183.8 195.69,183.24 v2(195.05,183.24)
  vias: v1(121.19,169.5) v4(120.98,171.33) v4(121.01,170.44) v4(121.88,171.33) v4(121.88,170.44) v4(189.21,184.64) v4(189.72,183.75) v4(190.23,184.64) v4(190.73,183.75) v4(191.24,184.64)
+BAT: length 365.3
  TOP w0.508: D8801.2 3.52,60.43 4.53,60.43 5.11,59.85 5.7,59.85 6.2,60.36 13.14,60.36 v2(14.84,58.66)
  IN1 w0.508: v2(14.84,58.66) 14.84,54.18 25.51,43.52 25.51,41 27.11,39.4 27.11,37.25 28.46,35.9 28.46,34.37 28.25,34.17 27.78,34.17 27.34,33.73 27.34,31.67 26.64,30.97 26.64,24.66 29.12,22.18 29.5,22.18 30.33,21.34 30.33,20.15 32.54,17.94 40.98,17.94 41.74,18.7 54.58,18.7 54.86,18.42 59.96,18.42 61.27,19.73 64.86,19.73 66.85,17.74 108.26,17.74 119.79,6.2 142.74,6.2 145,8.47 145.22,8.47 150.09,13.34 150.09,14.88 150.62,15.4 159.71,15.4 160.47,14.64 162.34,14.64 163.89,16.19 205.42,16.19 208.77,19.54 208.77,20.94 209.78,21.95 212.07,21.95 212.45,21.57 212.45,21.32 212.86,20.91 213.57,20.91 214.26,21.6 214.26,22.21 215.65,23.6 224.9,23.6 v2(228.2,20.3)
  IN2 w0.508: v2(228.2,20.3) 229.22,19.29 238.82,19.29 239.81,20.28 239.81,20.66 240.43,21.28 241.93,21.28 248.95,28.3 254.44,28.3 255.5,29.37 260.51,29.37 262.54,27.34 270.8,27.34 279.38,18.75 293.25,18.75 294.75,17.25 v2(305.8,17.25)
+BAT_CON:
  vias: v4(311.64,22.71) v4(311.64,21.75) v4(311.64,20.86) v4(311.64,19.92) v4(312.53,22.71) v4(312.53,21.75) v4(312.53,20.86) v4(312.53,19.92)
+BAT_R:
  vias: v1(298.74,21.04)
+CPU_VCC_OBS_AB: length 4.2
  TOP w0.508: v1(52.91,134.75) 52.97,134.75 53.31,135.1 v2(53.74,135.1) 53.79,135.14 SR4402.2
  BOTTOM w0.279: XDP4400.44 54.01,135.95 53.74,135.68 v2(53.74,135.1)
+CPU_VCC_OBS_CD: length 5.1
  TOP w0.508: v2(59.37,135.49) 59.02,135.14 v1(57.69,135.14) SR4401.2
  BOTTOM w0.279: XDP4400.43 59.85,135.95 59.39,135.49 v2(59.37,135.49)
+FBVDDQ: length 736.5
  TOP w0.102: 178.75,76.75 178.75,76.05 ; 175.99,87.13 175.99,85.95 ; 176.48,78.85 176.19,78.85 175.95,78.61 175.95,78.24 ; 177.33,86.05 177.33,87.35 ; 179.48,78.8 179.48,78.24 ; 178.74,77.53 178.74,78.8 ; 177.35,90.63 177.35,90.15 ; 163.45,80.94 161.98,80.94 ; 175.11,78.16 174.63,78.16 ; 173.87,93.53 173.87,92.26 ; 178.77,74.68 178.03,74.68 ; 177.34,87.99 177.34,88.54
  TOP w0.254: R8909.2 251.86,87.28 251.86,87.62 v2(251.49,87.99)
  TOP w0.279: v5(176.94,138.9) 176.94,138.97 176.79,139.11 C7708.1
  TOP w0.3: v5(176.16,129.66) v5(176.16,130.46)
  TOP w0.305: C7739.1 188.05,129.75 187.88,129.92 v5(187.55,129.92) ; 194.73,119.58 195.31,119 v5(195.46,119)
  TOP w0.381: C7638.1 160.58,141.78 v5(161.08,141.27) ; 195.2,111.46 C7765.1 ; C7650.1 152.85,139.27 v5(152.6,139.02)
  TOP w0.404: v5(177.55,127.8) 177.73,127.62 177.73,126.35 177.96,126.12 C7709.1 ; C7610.1 163.27,141.41 v5(163.4,141.28)
  TOP w0.432: v5(205.98,98.76) 205.98,99.25 C7820.1 ; v5(146.02,135.35) 146.28,135.62 C7642.1 ; v5(148.22,138.28) 148.11,138.17 C7644.1 ; C7719.1 180.57,129.06 180.41,129.22 180.28,129.22 v5(180.27,129.23) ; v5(164.96,138.31) 165.06,138.41 C7632.1 ; C7746.1 199.04,117.9 v5(199.08,117.94) ; C7830.1 197.8,105.53 v5(197.99,105.33) ; v5(198.24,122) 197.72,122.52 C7758.1 ; v5(195.81,120.56) 195.81,120.6 195.48,120.93 194.41,120.93 194.08,120.61 C7750.1 ; v5(204.72,101.24) 204.61,101.13 C7814.1 ; C7752.1 198.28,109.94 v2(198.33,109.99) ; v5(196.48,117.94) 196.4,117.85 C7748.1 ; v5(204.8,114.89) 204.8,115.39 C7745.1 ; v5(195.71,105.47) 195.87,105.62 C7824.1 ; C7744.1 203.54,117.19 v5(203.63,117.29) ; C7619.1 171.63,136.13 v5(171.62,136.13) ; v5(195.84,122) 195.97,122.13 C7741.1 ; v5(168.17,136.98) 168.17,136.99 168.17,136.99 168.17,137 168.05,137.12 C7633.1 ; C7630.1 164.31,131.1 164.28,131.13 v5(164.27,131.13) ; C7743.1 205.05,114.15 v5(204.93,114.04) ; v5(141.46,129.97) 141.18,129.7 C7656.1 ; C7857.1 208.31,121.42 v5(208.25,121.36) ; v5(145.62,131.78) 145.63,131.78 145.81,131.6 C7655.1 ; v5(182.85,136.36) 182.75,136.25 C7718.1 ; C7742.1 206.1,117.15 v5(206.24,117.29) ; C7713.1 180.42,131.68 v5(180.27,131.83) ; v5(180.37,137.12) 180.34,137.14 C7717.1 179.69,137.61 v5(179.62,137.68) ; C7631.1 167.47,128.48 v5(167.52,128.53) ; C7622.1 160.29,127.04 v5(160.35,126.97) ; v5(199.48,101.36) 199.48,101.35 199.5,101.33 C7818.1 ; v5(167.22,135.39) 167.27,135.35 C7629.1 ; C7724.1 176.1,129.72 v5(176.16,129.66) ; v5(202.08,103.31) 202.21,103.44 C7819.1 ; v5(180.4,135.34) 180.69,135.06 C7716.1 ; C7759.1 196.4,114.77 v5(196.48,114.69) ; C7720.1 183.47,129.93 v5(183.52,129.88) ; C7648.1 146.09,129.18 v5(145.62,129.18) ; C7616.1 164.4,129.95 164.28,129.83 v5(164.28,129.83) ; C7753.1 205.14,110.26 v2(205.17,110.29) ; C7826.1 199.65,105.5 v5(199.69,105.45) ; C7747.1 201.1,114.1 v5(201.03,114.04) ; C7646.1 148.81,131.07 v5(148.87,131.13) ; R7501.2 169.42,103.73 ; C7816.1 196.88,101.35 v5(196.88,101.36) ; v5(176.12,136.55) 176.08,136.51 175.39,136.51 ; v5(164.92,135.68) 165.04,135.57 C7627.1 ; v5(182.87,138.33) 182.75,138.21 C7715.1 ; v5(183.52,131.18) 183.47,131.12 C7721.1 ; C7625.1 171.64,136.91 v5(171.62,136.93) ; v5(148.2,136.31) 148.14,136.25 C7643.1 ; C7645.1 148.74,128.43 148.84,128.53 v5(148.87,128.53) ; v2(204.37,110.29) 204.27,110.19 C7755.1
  TOP w0.508: v5(160.44,141.03) 160.84,141.03 v5(161.08,141.27) ; C7707.1 196.4,109.66 v2(196.73,109.99) ; v2(199.44,110.01) 199.37,109.94 C7754.1 ; C7637.1 141.37,138.81 v5(141.47,138.9) ; C7615.1 160.19,138.76 v5(160.35,138.6) ; 194.73,119.58 C7722.1 ; v5(209.49,118.51) 209.51,118.5 C7723.1 ; 188.73,139.17 188.73,139.18 C7734.1 187.26,139.18 v5(187.15,139.07) ; C7664.1 151.37,127.55 v5(151.66,127.84) ; v5(187.18,137.48) 187.28,137.58 C7728.1 ; v5(152.68,129.41) 152.72,129.38 C7608.1 ; v5(163.22,127.28) 163.46,127.28 163.88,126.86 C7606.1 ; C7609.1 170.5,141.66 v5(170.23,141.38) ; v5(171.62,138.53) 172.02,138.93 C7605.1 ; v5(207.35,105.42) 207.35,106.03 C7810.1 207.99,106.35 v5(207.99,105.48) ; v5(152.6,137.43) 152.61,137.45 C7639.1 ; v5(141.5,132.15) 141.14,132.51 C7636.1 ; C7738.1 175.43,132.04 v5(176.18,132.04) ; v5(161.66,127.89) 161.47,127.89 161.17,127.59 161.17,126.83 161.93,126.06 C7612.1 ; v5(181.45,141.2) 181.95,141.7 C7740.1 ; v5(176.16,128.06) 175.35,128.06 C7712.1
  IN1 w0.18: v5(151.64,131.94) 151.24,132.35 151.24,132.62 151.02,132.83 150.48,132.83 150.17,132.52 150.17,132.43 v5(150.17,132.43)
  IN1 w0.3: v5(170.9,138.68) 170.52,138.68 v5(170.12,138.28) ; v5(161.6,134.45) 161.62,134.43 161.62,133.09 v5(161.62,133.08) ; v5(202.42,120.61) 202.39,120.61 202.35,120.56 201.12,120.56 v5(201.02,120.56) ; v5(170.12,134.38) 170.71,134.38 v5(170.88,134.55) ; v5(184.82,134.43) v5(185.47,133.78) v5(186.23,133.78) 186.54,133.78 186.75,133.99 v5(186.75,134.37) ; v5(164.27,137.63) v5(164.96,138.31) ; v5(204.28,120.54) v5(204.93,120.54)
  IN2 w0.254: v2(218.55,81.54) 218.55,81.52 219.49,80.58 235.52,80.58 236.33,81.39 239.12,81.39 240.16,82.43 240.16,83.69 241.72,85.25 243.15,85.25 246.63,88.73 250.98,88.73 251.49,88.22 v2(251.49,87.99)
  IN3 w0.102: 157.66,79.23 157.66,82.18 157.83,82.35 158.34,82.35
  IN4 w0.3: v5(142.23,137.34) 141.47,136.58 v5(141.47,136.5) 141.47,136.38 141.77,136.08 v5(142.23,136.08) ; v5(161.67,131.78) v5(162.32,132.43) v5(162.32,133.08) ; v5(186.16,127.89) 185.51,127.89 v5(185.48,127.92) ; v5(150.82,133.73) v5(150.17,134.38) ; v5(142.31,138.85) 141.52,138.85 v5(141.47,138.9)
  BOTTOM w0.102: U7701.E2 178.32,130.53 v5(178.97,130.53) ; U7601.L14 151.06,134.79 150.58,134.79 U7601.L13 ; v5(144.32,130.48) 143.67,130.48 U7601.E2
  BOTTOM w0.2: U7601.A11 149.26,128.14 149.26,127.56 v5(149.1,127.4) ; U7601.C13 150.58,129.59 151.06,129.59 U7601.C14 ; U7700.L14 v5(201.03,119.89) ; v5(178.97,130.53) U7701.E4 ; v5(200.78,84.83) 200.79,84.85 U7800.L14
  BOTTOM w0.249: v5(176.92,47.45) 177.15,47.68 177.15,47.76 U7901.W13
  BOTTOM w0.25: v5(167.21,139.66) 167.45,139.66 U7600.B5 ; U7701.B10 v5(183.52,128.58) U7701.A11 ; U7701.N1 v5(177.67,136.38) 178,136.05 U7701.N2 177.67,135.73 v5(177.67,135.73) ; U7701.N1 v5(177.67,135.73) ; U7701.N1 177.27,136.13 v5(176.89,136.13) 176.55,136.13 v5(176.12,136.55) ; U7800.R2 198.5,77.36 v5(198.83,77.03) U7800.R1 v5(198.16,76.37) ; U7700.G1 203.96,111.36 v5(203.91,111.31) ; v5(161.66,127.89) 161.97,128.2 U7600.W14 v5(162.34,127.87) 162.34,127.89 U7600.W13 ; v5(170.91,135.96) 171.45,135.96 v5(171.62,136.13) ; U7700.J2 v5(202.33,112.09) 202.34,112.08 U7700.J1 202.51,111.61 v5(202.51,111.31) ; v5(179.57,48.22) 179.56,48.22 U7901.V10 ; U7701.C2 v5(177.67,129.23) U7701.C1 ; v5(208.03,78.85) 207.84,78.66 U7800.A4 ; U7701.B5 180.27,129.23 v5(180.27,129.23) ; U7900.L13 165.33,54.72 v5(165.33,54.72) U7900.L14 v5(165.98,54.72) ; U7701.A2 178,128.25 v5(177.55,127.8) 177.55,128.05 U7701.A1 177.02,127.93 v5(176.97,127.93) 176.84,128.06 v5(176.16,128.06) ; U7700.R2 v5(199.08,112.09) 198.76,111.76 U7700.R1 198.42,111.43 v5(198.42,111.15) ; U7600.H3 v5(169.47,135.68) U7600.G2 ; v5(199.69,105.45) 199.8,105.34 v5(199.8,104.75) U7801.G1 v5(200.13,103.96) U7801.G2 ; U7800.M5 v5(200.78,78.98) ; U7601.G14 151.48,132.1 v5(151.64,131.94) ; U7801.V5 207.28,101.36 v5(207.28,101.36) ; v5(184.11,53.42) U7901.L2 U7901.L1 v5(185.55,53.1) ; v5(172.8,95.35) 172.85,95.35 U7000.K29 ; v5(163.38,47.5) 163.71,47.82 U7900.A11 ; U7600.J2 170.12,134.38 v5(170.12,134.38) 170.45,134.7 U7600.J1 170.6,134.55 v5(170.88,134.55) ; v5(159.32,47.3) 159.15,47.46 U7900.A4 ; v5(161.08,141.27) 160.68,141.27 v5(160.44,141.03) ; U7600.M5 v5(168.17,133.08) ; U7601.R1 143.02,137.63 v5(143.02,137.63) U7601.R2 ; U7601.R1 142.7,137.3 ; U7601.R1 142.26,137.3 v5(142.23,137.34) ; v5(148.11,132.6) 148.27,132.75 U7601.H10 ; v5(176.94,138.9) 177.1,138.9 U7701.U1 v5(177.67,138.98) 178,138.65 U7701.U2 ; U7900.W2 157.85,59.71 v5(157.51,60.05) 157.2,59.75 U7900.W1 156.85,59.95 v5(156.48,59.95) ; U7801.C13 197.35,96.33 197.35,95.98 U7801.C14 197.15,95.78 v5(197.15,95.38) ; v5(196.88,104.61) 196.88,104.98 197.22,105.33 v5(197.99,105.33) 197.99,105.19 v5(198.35,104.84) 198.35,104.43 U7801.E1 v5(198.18,103.96) U7801.E2 ; U7601.A1 142.65,128.2 142.32,127.88 v5(142.25,127.88) ; U7801.F10 v5(198.83,98.11) 198.83,98.11 U7801.E11 ; U7801.C2 v5(196.88,103.96) U7801.C1 ; U7701.E13 185.34,130.66 185.61,130.66 U7701.E14 186.2,130.85 v5(186.27,130.85) ; R7103.2 185.22,125.56 186.42,126.75 186.42,127.63 v5(186.16,127.89) U7701.A14 185.48,127.93 v5(185.48,127.92) 185.15,128.25 U7701.A13 ; 195.83,112.09 196.16,111.76 U7700.W1 v5(195.81,111.41) ; 195.83,112.09 v5(195.83,112.09) ; 195.83,112.09 U7700.W2 ; U7900.M10 163.05,55.05 162.67,55.05 v5(162.6,55.11) ; U7800.E11 v5(205.33,82.88) U7800.D10 v5(206.01,82.2) ; U7800.L13 201.1,84.53 200.81,84.83 v5(200.78,84.83) ; U7701.P10 183.2,136.7 v5(182.85,136.36) 182.82,136.32 v5(182.82,135.73) 183.15,135.4 U7701.M10 ; U7700.L14 201.02,120.55 v5(201.02,120.56) ; U7901.H12 177.61,55.37 v5(177.61,55.37) U7901.G13 ; U7901.J14 176.78,54.25 176.78,54.25 v5(176.96,54.07) U7901.J13 ; v5(156.77,53.25) 157.05,53.25 U7900.J1 v5(157.53,53.42) U7900.J2 ; v5(161.67,136.33) 161.85,136.15 161.85,136.15 U7600.G14 162,136 162.32,136.33 ; v5(199.64,95.39) 199.69,95.39 199.8,95.51 U7801.G14 ; U7800.W2 v5(195.58,77.03) U7800.W1 v5(195.54,76.34) ; 169.8,132.11 v5(169.47,132.43) U7600.M3 ; U7600.A2 v5(169.8,140.42) 170.43,140.42 v5(170.45,140.4) ; U7700.E2 v5(204.93,112.09) U7700.E1 205.26,111.31 v5(205.23,111.28) ; U7000.L15 172.5,85.85 v5(172.85,86.2) 173.15,85.9 U7000.K15 ; v5(186.75,134.37) 186.75,134.39 186.38,134.75 185.8,134.75 U7701.L14 ; v5(207.97,102.71) 207.97,102.7 U7801.W4 ; U7600.V10 164.28,128.53 v5(164.28,128.53) ; U7901.R11 v5(178.91,50.17) U7901.T10 v5(179.56,49.52) ; v5(152.47,141.56) v5(151.61,141.56) 151.61,140.36 v5(151.59,140.34) ; v5(186.51,137.48) 185.93,137.48 U7701.R14 v5(185.47,137.68) U7701.R13 v5(184.82,137.68) ; v5(141.46,129.97) 141.94,130.45 v5(142.34,130.45) U7601.E1 143.02,130.48 ; U7900.G13 v5(165.33,51.47) ; U7700.E11 v5(205.58,117.94) U7700.D10 v5(206.24,117.29) ; U7900.E11 v5(163.38,50.17) U7900.D10 v5(162.7,49.49) ; 162.32,136.33 U7600.G13 162.65,136 162.97,135.68 v5(162.97,135.68) 162.98,135.68 U7600.H12 ; 162.32,136.33 v5(162.32,136.33) ; U7901.N1 184.76,52.12 v5(184.76,52.12) 184.44,51.8 U7901.N2 v5(184.76,51.47) U7901.N1 ; U7901.N1 185.47,51.8 v5(185.55,51.72) ; U7801.J14 v5(201.43,96.16) U7801.J13 ; U7701.W11 183.7,140.1 v5(183.7,140.44) ; U7801.W13 207.91,96.18 v5(208.05,96.18) ; v5(206.36,85.62) 206.36,85.21 U7800.C14 ; U7901.V5 182.49,48.52 v5(182.08,48.11) ; v5(201.43,77.68) U7800.L2 U7800.L1 201.1,76.24 201.13,76.21 201.13,76.21 v5(201.14,76.2) ; v5(199.48,85.48) U7800.N14 v5(200.13,84.83) U7800.N13 v5(200.13,84.18) U7800.M12 ; v5(149.16,140.42) 149.2,140.38 U7601.W11 ; v5(142.22,134.68) 142.25,134.7 U7601.L1 U7601.L2 143.67,134.38 v5(143.67,134.38) ; v5(156.74,50.52) 156.76,50.5 U7900.E1 ; U7601.U13 150.5,138.61 v5(150.82,138.93) 151.14,138.61 U7601.U14 ; v5(162.71,48.22) 162.73,48.22 163.05,48.55 U7900.B10 ; v5(141.47,136.5) 141.89,136.08 v5(142.23,136.08) 142.62,136.08 U7601.N1 ; U7601.P5 U7601.R4 v5(144.97,137.63) ; U7900.C2 157.85,49.2 v5(157.53,49.52) 157.53,49.52 U7900.C1 157.13,49.12 v5(156.72,49.12) ; U7700.B5 207.21,115.52 v5(207.41,115.72) ; v5(203.38,97.46) 203.05,97.13 U7801.M12 ; U7701.C13 185.3,129.7 185.65,129.7 U7701.C14 185.85,129.5 v5(186.29,129.5) ; v5(176.87,137.39) 176.91,137.35 U7701.R1 177.66,137.66 177.66,137.67 v5(177.67,137.68) 177.68,137.66 177.69,137.66 178,137.35 U7701.R2 ; v5(170.8,131.8) 170.5,132.1 U7600.N1 170.45,132.11 v5(170.12,132.43) ; U7700.R13 198.67,119.65 198.67,119.67 198.63,119.7 198.63,120.07 198.67,120.11 198.67,120.12 U7700.R14 ; v5(196.23,98.11) U7801.A11 ; U7801.A1 v5(195.58,104.61) ; v5(195.58,104.61) 195.71,104.74 v5(195.71,105.47) ; v5(195.58,104.61) 195.28,104.31 v5(195.28,104.12) 195.37,104.03 195.5,104.03 U7801.A2 ; v5(168.21,127.82) 168.21,127.87 168.21,127.92 U7600.W4 ; U7900.U13 v5(165.33,57.97) 165.65,58.3 U7900.U14 165.69,58.3 v5(166.03,58.63) ; v5(144.93,140.43) 144.93,140.18 U7601.W4 ; 143.02,130.48 U7601.E2 ; 143.02,130.48 v5(143.02,130.48) ; v5(158.18,50.82) U7900.E2 ; 172.55,96.4 172.5,96.35 U7000.L30 ; 172.55,96.4 v5(172.82,96.67) 173.14,96.35 U7000.K30 ; 172.55,96.4 172.55,96.39 ; U7800.B5 v5(207.28,79.63) ; U7900.H10 163.05,52.45 v5(162.73,52.12) ; U7800.J14 202.25,85.31 v5(202.25,85.72) ; U7801.L1 v5(202.4,104.77) ; v5(183.52,129.88) U7701.D10 ; U7801.W11 v5(207.93,98.11) ; v5(160.13,59.27) U7900.V5 ; v5(172.82,89.02) 172.84,89.04 ; 172.84,89.04 U7000.K20 ; 172.84,89.04 172.84,89.06 172.55,89.35 U7000.L20 ; v5(176.92,133.27) 177.17,133.27 177.17,133.27 U7701.J1 177.67,133.13 v5(177.67,133.13) 177.68,133.13 U7701.J2 ; U7601.E11 v5(148.87,131.13) U7601.F10 ; v5(208.38,112.41) U7700.A2 ; U7800.V5 v5(196.23,79.63) ; v5(165.04,132.64) 164.93,132.75 U7600.M10 ; U7700.H5 203.31,114.8 v5(203.43,114.92) 203.43,115.1 204.13,115.8 ; U7901.W4 183.14,47.14 v5(183.11,47.12) ; v5(148.22,138.28) U7601.T10 v5(148.87,137.63) U7601.R11 ; U7901.C13 177.14,58.15 176.78,58.15 U7901.C14 176.58,58.35 v5(176.18,58.35) ; v5(200.64,117.15) 200.71,117.22 U7700.M10 ; U7801.V10 207.28,98.76 v5(207.28,98.77) ; U7901.U13 176.97,48.88 176.97,48.88 v5(176.96,48.87) 176.96,48.88 176.95,48.88 U7901.U14 ; v5(161.62,133.08) 161.68,133.08 U7600.L14 v5(162.32,133.08) 162.65,133.4 U7600.L13 ; U7601.C14 151.2,129.45 v5(151.66,129.45) 152.65,129.45 v5(152.68,129.41) ; U7900.H3 v5(158.18,52.12) 157.86,51.8 U7900.G2 ; U7901.W14 v5(176.18,47.44) ; v5(170.8,129.15) U7600.U1 170.12,129.18 v5(170.12,129.18) U7600.U2 ; U7901.W2 v5(184.76,47.57) 184.76,47.57 ; U7700.E14 205.26,120.21 v5(204.93,120.54) ; v5(158.18,54.07) 157.86,54.4 U7900.L2 157.21,54.4 U7900.L1 ; v5(185.51,54.58) 185.26,54.58 185.09,54.4 U7901.J1 v5(184.76,54.72) 184.76,54.72 U7901.J2 ; U7700.U2 v5(197.13,112.09) U7700.U1 ; v5(144.97,127.88) 144.97,127.88 U7601.A4 ; U7701.J14 v5(185.47,133.78) U7701.J13 ; v5(185.44,48.87) 185.11,49.2 U7901.U1 v5(184.76,48.87) U7901.U2 ; U7700.W12 195.55,118.91 v5(195.46,119) 194.81,119.65 R7102.2 ; U7900.A1 v5(157.2,47.42) ; U7600.W12 163.3,127.36 v5(163.22,127.28) ; v5(206.51,75.6) 206.38,75.73 v5(206.38,76.17) 206.3,76.24 U7800.C1 v5(205.98,77.03) U7800.C2 ; U7901.E2 184.76,57.32 U7901.E1 v5(185.44,57.35) ; U7700.H10 v5(203.63,117.29) 203.96,116.96 ; v5(205.2,94.36) 205.2,94.99 v5(205.23,95.01) 205.3,95.09 205.3,95.53 U7801.R14 v5(204.68,96.16) 204.68,96.16 U7801.R13 ; 175.86,61.46 175.86,60.37 v5(176.27,59.96) U7901.A14 176.96,59.92 v5(176.96,60.04) 177.29,59.71 U7901.A13 ; U7901.M5 182.47,52.43 v5(181.92,52.43) ; v5(170.45,140.4) U7600.A1 ; v5(170.45,140.4) 170.45,141.16 v5(170.23,141.38) ; U7800.W13 v5(195.58,84.83) 195.6,84.86 U7800.W14 v5(195.57,85.49) ; v5(152.61,134.37) 152.27,134.71 151.16,134.71 U7601.L14 ; U7600.U13 v5(162.32,129.83) 162,129.5 U7600.U14 161.67,129.18 v5(161.64,129.18) ; U7800.F10 v5(204.68,82.23) ; U7701.M12 v5(184.17,135.73) ; v5(177.67,135.73) 177.68,135.74 ; v5(164.93,139.58) U7600.B10 v5(164.27,139.58) 163.95,139.9 U7600.A11 ; U7601.J13 v5(150.82,133.73) ; v5(208.46,113.88) 208.29,113.71 U7700.A4 ; U7800.J13 v5(202.08,84.18) ; U7900.R2 v5(157.53,56.67) U7900.R1 156.85,57.35 v5(156.48,57.35) ; U7901.E13 177.04,57.24 176.88,57.24 U7901.E14 176.62,56.98 v5(176.16,56.98) ; v5(195.81,120.56) U7700.W14 v5(195.83,119.89) U7700.W13 ; v5(164.92,135.68) U7600.H10 ; U7701.R4 U7701.P5 180.36,137.12 v5(180.37,137.12) ; v5(166.12,49.2) U7900.C14 165.65,49.2 ; v5(203.38,96.16) U7801.N13 ; v5(170.9,138.68) 170.52,138.68 U7600.C1 170.45,138.6 v5(170.12,138.28) 169.8,138.6 U7600.C2 ; U7800.J2 v5(202.08,77.03) 202.08,77.03 U7800.J1 202.25,76.56 v5(202.25,76.27) ; v5(166.03,59.93) 165.69,59.6 U7900.W14 165.65,59.6 165.33,59.92 v5(165.33,59.93) 165.01,59.6 U7900.W13 ; U7801.R11 v5(205.33,98.11) U7801.T10 v5(205.98,98.76) ; U7700.W4 195.96,113.71 v5(195.75,113.93) ; v5(164.92,136.98) U7600.F10 ; v5(142.32,133.08) 142.37,133.08 U7601.J1 143.02,133.08 v5(143.02,133.08) 143.34,133.4 U7601.J2 ; v5(203.65,76.25) 203.7,76.3 U7800.G1 v5(203.38,77.03) U7800.G2 v5(203.38,77.68) U7800.H3 ; v5(167.52,128.53) 167.85,128.85 U7600.V5 ; U7000.K24 v5(172.82,92.48) 172.5,92.15 U7000.L24 ; U7600.R2 v5(170.12,131.13) U7600.R1 v5(170.77,130.48) ; U7801.M3 v5(203.38,102.66) ; U7700.B10 v5(207.53,117.29) ; U7601.N1 v5(143.02,136.33) ; U7601.N1 142.7,136 143.02,135.68 v5(143.02,135.68) 143.02,135.68 U7601.N2 ; v5(178.97,132.48) U7701.H3 ; U7800.A11 207.93,82.89 v5(207.96,82.89) ; v5(198.18,85.48) U7800.R14 198.41,85.07 198.41,85.05 198.38,85.02 198.38,84.65 198.41,84.61 198.41,84.6 U7800.R13 ; v5(177,140.3) U7701.W1 177.7,140.3 v5(177.7,140.32) ; U7701.F10 v5(183.52,131.18) U7701.E11 ; U7600.W2 170.1,127.9 v5(170.1,127.86) 170.1,127.86 U7600.W1 v5(170.8,127.85) ; v5(186.25,140.4) 186.25,140.23 185.98,139.95 U7701.W14 185.8,140.12 v5(185.52,140.4) 185.15,140.03 U7701.W13 ; v5(204.28,120.54) U7700.G14 v5(204.28,119.89) U7700.G13 203.63,119.24 v5(203.63,119.24) 203.31,118.91 U7700.H12 ; U7900.A2 157.85,47.43 v5(157.84,47.41) ; v5(177.61,53.42) U7901.L13 ; v5(206.63,111.31) 206.56,111.39 U7700.C1 206.55,111.76 v5(206.23,112.08) 206.56,112.41 U7700.C2 ; v5(200.84,104.69) 200.84,104.64 200.84,104.54 U7801.J1 201.1,104.28 v5(200.78,103.96) U7801.J2 ; U7901.F10 v5(178.91,56.67) U7901.E11 ; v5(170.12,135.68) U7600.G1 ; U7901.G14 176.45,55.88 v5(176.2,55.88) ; v5(183.46,55.37) U7901.H3 ; U7601.M5 v5(146.02,135.35) ; v5(196.87,76.37) U7800.U1 197.53,77.03 v5(197.53,77.03) U7800.U2 ; v5(170.96,133.44) 170.94,133.43 170.8,133.43 170.77,133.4 U7600.L1 U7600.L2 v5(169.48,133.73) ; U7901.M10 179.56,52.12 v5(179.58,52.12) 179.61,52.09 179.61,51.52 v5(179.58,51.49) 179.24,51.15 U7901.P10 ; U7901.H10 179.5,55.05 v5(179.66,55.21) ; v5(186.56,139.03) 186.18,139.03 U7701.U14 185.79,138.65 185.47,138.97 ; v5(150.17,134.38) 150.49,134.7 U7601.L13 ; U7800.R4 v5(198.83,78.98) U7800.P5 ; v5(202.02,94.67) 202.42,95.07 202.42,95.82 U7801.L14 ; v5(200.29,98.86) 200.45,98.7 U7801.H10 ; U7800.U13 v5(197.53,84.83) 197.49,84.88 U7800.U14 196.88,85.48 v5(196.88,85.53) ; v5(182.81,59.92) U7901.A4 ; v5(178.91,57.97) U7901.D10 ; v5(206.88,120.54) 206.88,120.54 U7700.C14 ; U7700.T10 198.11,117.61 197.79,117.93 v5(197.79,117.94) ; v5(141.5,132.15) 142.08,132.15 142.1,132.17 v5(142.12,132.17) 142.19,132.1 U7601.G1 v5(143.02,132.43) U7601.G2 ; v5(151.66,127.84) 151.59,127.84 151.22,128.2 U7601.A14 v5(150.81,127.87) 150.81,127.89 U7601.A13 ; U7601.P10 148.54,136.65 v5(148.2,136.31) 148.05,136.15 148.05,135.85 v5(148.2,135.7) U7601.M10 ; v5(207.93,76.38) U7800.A1 207.91,77.01 v5(207.96,77.01) 207.61,77.36 U7800.A2 ; U7800.W4 195.71,78.66 v5(195.49,78.87) ; U7700.A11 208.18,117.94 v5(208.21,117.94) ; v5(204.93,117.29) U7700.F10 ; v5(197.14,120.61) 197.14,120.53 U7700.U14 197.78,119.89 ; v5(143.67,129.18) 143.67,129.18 U7601.C2 ; U7801.W2 v5(207.93,103.96) 207.61,104.28 U7801.W1 ; v5(202.08,103.31) 202.08,103.31 U7801.L2 ; U7801.A13 v5(195.58,96.16) 195.58,96.15 U7801.A14 v5(195.54,95.47) ; v5(186.25,131.96) 186.05,132.15 U7701.G14 ; U7600.E14 161.83,137.13 v5(161.56,137.13) ; U7901.C1 v5(184.76,58.62) U7901.C2 ; v5(151.59,140.34) v5(150.85,140.34) 150.85,140.24 150.52,139.9 U7601.W13 ; v5(151.59,140.34) 151.15,139.9 U7601.W14 ; U7700.A1 v5(208.36,111.76) ; U7801.E4 v5(198.83,102.01) U7801.F5 199.15,101.68 v5(199.48,101.36) ; v5(161.67,131.78) U7600.N14 v5(162.32,132.43) U7600.N13 162.65,132.1 v5(162.97,132.43) U7600.M12 ; U7701.G13 v5(184.82,132.48) U7701.H12 ; v5(195.57,102) U7801.A4 ; U7901.E4 182.81,56.67 v5(182.81,56.67) 182.81,56.67 U7901.F5 v5(182.16,56.02) ; U7701.V5 v5(180.28,139.63) ; v5(176.87,134.75) U7701.L1 ; 197.78,119.89 v5(197.79,119.89) ; 197.78,119.89 U7700.U13 ; v5(178.97,135.73) U7701.M3 ; U7900.F10 163.05,51.15 v5(162.73,50.82) ; U7801.U2 v5(206.63,103.96) 206.63,103.96 U7801.U1 206.54,104.52 206.54,104.59 206.55,104.59 v5(206.55,104.7) ; U7800.E2 205,77.36 v5(204.68,77.03) U7800.E1 204.98,76.68 v5(204.98,76.22) v5(204.98,75.6) ; v5(208.86,95.61) 208.77,95.53 v5(208.05,95.53) 207.91,95.53 U7801.W14 ; v5(164.68,53.42) U7900.J13 ; U7601.D10 v5(148.87,129.83) ; v5(163.38,57.97) 163.38,57.97 U7900.T10 ; v5(196.88,101.36) 196.88,101.36 196.84,101.4 196.84,101.4 196.55,101.68 U7801.B5 ; U7601.A11 148.87,128.53 v5(148.87,128.53) 148.87,128.53 U7601.B10 ; U7801.R2 v5(205.33,103.96) U7801.R1 v5(205,104.75) ; U7801.E13 v5(198.18,96.16) U7801.E14 198.53,95.81 v5(198.53,95.38) ; U7601.E13 v5(150.82,130.48) U7601.E14 151.63,130.8 v5(151.66,130.83) ; v5(178.91,59.27) U7901.A11 178.59,60.33 v5(178.63,60.38) ; v5(200.13,102.66) U7801.H3 ; v5(179.62,127.93) U7701.A4 ; U7901.W11 178.59,47.77 v5(178.9,47.46) ; v5(177,130.5) U7701.E1 v5(177.67,130.53) U7701.E2 ; v5(207.28,82.23) U7800.B10 ; v5(159.48,54.72) U7900.M5 ; U7700.M5 201,114.07 201,114.07 v5(201.03,114.04) ; U7900.M12 164.5,55.19 v5(164.68,55.37) 165,55.7 U7900.N13 v5(165.33,55.37) 165.65,55.7 U7900.N14 v5(165.98,56.02) ; v5(202.42,120.61) 202.42,120.45 U7700.J14 ; v5(204.03,85.48) U7800.G14 v5(204.03,84.83) U7800.G13 203.7,84.51 v5(203.38,84.18) 203.05,83.86 U7800.H12 ; U7701.G2 177.99,132.15 v5(177.67,132.47) 177.67,132.47 U7701.G1 v5(177.02,131.83) ; v5(161.6,134.45) 161.75,134.45 U7600.J14 ; v5(178.32,134.43) U7701.L2 ; U7700.V5 v5(196.48,114.69) ; U7801.U13 v5(206.63,96.16) U7801.U14 ; U7600.E11 v5(164.27,137.63) U7600.D10 v5(164.96,138.31) ; U7601.R13 150.61,137.42 151.03,137.42 U7601.R14 ; v5(200.38,112.74) U7700.M3 ; U7801.N1 203.7,104.67 v5(203.78,104.75) ; U7801.N1 v5(203.38,103.96) 203.38,103.96 U7801.N2 v5(204.03,103.96) U7801.N1 ; v5(199.73,120.54) U7700.N14 v5(200.38,119.89) U7700.N13 v5(200.38,119.24) U7700.M12 ; v5(208.22,120.57) U7700.A14 208.15,119.92 v5(208.22,119.92) U7700.A13 ; v5(171.62,136.93) 171.27,137.28 v5(171.18,137.28) 170.63,137.28 170.61,137.3 U7600.E1 170.12,136.98 v5(170.12,136.98) U7600.E2 ; U7900.B5 160.16,48.19 v5(160.44,48.19) ; U7000.L21 172.55,90.05 172.82,90.32 v5(172.82,90.38) U7000.K21 ; v5(180.27,131.83) U7701.F5 ; v5(175.7,53.37) 176,53.07 176.61,53.07 U7901.L14 ; v5(162.97,134.38) 162.65,134.7 U7600.J13 ; v5(182.77,132.64) 182.94,132.8 U7701.H10 ; v5(185.56,50.5) U7901.R1 v5(184.76,50.17) U7901.R2 ; v5(195.43,83.91) 195.48,83.86 U7800.W12 ; U7600.T10 164.6,130.15 v5(164.28,129.83) ; U7800.H5 203.05,79.53 v5(203.31,79.79) ; U7000.K35 172.85,99.55 v5(172.8,99.55) 172.75,99.55 U7000.L35 ; U7600.R4 v5(168.17,131.13) U7600.P5 ; U7801.M10 203.05,98.79 v5(203.18,98.92) 203.28,99.02 v5(203.86,99.02) 203.86,98.92 U7801.P10 ; U7901.A2 184.68,59.84 v5(184.68,60.27) 185.16,60.27 v5(185.51,59.92) 185.41,59.92 U7901.A1 ; v5(179.32,140.73) 179.32,139.98 U7701.W4 ; U7900.W12 164.35,59.6 164.35,60.21 v5(164.44,60.3) ; U7701.V10 v5(182.87,139.63) ; 185.47,138.97 U7701.U13 ; 185.47,138.97 v5(185.47,138.98) ; U7600.A4 168.5,140.4 v5(168.32,140.57) ; v5(201.03,119.89) U7700.L13 ; v5(201.36,111.14) U7700.L1 U7700.L2 v5(201.68,112.74) ; U7900.J14 165.91,53.35 v5(166.17,53.35) ; v5(144.32,132.43) U7601.H3 ; U7601.V10 v5(148.22,139.58) ; v5(186.3,55.61) 186.03,55.89 185.28,55.89 U7901.G1 v5(184.76,55.37) U7901.G2 ; U7801.L13 v5(202.08,96.81) ; v5(182.87,138.33) U7701.T10 v5(183.52,137.68) U7701.R11 ; v5(182.16,58.62) U7901.B5 ; v5(176.96,50.17) U7901.R13 ; U7900.U2 157.53,58.62 v5(157.53,58.62) U7900.U1 156.88,58.62 v5(156.51,58.62) ; U7801.D10 v5(197.53,98.11) ; v5(204.68,85.48) U7800.E14 ; v5(200.78,85.49) U7800.L14
  BOTTOM w0.254: v5(203.38,82.23) 203.38,81.06 ; v5(208.11,86.1) 207.68,85.67 207.68,85.23 U7800.A14 ; v5(150.82,135.68) U7601.N14 ; U7601.W2 143.02,140.23 143.02,140.23 ; v5(143.02,136.33) U7601.N2 ; U7601.U2 143.34,138.61 v5(143.02,138.93) 142.69,138.61 U7601.U1 142.44,138.85 v5(142.31,138.85) ; v5(203.31,79.79) 204.16,80.63 ; U7900.G14 v5(165.33,51.47)
  BOTTOM w0.28: U7601.P5 v5(145.71,137.07) ; v5(167.22,135.39) 167.25,135.39 167.27,135.37 167.83,135.37 U7600.H5 ; v5(155.73,59.31) v5(155.73,58.51) ; v5(167.46,57.65) 166.64,57.65 166.33,57.34 v5(166.04,57.34) ; U7701.C1 177.13,129.33 176.49,129.33 v5(176.16,129.66) ; v5(176.31,54.07) U7901.J14 ; v5(201.43,95.51) U7801.J14 ; v5(156.74,50.52) 156.39,50.87 v5(156.03,50.87) ; v5(185.51,58.62) 185.84,58.62 v5(186.28,58.19) ; U7601.U14 151.54,139 v5(151.76,139) ; v5(155.74,56.6) 155.76,56.6 156.33,56.02 v5(156.88,56.02) ; U7601.J14 151.3,133.4 151.6,133.7 v5(151.64,133.7) ; v5(160.36,52.33) 159.92,52.33 U7900.H5 ; v5(156.58,54.4) U7900.L1 ; v5(167.46,58.45) 167.27,58.63 v5(166.03,58.63) ; U7701.J14 186.12,133.78 v5(186.23,133.78) ; U7701.L1 U7701.L2 ; 156.07,48.47 v5(156.72,49.12) 156.66,49.12 156.51,49.27 v5(156.03,49.27) 155.42,49.27 155.15,49 C7955.1 155.91,48.6 v5(156.03,48.47) 156.07,48.47
  BOTTOM w0.281: U7601.M12 v5(149.52,135.68)
  BOTTOM w0.3: v5(164.35,105.1) 164.35,105.15 U7000.AC43 ; v5(166.45,82.7) 166.45,82.65 U7000.Y10 ; U7000.AF43 162.26,105.14 v5(162.26,105.1) ; v5(146.8,141.16) v5(147.6,141.16) 147.6,140.2 v5(148.22,139.58) ; U7601.E4 v5(144.32,130.48) ; v2(205.17,110.29) 205.23,110.35 v5(205.23,111.28) ; U7000.K39 172.83,102.97 v5(172.81,102.97) ; U7000.P11 170.6,83.3 v5(170.6,83.43) ; U7900.H12 v5(164.68,52.12) ; U7000.AJ11 160.1,83.3 v5(160.1,83.45) ; v5(208.92,83.46) 208.35,82.89 v5(207.96,82.89) ; U7700.P5 199.08,114.04 v5(199.08,114.04) 199.06,114.01 U7700.R4 ; U7801.N13 v5(204.03,96.16) U7801.N14 ; U7000.AC42 164.3,104.5 v5(164.3,104.35) ; U7000.M43 171.43,105.13 v5(171.43,105.12) ; v5(204.03,95.51) U7801.N14 ; U7801.N14 v5(203.38,96.16) ; U7900.P10 v5(163.38,56.67) 163.7,57 U7900.R11 ; U7000.P42 170.6,104.5 v5(170.6,104.35) ; v5(167.3,104.35) 167.3,104.5 U7000.V42 ; U7600.F5 v5(168.17,136.98) 168.5,137.3 U7600.E4 ; U7600.F5 167.85,136.65 ; U7600.F5 167.85,136.65 ; U7800.H10 v5(203.38,82.23) ; v5(169.35,82.7) 169.35,82.65 U7000.R10 ; U7901.N14 v5(176.96,51.47) 176.96,51.47 U7901.N13 177.29,51.8 v5(176.96,52.12) 176.64,51.8 U7901.N14 ; U7901.N14 176.32,51.48 175.9,51.48 v5(175.77,51.61) ; v5(141.47,138.9) 141.52,138.85 v5(142.31,138.85) ; v5(208.22,120.57) 208.22,121.06 208.25,121.09 v5(208.25,121.36) ; v5(207.35,105.42) 207.41,105.48 v5(207.99,105.48) 207.95,105.45 v5(207.95,104.63) ; U7901.P5 U7901.R4 v5(182.81,50.17) ; U7000.AK43 158.85,105.15 v5(158.85,105.1) ; v5(150.82,135.68) U7601.N13 v5(150.82,136.33) 151,136.15 U7601.N14 v5(151.47,136.33) 151.63,136.49 v5(151.63,137.43) ; U7901.M12 177.94,52.45 v5(178.26,52.12) ; U7000.AC10 164.36,82.66 v5(164.36,82.69) ; v5(206.23,119.24) U7700.C13 ; v5(204.93,120.54) 204.82,120.65 204.4,120.65 204.28,120.54 v5(204.28,120.54) ; U7600.R13 v5(162.32,130.48) 162,130.8 U7600.R14 v5(161.67,130.48) 161.36,130.17 v5(160.35,130.17) ; v5(197.07,87.21) 197.07,85.72 v5(196.88,85.53) ; U7000.AA10 165.13,82.67 v5(165.13,82.68) ; v2(206.77,110.29) 206.63,110.42 v5(206.63,111.31) ; v5(186.29,47.38) 185.61,47.38 v5(185.44,47.55) U7901.W1 v5(184.76,47.57) ; v5(166.41,83.43) 166.41,83.31 U7000.Y11 ; 143.02,129.18 U7601.C2 ; 143.02,129.18 v5(143.02,129.18) ; 143.02,129.18 U7601.C1 ; v5(141.47,141.3) v5(141.47,140.5) 142.09,140.5 v5(142.34,140.25) U7601.W1 143.02,140.23 v5(143.02,140.31) ; U7000.AK42 158.88,104.48 v5(158.88,104.38) ; U7900.E14 v5(165.98,50.82) ; U7000.AG10 160.94,82.66 v5(160.94,82.7) ; v5(197.75,87.18) 197.87,87.06 197.87,85.79 v5(198.18,85.48) ; U7701.L13 v5(184.82,134.43) ; U7700.R14 v5(198.43,120.54) 198.24,120.73 v5(198.24,122) ; U7000.K36 172.85,100.85 v5(172.8,100.85) ; U7000.V10 167.25,82.65 v5(167.25,82.7) ; v5(206.88,120.54) 206.88,120.79 206.57,121.11 v5(206.57,121.44) ; v5(163.04,82.7) 163.04,82.66 U7000.AD10 ; v5(162.97,136.98) 162.65,137.3 U7600.E13 ; v5(162.26,82.7) 162.26,82.66 U7000.AF10 ; v5(199.66,76.08) 199.66,76.56 U7800.N1 v5(200.13,77.03) U7800.N2 v5(200.13,77.68) 200.45,78.01 U7800.M3 ; v5(187,136.94) 186.69,136.94 v5(186.12,136.37) 186.12,136.37 U7701.N14 ; v5(155.95,105.1) 155.95,105.15 U7000.AR43 ; v5(204.8,114.89) 204.8,114.55 U7700.F5 v5(204.93,114.04) U7700.E4 ; U7700.P10 v5(199.08,117.94) U7700.R11 ; v5(169.34,105.11) 169.34,105.14 U7000.R43 ; v5(177,140.3) 176.76,140.55 v5(176.18,140.55) 175.59,140.55 C7737.1 175.4,141.1 v5(177,141.1) 177.7,140.4 v5(177.7,140.32) 178,140.02 U7701.W2 ; v5(171.45,82.7) 171.45,82.65 U7000.M10 ; U7600.P10 164.27,131.13 v5(164.27,131.13) 164.27,131.13 U7600.R11 ; v5(197.53,82.88) 197.85,82.56 U7800.T10 ; U7000.K17 172.83,86.93 v5(172.83,86.92) ; U7900.E4 v5(159.48,50.82) U7900.F5 159.81,51.15 v5(160.13,50.82) ; v2(204.37,110.29) 203.91,110.75 v5(203.91,111.31) ; v5(163.1,104.35) 163.1,104.5 U7000.AD42 ; U7601.A1 v5(143.02,127.88) U7601.A2 ; 166.5,135.61 167,135.61 v5(167.22,135.39) ; v5(152.6,139.02) 151.78,139.02 v5(151.76,139) ; v5(172.07,102.9) 172.2,102.9 U7000.L39 ; U7701.N14 v5(185.47,135.73) U7701.N13 185.47,136.37 v5(185.47,136.37) 185.48,136.37 U7701.N14 ; 167.85,136.65 v5(167.06,136.65) ; U7000.V43 167.23,105.13 v5(167.23,105.11) ; v5(172.13,98.77) U7000.L33 ; v5(200.38,112.74) U7700.N2 v5(200.38,112.09) U7700.N1 v5(199.73,111.44) ; U7901.B10 178.91,59.27 v5(178.91,59.27) ; v5(197.13,111.44) U7700.U1 ; v5(166.45,105.09) 166.45,105.15 U7000.Y43 ; v5(185.52,140.4) 185.49,140.42 v5(185.49,141.56) ; U7000.U11 168.5,83.3 v5(168.5,83.44) ; v5(207.95,104.63) U7801.W1 ; v5(207.95,104.63) 208.85,104.63 v5(209.03,104.46) ; v5(186.56,139.03) 187.11,139.03 v5(187.15,139.07) ; U7801.R4 v5(205.33,102.01) ; v5(172.8,94.57) 172.83,94.57 U7000.K27 ; v5(155.73,58.51) 156.4,58.51 v5(156.51,58.62) ; U7000.AN43 156.75,105.15 v5(156.75,105.1) ; U7000.K23 v5(172.81,91.11) ; v5(172.02,91.2) 172.2,91.2 U7000.L23 ; v5(209.49,118.51) v5(209.49,117.71) 209.27,117.94 v5(208.21,117.94) ; v5(158.05,105.1) 158.05,105.15 U7000.AM43 ; v5(204.2,105.48) 203.78,105.06 v5(203.78,104.75) ; U7600.W11 163.95,128.2 164.27,128.53 v5(164.28,128.53) ; U7000.AA43 165.16,105.16 165.16,105.1 v5(165.15,105.1) ; U7000.AA11 165.21,83.29 v5(165.21,83.45) ; v5(169.4,104.35) 169.4,104.5 U7000.R42 ; v5(150.82,133.73) U7601.J14 ; v5(186.31,48.9) 186.29,48.87 v5(185.44,48.87) ; v5(155.93,104.35) 155.65,104.62 U7000.AR42 ; U7900.G1 v5(157.53,52.12) U7900.G2 ; v5(152.68,127.78) 152.62,127.84 v5(151.66,127.84) ; v5(145.62,129.18) 145.62,129.18 145.29,128.86 U7601.B5 ; v5(171.62,138.53) 171.47,138.68 v5(170.9,138.68) ; U7900.W11 163.7,59.6 v5(163.38,59.27) U7900.V10 ; v5(160.95,105.1) 160.95,105.15 U7000.AG43 ; v5(208.11,86.1) 208.23,86.23 v5(208.99,86.23) ; U7800.P10 199.15,82.56 v5(198.83,82.88) 198.5,83.21 U7800.R11 ; U7000.L32 172.32,97.75 v5(172.06,97.49) ; U7000.U43 v5(168.57,105.13) ; v5(172.8,98.77) 172.83,98.77 U7000.K33 ; v5(161,104.35) 161,104.5 U7000.AG42 ; U7700.V10 v5(196.48,117.94) U7700.W11 ; U7800.V10 v5(196.23,82.88) U7800.W11 ; U7900.R4 159.42,56.73 159.43,56.73 159.48,56.68 v5(159.48,56.67) U7900.P5 ; U7801.H12 v5(200.13,96.81) U7801.G13 ; v5(168.55,82.7) 168.55,82.65 U7000.U10 ; U7601.V5 145.7,139.66 v5(145.71,139.66) ; U7000.Y42 166.43,104.47 v5(166.43,104.38) ; U7801.M5 203.05,100.85 v5(203.03,100.82) ; U7000.AJ42 160.1,104.5 v5(160.1,104.35) ; v5(196.88,104.61) U7801.C1 ; U7700.G1 v5(203.63,112.09) U7700.G2 v5(203.63,112.74) U7700.H3 ; v5(176.96,50.17) U7901.R14 176.32,50.18 v5(175.77,50.18) ; U7000.R11 169.4,83.3 v5(169.4,83.45) ; U7600.C14 v5(161.67,138.93) 161.35,138.6 v5(160.35,138.6) ; v5(161.64,129.18) 161.45,129.37 v5(160.35,129.37) ; U7801.H5 v5(200.78,102.01) ; v5(166.03,59.93) 166.08,59.93 166.29,60.14 167.36,60.14 v5(167.46,60.05) v5(167.46,60.85) ; v5(204.03,75.58) 203.65,75.95 v5(203.65,76.25) ; v5(172.82,88.28) U7000.K18 ; U7900.V5 v5(159.48,59.27) 159.16,59.6 U7900.W4 ; v5(165.2,104.35) 165.2,104.5 U7000.AA42 ; v5(164.3,83.45) 164.3,83.3 U7000.AC11 ; v5(170.12,132.43) 169.8,132.1 U7600.N2 ; v5(177,130.5) 176.96,130.46 v5(176.16,130.46) ; U7000.L27 172.2,94.5 v5(171.99,94.5) ; U7601.M3 v5(144.32,135.68) ; U7901.C1 185.41,58.62 v5(185.51,58.62) ; v5(163.04,105.11) 163.04,105.14 U7000.AD43 ; v5(195.81,120.56) 195.69,120.68 195.69,121.85 v5(195.84,122) ; v5(151.63,137.43) 151.28,137.43 U7601.R14 ; v5(151.63,137.43) v5(152.6,137.43) ; v5(156.48,57.35) 156.36,57.35 155.75,56.74 155.75,56.61 v5(155.74,56.6) ; v5(197.14,120.61) 197.14,121.72 v5(197.44,122.02) ; v5(208.36,111.76) 208.38,111.78 v5(208.38,112.41) ; U7700.E13 v5(204.93,119.24) ; v5(145.62,131.78) 145.62,131.78 145.59,131.75 145.59,131.75 145.29,131.46 U7601.F5 ; U7900.C13 165,49.2 v5(164.68,49.52) ; v5(180.4,135.34) 180.34,135.4 U7701.M5 ; v5(166.04,57.34) 165.69,57 U7900.R14 165.53,57.12 165.14,57.12 165.11,57.09 165.09,57.09 U7900.R13 ; v5(186.25,140.4) v5(186.25,141.57) ; v5(183.46,52.12) U7901.M3 ; v5(172.79,101.63) 172.83,101.63 U7000.K38 ; U7701.H5 v5(179.62,133.13) ; v5(185.56,50.5) 185.58,50.5 185.93,50.85 186.31,51.23 v5(186.31,51.3) 185.89,51.72 v5(185.55,51.72) ; U7000.K26 v5(172.82,93.22) ; v5(170.67,105.12) 170.67,105.13 U7000.P43 ; v5(176.92,47.45) 176.64,47.73 U7901.W14 ; U7000.AG11 160.99,83.31 v5(160.99,83.43) ; U7801.B10 v5(196.23,98.11) ; U7000.AK11 159.02,83.18 158.9,83.3 158.9,83.37 158.87,83.4 v5(158.87,83.43) ; v5(157.84,47.41) 157.83,47.4 157.22,47.4 v5(157.2,47.42) 157.2,46.32 v5(157.35,46.17) ; U7000.L18 172.18,88.22 v5(172.07,88.22) 172.09,88.2 172.2,88.2 ; v5(179.62,137.68) 179.62,137.68 U7701.R4 ; v5(206.36,86.2) v5(206.36,85.62) ; U7900.M3 v5(158.18,55.37) 157.86,55.7 U7900.N2 v5(157.53,55.37) 157.21,55.7 U7900.N1 v5(156.88,56.02) ; U7000.AJ43 160.15,105.15 v5(160.15,105.1) ; v5(161.64,140.36) 161.64,140.72 v5(161.08,141.27) ; v5(176.18,132.04) 176.39,131.83 v5(177.02,131.83) ; v5(144.97,133.08) U7601.H5 ; U7000.AD11 163.1,83.3 v5(163.1,83.45) ; v5(172.8,97.45) 173.1,97.75 U7000.K32 ; U7601.G13 150.17,132.43 v5(150.17,132.43) 150.17,132.43 U7601.H12 ; U7000.L26 172.35,93.45 v5(171.96,93.45) ; U7700.J13 v5(202.33,119.24) ; v5(170.65,82.7) 170.65,82.65 U7000.P10 ; v5(208.05,95.53) v5(208.05,94.72) ; U7000.AM42 158,104.5 v5(158,104.35) ; v5(195.57,85.49) 195.47,85.59 v5(195.47,87.19) ; v5(162.29,140.36) 162.29,140.19 U7600.A14 ; v2(192.08,85.15) 192.23,85.15 R7104.2 ; 205.39,100.57 v5(204.72,101.24) 204.72,101.31 U7801.P5 ; v5(186.51,137.48) v5(187.18,137.48) ; U7600.C13 162.65,138.6 v5(162.97,138.28) ; v5(160.17,82.68) 160.15,82.65 U7000.AJ10 ; U7000.K12 v5(172.82,84.07) ; v5(152.68,130.75) 151.73,130.75 v5(151.66,130.83) ; v5(172.75,103.78) 172.83,103.78 172.9,103.85 172.95,103.85 U7000.K41 ; v5(164.68,50.82) U7900.E13 ; v5(208.86,98.81) 208.64,98.81 v5(207.93,98.11) ; U7000.AK10 158.85,82.65 v5(158.85,82.7) ; v5(172,84.8) 172.35,85.15 U7000.L14 ; v5(204.54,79.76) 204.54,79.5 U7800.F5 v5(204.68,78.98) U7800.E4 ; v5(172.05,100.8) 172.2,100.8 U7000.L36 ; v5(182.81,54.72) U7901.H5 ; v5(172.82,84.82) U7000.K14 ; v5(204.68,84.18) U7800.E13
  BOTTOM w0.305: v5(197.21,94.05) 197.03,93.88 C7821.1 ; U7800.M10 200.45,82.22 v5(200.34,82.1) ; v5(187.55,129.92) 187.55,129.92 C7731.1 ; v5(205.98,84.18) U7800.C13 ; C7924.1 174.73,57.87 v5(174.84,57.76) ; U7900.G1 156.8,51.8 ; C7725.1 187.99,127.41 v5(187.55,127.85) ; v5(198.66,93.96) 198.69,93.94 C7833.1
  BOTTOM w0.356: R7710.2 v2(200.89,127.92)
  BOTTOM w0.381: R7910.2 173.44,49.74 C7910.1 ; R7511.2 160.74,45.98 160.74,45.98 ; v5(187,136.94) 187.23,136.71 C7714.1 ; v5(208.95,79.23) 209.05,79.33 C7855.1
  BOTTOM w0.432: R7101.2 151.8,125.86 151.69,125.97 151.69,127.82 v5(151.66,127.84) ; v5(204.03,75.58) 204.04,75.58 C7841.1 ; v5(152.68,129.41) 152.85,129.25 C7653.1 ; C7953.1 155.98,51.72 v5(156.03,51.67) ; C7926.1 176.17,45.94 v5(176.17,46.34) ; v5(160.35,129.37) 160.3,129.31 C7621.1 ; v5(152.6,137.43) 152.67,137.36 C7657.1 ; C7949.1 175.66,138.49 176.12,138.95 176.17,138.9 v5(176.94,138.9) ; C7749.1 205.14,110.26 v2(205.17,110.29) ; C7948.1 186.43,48.78 v5(186.31,48.9) ; R7610.2 157.71,136.15 ; v5(187.18,137.48) 187.19,137.47 C7732.1 ; v5(156.03,50.87) 156.02,50.88 C7951.1 ; v5(185.49,141.56) 185.48,141.58 C7729.1 ; C7652.1 160.28,138.68 v5(160.35,138.6) ; v5(171.62,136.13) 171.66,136.09 C7617.1 ; v5(195.54,94.04) 195.54,93.78 R7105.2 ; v5(195.84,122) 195.83,122.02 C7751.1 ; v5(167.46,57.65) 167.58,57.77 C7941.1 ; C7832.1 196.96,87.32 v5(197.07,87.21) ; v5(204.98,75.6) 204.94,75.56 C7851.1 ; v5(176.12,136.55) 176.09,136.59 C7730.1 ; v5(167.46,58.45) 167.51,58.5 C7950.1 ; C7626.1 152.79,130.86 v5(152.68,130.75) ; v2(204.37,110.29) 204.27,110.19 C7757.1 ; v5(162.6,124.47) 162.63,124.5 R7100.2 ; v5(141.47,138.9) 141.38,138.99 C7618.1 ; C7925.1 174.76,60.13 v5(174.87,60.02) ; v5(151.61,141.56) 151.61,142.24 C7628.1 ; C7659.1 152.9,127.56 v5(152.68,127.78) ; v5(198.24,122) 197.97,122.27 C7756.1 197.44,122.23 v5(197.44,122.02) ; v5(171.62,136.93) 171.65,136.95 C7620.1 ; v5(167.46,60.85) 166.9,61.41 R7106.2 ; v5(186.31,51.3) 186.33,51.32 C7947.1 ; v5(141.47,136.5) 141.34,136.37 C7658.1 ; 175.86,61.46 174.79,62.54 R7107.2 ; v5(197.75,87.18) 197.8,87.23 C7856.1 ; C7624.1 160.32,130.14 v5(160.35,130.17) ; C7932.1 186.49,47.17 v5(186.29,47.38)
  BOTTOM w0.508: v2(207.55,110.27) 207.55,109.77 C7766.1 206.81,109.75 206.81,110.24 v2(206.77,110.29) ; v5(206.36,86.2) 206.17,86.38 C7823.1 ; v5(175.21,48.8) 175.15,48.74 C7910.1 ; C7812.1 204.15,105.53 v5(204.2,105.48) ; v5(160.44,141.03) 160.38,141.1 C7611.1 ; C7764.1 206.57,122.22 v5(206.57,121.44) ; v5(175.15,50.37) 175.09,50.31 C7940.1 ; C7640.1 141.42,141.35 v5(141.47,141.3) ; C7760.1 210.07,118.51 v5(209.49,118.51) ; C7660.1 152.6,139.01 v5(152.6,139.02) ; v5(208.99,86.23) 208.98,86.23 C7811.1 ; v5(208.05,94.72) 207.72,94.39 C7838.1 ; v5(146.8,141.16) 146.8,141.58 147.55,142.33 147.6,142.29 v5(147.6,141.16) ; C7710.1 187.52,139.44 v5(187.15,139.07) ; v5(209.48,121.16) 209.22,121.41 C7705.1 ; v5(207.99,105.48) 208.38,105.88 C7860.1 ; v5(167.02,49.2) 167.37,49.54 C7922.1 ; v5(206.51,75.6) 206.51,74.82 C7863.1 207.14,74.56 v5(207.14,75.6) ; C7912.1 167.08,46.67 v5(166.97,46.56)
  vias: v1(195.23,63.58) v2(173.33,137.23) v2(173.33,135.96) v2(173.33,134.69) v2(173.39,138.29) v2(174.07,138.91) v2(174.08,137.74) v2(174.08,136.47) v2(174.08,135.2) v2(174.08,133.93) v2(194.78,75.17) v2(198.08,75.19) v2(200.26,75.17) v2(203.41,108.29) v2(203.8,91.69) v2(209.91,80.8) v4(187.18,71.48) v4(187.18,70.21) v4(187.18,68.94) v4(188.45,71.48) v4(188.45,70.21) v4(188.45,68.94) v4(188.45,67.67) v4(189.72,71.48) v4(189.72,70.21) v4(189.72,68.94) v4(189.72,67.67) v4(190.99,71.48) v4(190.99,70.21) v4(190.99,68.94) v4(192.26,71.48) v4(192.26,70.21) v4(194.54,132.7) v4(194.54,131.68) v4(194.54,129.14) v4(195.18,130.41) v4(195.18,127.87) v4(195.81,132.7) v4(195.81,131.68) v4(195.81,129.14) v4(196.45,130.41) v4(196.45,127.87) v4(197.08,132.7) v4(197.08,131.68) v4(197.08,129.14) v4(197.72,130.41) v4(197.72,127.87) v4(198.35,132.7) v4(198.35,131.68) v4(198.35,129.14) v4(198.99,130.41) v4(198.99,127.87) v4(199.62,129.14) v4(200.26,130.41) v4(200.89,129.14) v4(208.9,91.93) v4(208.9,90.66) v4(208.9,89.39) v4(210.55,93.45) v4(210.55,92.18) v4(210.55,90.91) v4(210.55,89.64) v4(211.28,86.39) v4(211.28,85.53) v4(211.26,84.62) v4(211.26,83.76) v4(211.28,82.87) v4(211.28,81.98) v4(211.26,81.06) v4(211.44,95.74) v4(211.74,94.65) v4(211.74,93.5) v4(211.84,90.46) v4(211.84,89.19) v4(212.15,86.41) v4(212.15,84.62) v4(212.14,83.76) v4(212.12,81.06) v4(212.17,85.53) v4(212.17,82.87) v4(212.17,81.98) v5(156.75,51.84) v5(158.07,78.52) v5(159.63,46.82) v5(161.1,47.17) v5(163.46,46.55) v5(164.26,46.55) v5(165.03,46.55) v5(165.37,47.46) v5(166.02,47.46) v5(167.02,47.6) v5(171.9,131.2) v5(171.92,129.29) v5(171.92,128.49) v5(171.92,127.69) v5(172.24,92.84) v5(172.28,90.59) v5(172.34,88.72) v5(172.47,86.54) v5(174.89,58.45) v5(175.96,48.99) v5(176.97,46.34) v5(179.38,46.64) v5(180.18,46.64) v5(180.81,141.2) v5(180.98,46.64) v5(181.61,50.48) v5(188.91,135.16) v5(194.88,94.01) v5(206.48,95.18) v5(208.15,85.52) v5(208.15,84.87) v5(208.86,94.81) v5(209.03,103.66)
