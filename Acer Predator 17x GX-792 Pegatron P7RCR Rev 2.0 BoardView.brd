# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+NVVDD on VCC2 (solid shape): 187.94,158.04 187.94,150.98 187.95,150.94 187.98,150.89 190.1,148.77 190.1,77.5 178.36,65.77 136.05,65.77 124.44,77.38 124.44,122.79 124.43,122.84 124.4,122.88 120.85,126.44 120.81,126.46 120.76,126.47 120.05,126.47 119.87,126.65 119.87,129.72 120.59,130.45 120.62,130.49 120.63,130.54 120.63,133.97 120.62,134.02 120.59,134.06 120.12,134.53 120.12,134.8 120.59,135.27 120.62,135.32 120.63,135.36 120.63,153.4 129.39,153.4 129.44,153.41 129.48,153.43 137.07,161.02 184.97,161.02
+NVVDD on IN3 (solid shape): outline of 14390 points within 127.14,84.78 184.46,160.97
+NVVDDS on TOP (solid shape): 157.04,103.2 157.04,101.63 156.83,101.42 156.63,101.42 156.45,101.6 156.45,103.08 156.63,103.26 156.99,103.26
+NVVDDS on TOP (solid shape): 164,103.1 164,100.16 163.84,100 163.56,100 163.44,100.13 163.44,103.08 163.56,103.2 163.89,103.2
+NVVDDS on TOP (solid shape): 154.21,87.61 154.21,87.28 154.34,87.15 154.34,86.47 154.16,86.29 154.16,85.43 154.06,85.33 153.8,85.33 153.65,85.48 153.65,87.71 153.75,87.81 154.01,87.81
+NVVDDS on TOP (solid shape): 156.93,87.71 156.93,87.23 156.83,87.13 156.83,86.47 156.93,86.37 156.93,85.4 156.85,85.33 156.55,85.33 156.39,85.48 156.39,86.49 156.24,86.65 156.24,87.23 156.39,87.38 156.39,87.74 156.47,87.81 156.83,87.81
+NVVDDS on TOP (solid shape): 159.74,87.66 159.74,87.34 159.9,87.18 159.9,86.44 159.8,86.34 159.8,84.67 159.75,84.61 159.34,84.61 159.29,84.67 159.29,86.24 159.34,86.29 159.34,87.15 159.25,87.23 159.25,87.72 159.35,87.81 159.58,87.81
+NVVDDS on TOP (solid shape): 164.02,87.61 164.02,85.47 163.84,85.3 163.81,85.3 163.8,85.29 163.6,85.29 163.59,85.3 163.52,85.3 163.36,85.45 163.36,85.5 163.36,85.54 163.36,87.48 163.39,87.51 163.39,87.58 163.64,87.84 163.79,87.84
+NVVDDS on TOP (solid shape): 166.78,87.75 166.78,87.41 167.17,87.02 167.17,86.67 167.02,86.52 166.99,86.52 166.84,86.37 166.84,85.64 166.55,85.34 166.41,85.34 166.18,85.58 166.18,86.31 166.44,86.57 166.44,86.59 166.44,87.28 166.28,87.44 166.28,87.75 166.38,87.85 166.68,87.85
+NVVDDS on TOP (solid shape): 161.81,102.39 161.81,101.54 161.71,101.43 161.71,100.45 161.79,100.37 161.79,100.11 161.68,100 161.48,100 161.33,100.16 161.33,100.33 161.02,100.64 161.02,101.17 161.25,101.4 161.25,101.55 161.26,101.6 161.25,101.65 161.25,102.25 161.26,102.3 161.25,102.34 161.37,102.46 161.74,102.46
+NVVDDS on TOP (solid shape): 166.76,102.39 166.76,101.4 167.04,101.12 167.04,100.64 166.71,100.31 166.71,100.16 166.7,100.12 166.58,100 166.52,99.98 166.46,99.98 166.28,100.16 166.28,100.51 166.3,100.51 166.3,101.27 166.28,101.27 166.28,102.44 166.37,102.53 166.56,102.53 166.56,102.54 166.61,102.54
+NVVDDS on TOP (solid shape): 202.27,156.83 202.27,155.38 200.54,153.65 200.54,147.67 201.43,146.78 201.43,132.05 201.25,131.87 200.07,131.87 199.76,132.19 199.76,133.4 196.65,136.51 196.65,141.79 195.53,142.91 194.37,142.91 193.99,143.29 192.99,143.29 191.9,144.39 191.9,152.38 192.59,153.07 192.59,156.67 193.33,157.41 201.68,157.41
+NVVDDS on TOP (solid shape): 159.57,103.16 159.57,102.52 159.7,102.39 159.7,101.48 159.6,101.38 159.32,101.38 159.16,101.54 159.14,101.72 159.04,101.87 159.04,102.03 159.16,102.29 159.04,102.56 159.04,103.2 159.07,103.23 159.5,103.23
+NVVDDS on TOP (solid shape): 164,95.38 164,95.15 164.05,95.1 164.05,94.04 164.05,94.04 164.05,93.86 163.9,93.71 163.59,93.71 163.49,93.81 163.49,94.18 163.4,94.26 162.81,94.26 162.69,94.38 162.69,94.89 162.76,94.95 163.01,94.95 163.27,95.06 163.36,95.33 163.59,95.56 163.82,95.56
+NVVDDS on TOP (solid shape): 169.65,87.64 169.65,87.58 169.66,87.54 169.67,87.5 169.69,87.45 169.69,86.36 169.68,86.35 169.65,86.24 169.66,86.13 169.67,86.09 169.69,86.05 169.69,85.68 169.68,85.67 169.64,85.5 169.68,85.34 169.69,85.33 169.69,84.66 169.58,84.56 169.15,84.56 169,84.71 169,87.68 169.18,87.86 169.43,87.86
+NVVDDS on TOP (solid shape): 154.26,94.04 154.25,94.01 154.26,93.78 154.41,93.6 154.46,93.55 154.46,92.88 154.24,92.67 154.24,92.52 154.24,92.45 154.09,92.31 153.73,92.31 153.56,92.48 153.56,92.5 153.54,92.6 153.51,92.68 153.51,93.71 153.55,93.82 153.56,93.94 153.56,93.96 153.71,94.11 154.19,94.11
+NVVDDS on TOP (solid shape): 169.67,95.4 169.66,95.37 169.66,95.21 169.74,95.07 169.74,94.14 169.68,94.03 169.65,93.92 169.65,93.9 169.41,93.65 169.18,93.65 168.97,93.87 168.91,94.09 168.72,94.24 168.72,94.95 168.75,94.97 168.93,95.14 168.96,95.38 168.95,95.41 169.1,95.56 169.51,95.56
+NVVDDS on TOP (solid shape): 169.74,103.15 169.74,102.56 169.71,102.53 169.69,102.5 169.63,102.44 169.63,101.76 169.56,101.68 169.56,100.13 169.43,100 169.15,100 168.97,100.19 168.97,100.24 168.95,100.3 168.94,100.34 168.92,100.37 168.92,100.39 168.9,100.41 168.87,100.45 168.82,100.49 168.82,101.22 169.09,101.49 169.08,101.56 169.08,101.61 169.09,101.67 169.1,101.69 169.1,102.2 169.08,102.26 169.08,102.29 169.08,102.34 169.08,102.37 169.1,102.43 169.1,103.08 169.28,103.26 169.64,103.26
+NVVDDS on TOP (solid shape): 159.76,94.14 159.84,94.1 159.86,94.01 159.92,93.67 160.25,93.55 160.33,93.53 160.36,93.45 160.36,93 160.02,93 159.82,92.88 159.82,92.65 159.83,92.64 159.83,91.72 159.67,91.57 159.34,91.57 159.3,91.6 159.3,91.68 159.28,91.72 159.26,91.81 159.28,91.9 159.3,91.96 159.3,92.36 159.28,92.4 159.26,92.49 159.27,92.58 159.31,92.66 159.27,92.7 159.27,93.81 159.26,93.87 159.25,93.98 159.25,94.08 159.25,94.09 159.31,94.14
+NVVDDS on BOTTOM (solid shape): 206.53,156.78 206.53,153.55 206,153.01 200.75,153.01 200.52,152.79 200.52,146.04 200.21,145.73 192.24,145.73 191.87,146.1 191.87,151.87 191.65,152.09 189.5,152.09 189.32,152.27 189.32,157.07 189.84,157.58 205.73,157.58
+NVVDDS on BOTTOM (solid shape): 161.29,95.82 161.41,95.69 161.57,95.64 161.59,95.64 161.69,95.54 161.74,95.46 161.8,95.41 161.83,95.4 161.83,95.2 161.8,95.19 161.67,94.95 161.8,94.71 161.83,94.7 161.83,94.55 161.52,94.24 161.51,94.24 161.41,94.2 161.32,94.13 161.27,94.13 161.09,94.3 161.09,95.01 161.25,95.3 161.09,95.6 161.09,95.71 161.15,95.76 161.2,95.82
+NVVDDS on BOTTOM (solid shape): 161.98,93.71 162.1,93.59 162.26,93.54 162.28,93.53 162.36,93.45 162.36,92.97 162.24,92.84 161.96,92.56 162.11,92.2 162.11,92.1 162.06,92.05 162.02,92.01 162,91.99 161.9,91.99 161.83,92.07 161.74,92.13 161.73,92.13 161.38,92.47 161.38,92.6 161.4,92.61 161.45,92.65 161.49,92.7 161.63,92.84 161.65,92.85 161.95,93.12 161.8,93.5 161.8,93.6 161.85,93.65 161.9,93.71
+NVVDDS on BOTTOM (solid shape): 156.79,102.76 156.78,102.73 156.79,102.55 156.9,102.41 156.93,102.4 156.93,102.2 156.9,102.19 156.77,101.95 156.9,101.71 156.93,101.7 156.93,101.5 156.9,101.49 156.78,101.31 156.82,101.1 156.82,100.7 156.78,100.49 156.9,100.31 156.93,100.3 156.93,100.1 156.9,100.09 156.82,100.01 156.78,99.9 156.77,99.89 156.58,99.69 156.29,99.69 156.2,99.78 156.2,99.92 156.34,100.21 156.2,100.49 156.2,101.99 156.37,102.3 156.2,102.6 156.2,102.73 156.3,102.83 156.72,102.83
+NVVDDS on BOTTOM (solid shape): 169.8,88.03 169.8,87.89 169.65,87.6 169.8,87.31 169.8,86.49 169.65,86.2 169.8,85.91 169.8,85.79 169.65,85.5 169.8,85.21 169.8,85.06 169.73,84.99 169.35,84.99 169.23,85.11 169.23,85.13 169.2,85.28 169.09,85.39 169.09,85.61 169.23,85.85 169.09,86.09 169.09,86.31 169.22,86.49 169.17,86.72 169.17,87.08 169.22,87.31 169.09,87.49 169.09,87.71 169.16,87.77 169.21,87.84 169.21,87.85 169.47,88.11 169.72,88.11
+NVVDDS on BOTTOM (solid shape): 156.77,87.97 156.77,87.95 156.81,87.8 156.92,87.7 156.92,87.5 156.78,87.31 156.82,87.08 156.82,86.72 156.78,86.49 156.92,86.3 156.92,86.1 156.77,85.85 156.92,85.6 156.92,85.4 156.83,85.32 156.78,85.22 156.77,85.2 156.58,85 156.28,85 156.21,85.08 156.21,85.21 156.37,85.5 156.21,85.8 156.21,85.93 156.34,86.2 156.21,86.48 156.21,87.31 156.36,87.6 156.21,87.89 156.21,88.04 156.31,88.14 156.6,88.14
+NVVDDS on BOTTOM (solid shape): 153.98,88.01 153.97,87.99 154,87.82 154.12,87.7 154.12,87.5 153.98,87.32 154.02,87.09 154.02,86.71 153.98,86.48 154.12,86.3 154.12,86.1 153.97,85.85 154.12,85.6 154.12,85.4 154.05,85.35 154,85.28 154,85.27 153.72,84.99 153.49,84.99 153.41,85.08 153.41,85.22 153.55,85.5 153.41,85.79 153.41,85.91 153.56,86.2 153.41,86.49 153.41,87.3 153.56,87.6 153.41,87.89 153.41,88.04 153.49,88.12 153.87,88.12
+NVVDDS on BOTTOM (solid shape): 159.57,87.98 159.57,87.96 159.61,87.81 159.72,87.7 159.72,87.5 159.58,87.31 159.63,87.08 159.63,86.72 159.58,86.49 159.72,86.3 159.72,86.1 159.57,85.85 159.72,85.6 159.72,85.4 159.65,85.34 159.6,85.27 159.59,85.26 159.33,85 159.08,85 159,85.07 159,85.21 159.16,85.5 159,85.8 159,85.91 159.15,86.2 159,86.48 159,87.29 159.16,87.59 159,87.89 159,88.04 159.09,88.12 159.43,88.12
+NVVDDS on BOTTOM (solid shape): 162.1,88.04 162.1,87.89 161.96,87.6 162.1,87.32 162.1,86.5 161.94,86.2 162.1,85.9 162.1,85.79 161.95,85.5 162.1,85.2 162.1,85.09 162.01,84.99 161.75,84.99 161.52,85.23 161.52,85.24 161.46,85.33 161.38,85.4 161.38,85.6 161.53,85.85 161.38,86.1 161.38,86.3 161.53,86.5 161.46,86.74 161.46,87.06 161.53,87.3 161.38,87.5 161.38,87.7 161.45,87.75 161.5,87.82 161.5,87.83 161.78,88.11 162.03,88.11
+NVVDDS on BOTTOM (solid shape): 159.58,102.72 159.57,102.7 159.6,102.53 159.72,102.4 159.72,102.2 159.57,101.95 159.72,101.7 159.72,101.5 159.57,101.3 159.64,101.06 159.64,100.74 159.57,100.5 159.72,100.3 159.72,100.1 159.65,100.04 159.6,99.97 159.59,99.96 159.33,99.7 159.08,99.7 159,99.78 159,99.91 159.16,100.21 159,100.51 159,101.31 159.16,101.61 159,101.91 159,101.99 159.16,102.29 159,102.59 159,102.74 159.08,102.81 159.49,102.81
+NVVDDS on BOTTOM (solid shape): 169.8,102.75 169.8,102.59 169.65,102.3 169.8,102.01 169.8,101.89 169.65,101.6 169.8,101.31 169.8,100.49 169.65,100.2 169.8,99.91 169.8,99.78 169.71,99.69 169.32,99.69 169.22,99.78 169.23,99.81 169.2,99.97 169.09,100.09 169.09,100.3 169.23,100.5 169.16,100.73 169.16,101.07 169.23,101.3 169.09,101.49 169.09,101.7 169.23,101.95 169.09,102.19 169.09,102.4 169.2,102.52 169.23,102.69 169.22,102.71 169.35,102.83 169.71,102.83
+NVVDDS on BOTTOM (solid shape): 164.2,88.05 164.2,87.9 164.04,87.6 164.2,87.3 164.2,86.49 164.04,86.19 164.2,85.89 164.2,85.8 164.04,85.5 164.2,85.2 164.2,85.11 164.11,85.02 163.8,85.02 163.63,85.19 163.62,85.2 163.58,85.31 163.49,85.39 163.49,85.61 163.63,85.85 163.49,86.09 163.49,86.31 163.62,86.48 163.59,86.7 163.59,87.1 163.62,87.32 163.49,87.49 163.49,87.71 163.56,87.77 163.61,87.84 163.61,87.85 163.7,87.94 163.72,87.94 163.89,87.99 164.02,88.12 164.13,88.12
+NVVDDS on BOTTOM (solid shape): 167.01,102.75 167.01,102.61 166.85,102.3 167.01,102 167.01,101.9 166.85,101.6 167.01,101.3 167.01,100.5 166.84,100.2 167.01,99.9 167.01,99.8 166.91,99.69 166.59,99.69 166.43,99.85 166.43,99.87 166.39,99.99 166.3,100.09 166.27,100.1 166.27,100.3 166.3,100.31 166.42,100.49 166.38,100.7 166.38,101.1 166.42,101.31 166.3,101.49 166.27,101.5 166.27,101.7 166.3,101.71 166.43,101.95 166.3,102.19 166.27,102.2 166.27,102.4 166.3,102.41 166.39,102.51 166.43,102.65 166.43,102.67 166.58,102.82 166.94,102.82
+NVVDDS on BOTTOM (solid shape): 161.68,102.71 161.67,102.69 161.7,102.52 161.82,102.4 161.82,102.2 161.67,101.95 161.82,101.7 161.82,101.5 161.68,101.3 161.74,101.07 161.74,100.73 161.68,100.5 161.82,100.3 161.82,100.1 161.75,100.04 161.69,99.96 161.69,99.95 161.42,99.68 161.21,99.68 161.15,99.74 161.11,99.78 161.11,99.92 161.25,100.21 161.11,100.49 161.11,101.31 161.26,101.6 161.11,101.89 161.11,102.01 161.26,102.3 161.11,102.59 161.11,102.74 161.21,102.84 161.55,102.84
+NVVDDS on BOTTOM (solid shape): 167,88.04 167,87.9 166.84,87.6 167,87.31 167,86.5 166.85,86.2 167,85.91 167,85.81 166.83,85.5 167,85.2 167,85.09 166.9,84.99 166.6,84.99 166.43,85.16 166.43,85.18 166.39,85.3 166.29,85.39 166.27,85.4 166.27,85.59 166.29,85.61 166.43,85.85 166.29,86.09 166.27,86.1 166.27,86.29 166.29,86.31 166.43,86.51 166.35,86.74 166.35,87.06 166.43,87.29 166.29,87.49 166.27,87.5 166.27,87.69 166.29,87.71 166.37,87.78 166.42,87.87 166.42,87.88 166.67,88.13 166.91,88.13
+NVVDDS on BOTTOM (solid shape): 164.2,102.73 164.2,102.59 164.04,102.3 164.2,102.01 164.2,101.89 164.04,101.6 164.2,101.31 164.2,100.5 164.05,100.21 164.2,99.92 164.2,99.76 164.15,99.71 163.72,99.71 163.63,99.8 163.63,99.83 163.6,99.98 163.49,100.09 163.46,100.11 163.46,100.29 163.49,100.31 163.62,100.49 163.57,100.72 163.57,101.08 163.62,101.31 163.49,101.49 163.46,101.51 163.46,101.69 163.49,101.71 163.63,101.95 163.46,102.22 163.46,102.39 163.49,102.41 163.59,102.51 163.63,102.65 163.63,102.67 163.78,102.82 164.11,102.82
+NVVDDS on BOTTOM (solid shape): 154.01,102.9 154.01,102.79 153.97,102.63 154.03,102.48 154.03,102.12 153.97,101.91 154.08,101.73 154.08,101.47 153.97,101.28 154.03,101.07 154.03,100.73 153.97,100.52 154.08,100.33 154.08,100.07 154.01,100 153.97,99.9 153.96,99.87 153.92,99.86 153.75,99.82 153.61,99.7 153.49,99.7 153.4,99.79 153.4,99.9 153.56,100.19 153.4,100.49 153.4,102.01 153.55,102.39 153.23,102.65 153.22,102.66 153.1,102.77 153.1,102.78 153.05,102.85 152.98,102.9 152.95,102.91 152.95,103.09 152.98,103.1 153.06,103.16 153.11,103.25 153.12,103.28 153.63,103.28
+NVVDDS on BOTTOM (solid shape): 169.72,95.79 169.76,95.75 169.8,95.71 169.8,95.59 169.65,95.3 169.8,95.01 169.8,94.19 169.65,93.9 169.8,93.61 169.8,92.79 169.65,92.5 169.8,92.21 169.8,92.09 169.76,92.05 169.71,92 169.6,92 169.49,92.1 169.34,92.15 169.33,92.16 169.19,92.29 169.15,92.35 169.08,92.4 169.08,92.6 169.22,92.79 169.18,93.01 169.18,93.39 169.23,93.6 169.11,93.78 169.08,93.8 169.08,93.99 169.12,94.03 169.22,94.19 169.19,94.39 169.19,94.81 169.22,95.03 169.08,95.2 169.08,95.4 169.15,95.45 169.2,95.52 169.2,95.53 169.32,95.64 169.33,95.64 169.48,95.69 169.59,95.79
+NVVDDS on BOTTOM (solid shape): 153.6,95.8 153.74,95.68 153.92,95.65 153.95,95.64 153.97,95.61 154.02,95.49 154.11,95.41 154.13,95.38 154.13,95.22 154.1,95.18 153.97,94.98 154.04,94.76 154.04,94.44 153.97,94.23 154.07,94.03 154.13,93.97 154.13,93.82 154.1,93.79 153.97,93.59 154.04,93.37 154.04,93.03 153.97,92.8 154.11,92.61 154.13,92.59 154.13,92.42 154.08,92.37 154.05,92.35 153.85,92.15 153.84,92.14 153.71,92.1 153.6,92 153.5,92 153.45,92.05 153.39,92.1 153.39,92.2 153.56,92.5 153.39,92.8 153.39,93.61 153.55,93.91 153.39,94.2 153.39,95 153.56,95.31 153.39,95.61 153.39,95.7 153.45,95.75 153.5,95.8
+NVVDDS on BOTTOM (solid shape): 159.61,96.21 159.65,96.15 159.71,96.1 159.71,95.89 159.57,95.65 159.71,95.4 159.71,95.19 159.57,95 159.63,94.77 159.63,94.43 159.57,94.2 159.71,94 159.71,93.79 159.58,93.61 159.62,93.39 159.62,93.01 159.58,92.78 159.71,92.6 159.71,92.39 159.57,92.15 159.71,91.9 159.71,91.7 159.65,91.65 159.61,91.6 159.6,91.57 159.4,91.57 159.39,91.6 159.33,91.67 159.25,91.71 159.24,91.71 159.16,91.79 159.16,91.81 159.12,91.97 159.01,92.1 159.01,92.2 159.16,92.49 159.01,92.79 159.01,93.62 159.16,93.91 159.01,94.2 159.01,95.01 159.16,95.31 159.01,95.6 159.01,95.7 159.13,95.83 159.16,96.01 159.16,96.03 159.2,96.07 159.22,96.08 159.32,96.13 159.39,96.21
+NVVDDS on IN1 (solid shape): outline of 9655 points within 151.62,84.07 171.42,104.74
+NVVDDS on GND4 (solid shape): 209.28,151.95 209.28,124.37 207.83,122.92 193.91,122.92 193.86,122.91 193.82,122.88 192.93,121.99 192.9,121.95 192.89,121.9 192.89,96.94 181.41,85.45 171.56,85.45 171.51,85.44 171.47,85.42 170.74,84.69 152.69,84.69 151.84,85.54 151.79,85.57 151.75,85.58 144.81,85.58 143.49,86.9 143.49,110.8 145.23,112.54 145.26,112.58 145.27,112.63 145.27,121.34 149.26,125.33 152.25,125.33 152.3,125.34 152.34,125.37 154.38,127.4 154.4,127.44 154.41,127.49 154.41,155.12 156.62,157.33 203.89,157.33
+NVVDDS on IN3 (solid shape): 203.79,156.36 203.79,147.3 203.16,146.67 192.07,146.67 190.28,148.46 190.28,156.81 190.87,157.41 202.74,157.41
+NVVDDS on GND5 (solid shape): 200.89,156.9 200.89,146.97 197.79,143.87 140.7,143.87 140.65,143.86 140.61,143.84 140.1,143.33 140.07,143.29 140.06,143.24 140.06,136.05 139.34,135.33 139.31,135.29 139.3,135.24 139.3,133.26 138.07,132.02 138.04,131.98 138.03,131.93 138.03,121.77 138.04,121.73 138.07,121.68 142.09,117.66 142.09,114.79 142.1,114.74 142.13,114.7 148.61,108.22 148.65,108.2 148.7,108.19 150.93,108.19 153.18,105.94 153.22,105.91 153.27,105.9 153.73,105.9 156.36,103.27 156.4,103.24 156.44,103.23 170.36,103.23 171.05,102.55 171.05,85.63 170.36,84.94 152.81,84.94 152.38,85.38 152.38,90.79 152.37,90.84 152.34,90.88 151.58,91.64 151.54,91.67 151.49,91.68 144.31,91.68 139.64,96.34 139.6,96.37 139.55,96.37 135.67,96.37 133.33,98.71 133.33,106.03 133.32,106.08 133.29,106.12 131.17,108.24 131.17,129.39 131.16,129.44 131.13,129.48 129.86,130.75 129.82,130.78 129.77,130.79 128.3,130.79 127.62,131.48 127.62,133.2 127.61,133.25 127.58,133.29 127.11,133.77 127.11,143.57 134.06,150.51 134.08,150.56 134.09,150.6 134.09,154.11 136.05,156.06 150.22,156.06 150.27,156.07 150.31,156.1 151.54,157.33 200.46,157.33
+NVVDDS on IN4 (solid shape): outline of 18829 points within 122.44,84.3 200.78,157.39
+NVVDDS_BOOT1 on TOP (solid shape): 202.21,186.57 203.85,186.57 204.02,186.39 204.02,186.07 203.92,185.97 203.57,185.97 203.43,186.1 201.96,186.1 201.46,186.6 201.37,186.6 201.11,186.86 201.11,187.06 201.14,187.09 201.69,187.09
+NVVDDS_BOOT1_R on TOP (solid shape): 203.06,185.57 203.06,184.89 203.24,184.72 203.77,184.72 204.07,184.42 204.07,184.06 203.98,183.97 202.66,183.97 202.54,184.08 202.54,185.57 202.61,185.64 203,185.64
+NVVDDS_BOOT2 on TOP (solid shape): 198.88,187.08 198.88,186.99 198.81,186.92 198.28,186.92 197.3,185.94 196.6,185.94 196.54,186 196.54,186.42 196.99,186.87 197.23,186.87 198.13,187.12 198.84,187.12
+NVVDDS_LGATE1 on TOP (solid shape): 200.52,186.66 200.52,185.98 200.91,185.58 200.91,184.21 200.69,183.99 200.33,183.99 200.11,184.21 200.11,184.56 200.11,184.56 200.11,185.1 200.29,185.28 200.39,185.53 200.29,185.78 200.29,186.63 200.37,186.7 200.48,186.7
+NVVDDS_LGATE1 on BOTTOM (solid shape): 209.77,174.04 209.77,172.59 209.6,172.41 208.78,172.41 208.47,172.72 208.47,174.32 209.49,174.32
+NVVDDS_LGATE1 on BOTTOM (solid shape): 203.06,174.21 203.06,173.32 203.07,173.3 203.76,173.3 203.96,173.1 203.96,172.65 203.75,172.43 203.01,172.43 202.51,172.93 202.51,174.14 202.63,174.27 203,174.27
+NVVDDS_LGATE2 on TOP (solid shape): 199.71,185.77 199.62,185.53 199.71,185.28 199.71,184.77 199.51,184.57 199.19,184.57 198.79,184.97 198.79,185.69 199.05,185.95 199.36,185.95 199.49,186.08 199.49,186.66 199.71,186.66
+NVVDDS_LGATE2 on BOTTOM (solid shape): 192.18,174.09 192.18,173.26 191.96,173.04 190.8,173.04 190.73,173.11 190.73,174.27 192,174.27
+NVVDDS_LGATE2 on BOTTOM (solid shape): 197.17,174.19 197.17,173.41 197.54,173.03 198.1,173.03 198.35,172.78 198.35,172.43 198.23,172.31 197.13,172.31 196.61,172.84 196.61,174.2 196.69,174.28 197.07,174.28
+NVVDDS_PHASE1 on TOP (solid shape): 201.12,186.43 201.44,186.43 202.22,185.66 202.22,184.22 201.93,183.94 201.32,183.94 201.22,184.04 201.22,185.58 200.69,186.11 200.69,186.63 200.74,186.68 200.87,186.68
+NVVDDS_PHASE1 on TOP (solid shape): 202.84,175.62 202.84,172.32 203.47,171.69 203.57,171.69 203.71,171.66 203.86,171.69 208.39,171.69 209.15,170.92 209.15,163.3 208.9,163.05 199.78,163.05 199.08,163.76 199.08,175.46 199.42,175.8 202.65,175.8
+NVVDDS_PHASE1 on BOTTOM (solid shape): 208.78,172.09 208.78,172.05 209.61,171.23 209.61,171.18 209.63,171.18 210.05,170.76 210.58,170.76 210.7,170.65 210.7,170.43 210.5,170.24 209.61,170.24 208.78,169.42 208.78,163.43 208.03,162.68 199.73,162.68 199.29,163.13 199.29,172.03 199.47,172.2 208.66,172.2
+NVVDDS_PHASE2 on TOP (solid shape): 199.28,186.6 199.28,186.2 199.21,186.13 198.97,186.13 198.46,185.63 198.46,184.63 198.3,184.46 197.1,184.46 197.01,184.55 197.01,185.36 198.28,186.63 198.8,186.63 198.83,186.66 199.23,186.66
+NVVDDS_PHASE2 on TOP (solid shape): 197.01,175.48 197.01,172.32 198.35,170.98 198.35,162.92 198.1,162.67 190.48,162.67 190.1,163.05 190.1,170.54 193.02,173.46 193.02,173.94 193.81,174.73 193.81,175.56 194.04,175.79 196.71,175.79
+NVVDDS_PHASE2 on BOTTOM (solid shape): 197.31,171.68 197.31,168.33 198.21,167.43 198.21,163.28 197.7,162.76 189.05,162.76 188.5,163.32 187.55,163.32 186.91,163.95 186.91,166.17 185.79,167.29 185.22,167.29 185.09,167.42 185.09,167.9 185.23,168.03 186.25,168.03 186.91,168.69 186.91,171.95 187.25,172.29 196.7,172.29
+NVVDDS_UGATE1 on TOP (solid shape): 202.95,187.41 203.32,187.41 203.36,187.38 203.36,186.98 203.31,186.94 202.11,186.94 201.73,187.31 201.14,187.31 201.11,187.34 201.11,187.48 201.13,187.5 202.86,187.5
+NVVDDS_UGATE1_R on TOP (solid shape): 204.52,175.63 204.52,173.77 204.33,173.58 203.49,173.58 203.2,173.87 203.2,174.81 203.55,175.15 203.55,175.72 203.67,175.84 204.31,175.84
+NVVDDS_UGATE2 on TOP (solid shape): 198.33,187.51 198.87,187.51 198.91,187.47 198.91,187.38 198.84,187.31 198.14,187.31 197.11,187.03 196.57,187.03 196.52,187.08 196.52,187.5 196.55,187.54 198.31,187.54
+NVVDDS_UGATE2_R on TOP (solid shape): 198.62,175.69 198.62,173.89 198.34,173.6 197.74,173.6 197.55,173.79 197.55,175.66 197.72,175.84 198.48,175.84
+NVVDDS_UGATE2_R on TOP (solid shape): 195.62,187.55 196.01,187.55 196.1,187.47 196.1,187.12 196.03,187.06 195.42,187.06 195.27,186.91 194.83,186.91 194.66,187.08 194.66,187.54 194.83,187.71 195.47,187.71
+VCORE on TOP (solid shape): 108.95,116.6 108.95,115.81 108.86,115.58 108.95,115.34 108.95,115.2 108.94,115.19 108.88,114.99 108.95,114.79 108.95,112.82 108.94,112.81 108.91,112.7 108.91,112.59 108.92,112.56 108.73,112.38 107.99,112.38 107.99,116.91 108.01,116.92 108.63,116.92
+VCORE on TOP (solid shape): outline of 781 points within 76.31,111.28 106.82,168.48
+VCORE on BOTTOM (solid shape): outline of 3089 points within 82.81,110.95 110,172.83
+VCORE on IN1 (solid shape): outline of 4473 points within 76.18,111.28 109.48,168.51
+VCORE on IN2 (solid shape): outline of 4836 points within 75.01,111.28 108.95,172.83
+VCORE on VCC1 (solid shape): 88.12,168.46 88.12,156.06 88.13,156.02 88.16,155.97 88.41,155.72 88.45,155.69 88.5,155.68 89.59,155.68 93.74,151.53 93.79,151.5 93.83,151.49 97.08,151.49 107.55,141.03 107.55,115.93 107.56,115.88 107.59,115.84 108.82,114.61 108.82,112.43 107.75,111.36 94.21,111.36 94.21,123.5 94.81,124.1 94.84,124.14 94.85,124.19 94.85,130.03 94.84,130.08 94.81,130.12 93.42,131.52 93.37,131.54 93.33,131.55 90.84,131.55 87.86,134.53 87.86,136.38 87.86,136.43 87.83,136.47 86.47,137.83 86.47,139.55 86.46,139.6 86.43,139.64 83.55,142.53 83.55,145.4 83.54,145.45 83.51,145.49 82.78,146.21 82.78,147.05 82.78,147.1 82.75,147.14 82.37,147.52 82.33,147.55 82.28,147.56 77.12,147.56 75.93,148.75 75.93,167.82 77,168.89 87.69,168.89
+VCORE on VCC2 (solid shape): 88.12,168.46 88.12,156.06 88.13,156.02 88.16,155.97 88.41,155.72 88.45,155.69 88.5,155.68 89.59,155.68 93.74,151.53 93.79,151.5 93.83,151.49 97.08,151.49 107.55,141.03 107.55,115.93 107.56,115.88 107.59,115.84 108.82,114.61 108.82,112.43 107.75,111.36 94.21,111.36 94.21,123.5 94.81,124.1 94.84,124.14 94.85,124.19 94.85,130.03 94.84,130.08 94.81,130.12 93.42,131.52 93.37,131.54 93.33,131.55 90.84,131.55 87.86,134.53 87.86,136.38 87.86,136.43 87.83,136.47 86.47,137.83 86.47,139.55 86.46,139.6 86.43,139.64 83.55,142.53 83.55,145.4 83.54,145.45 83.51,145.49 82.78,146.21 82.78,147.05 82.78,147.1 82.75,147.14 82.37,147.52 82.33,147.55 82.28,147.56 77.12,147.56 75.93,148.75 75.93,167.82 77,168.89 87.69,168.89
+VCORE on IN3 (solid shape): outline of 1662 points within 82.02,124.87 108.18,169.65
+VCORE on IN3 (solid shape): outline of 1979 points within 94.63,111.28 108.91,123.71
+VCORE on IN4 (solid shape): outline of 266 points within 77.07,151.75 88.12,172.83
+VCORE on IN4 (solid shape): outline of 3712 points within 89.19,111.2 112.14,138.79
+VTT_DDR on TOP (solid shape): 109.81,55.33 109.82,55.29 109.82,54.56 109.63,54.38 108.58,54.38 108.52,54.44 108.52,55.5 108.59,55.57 109.57,55.57
+VTT_DDR on TOP (solid shape): 24.62,57.51 24.62,55.73 24.49,55.61 21.7,55.61 21.57,55.73 20.61,55.73 20.55,55.79 20.55,56.43 20.62,56.5 21.19,56.5 21.32,56.62 21.32,57.64 21.44,57.77 24.36,57.77
+VTT_DDR on TOP (solid shape): 106,72.97 106,69.73 106.57,69.15 109.55,69.15 110.01,68.7 110.01,66.51 109.34,65.84 108.57,65.84 108.43,65.99 108.43,66.22 109.07,66.87 109.07,67.59 108.75,67.91 105.83,67.91 104.77,68.98 104.77,72.68 104.95,72.86 105.1,72.86 105.4,73.16 105.81,73.16
+VTT_DDR on BOTTOM (solid shape): 105.92,73.23 105.92,69.48 106.13,69.27 106.13,68.47 105.91,68.25 104.73,68.25 104.66,68.32 104.66,73.32 104.76,73.41 105.74,73.41
+VTT_DDR on BOTTOM (solid shape): 117.13,58.37 117.13,57.28 116.88,57.04 113.73,57.04 112.41,55.72 110.11,55.72 109.36,54.97 107.99,54.97 107.88,55.09 107.88,56.46 108.65,57.23 112.31,57.23 113.65,58.57 116.93,58.57
+VTT_DDR on BOTTOM (solid shape): 114.28,51.8 114.28,47.93 114.12,47.78 113.67,47.78 113.56,47.67 113.5,47.62 113.46,47.57 112.51,46.62 112.51,45.4 111.09,43.98 108.45,43.98 107.76,44.67 107.76,45.58 107.69,45.66 106.6,45.66 106.47,45.78 106.47,46.47 107.11,47.1 108.31,47.1 108.82,46.6 108.83,46.53 108.86,46.46 108.86,46.33 108.85,46.31 108.84,45.75 109.39,45.63 109.4,45.64 109.47,45.64 109.99,46.16 109.99,46.21 110.06,46.28 110.06,47.04 112.65,49.64 112.65,51.77 112.76,51.87 114.2,51.87
+VTT_DDR on IN2 (solid shape): outline of 1622 points within 55.14,36.26 119.59,58.55
+VTT_DDR on IN3 (solid shape): 106.78,73.36 106.78,71.81 106.51,71.54 105.16,71.54 104.86,71.84 104.86,73.2 105.22,73.57 106.57,73.57
+VTT_DDR on IN3 (solid shape): outline of 381 points within 45.95,36.43 57.51,41
+VTT_DDR on IN4 (solid shape): outline of 4092 points within 21.32,35.94 121.52,69.27
A_DVDD on TOP (solid shape): 5.5,25.63 5.5,25.44 5.44,25.38 5.44,22.62 4.81,21.98 4.81,21.52 4.76,21.47 3.94,21.47 3.92,21.5 3.92,21.95 4.43,22.46 4.43,23.86 4.68,24.11 4.68,25.38 5.06,25.76 5.37,25.76
ACG on TOP (solid shape): 10.15,82.6 10.15,82 10.38,81.77 11.44,81.77 11.52,81.7 11.52,81.26 11.4,81.15 10.31,81.15 9.82,80.66 9.26,80.66 9.1,80.82 9.1,81.54 9.48,81.92 9.48,82.77 9.54,82.82 9.93,82.82
AMP_SPK_LN on BOTTOM (solid shape): 12.14,23.68 12.14,23.12 12.03,23.01 10.42,23.01 10.33,23.1 8.77,23.1 8.75,23.12 8.75,23.69 8.76,23.7 11.28,23.7 11.34,23.77 12.05,23.77
AMP_SPK_LP on BOTTOM (solid shape): 12.15,24.69 12.15,24.15 12.01,24.02 10.54,24.02 10.46,24.1 8.76,24.1 8.74,24.12 8.74,24.7 8.8,24.76 12.07,24.76
AMP_SPK_RN on BOTTOM (solid shape): 12.15,22.73 12.15,22.16 12.01,22.02 10.42,22.02 10.33,22.1 8.78,22.1 8.75,22.13 8.75,22.7 8.76,22.7 10.86,22.7 10.93,22.78 12.09,22.78
AMP_SPK_RP on BOTTOM (solid shape): 11.96,21.74 11.96,21.12 11.8,20.96 11.31,20.96 11.16,21.1 8.76,21.1 8.75,21.11 8.75,21.7 8.76,21.7 10.86,21.7 10.93,21.78 11.92,21.78
BATG on TOP (solid shape): 295.68,13.83 296.44,13.83 296.58,13.68 296.58,13.19 296.51,13.12 295.08,13.12 294.82,13.37 294.82,13.77 294.93,13.88 295.63,13.88
BATSRC on TOP (solid shape): 300.33,13.95 300.33,13.14 300.3,13.11 299.38,13.11 299.18,13.3 299.18,13.84 299.35,14 300.28,14
BOOT_C on TOP (solid shape): 100.83,156.87 100.83,155.64 101.1,155.37 101.1,155.08 101.02,155 100.93,154.94 100.87,154.85 100.68,154.67 99.86,154.67 99.78,154.74 99.78,155.04 99.91,155.17 100.27,155.17 100.56,155.46 100.56,156.86 100.61,156.91 100.79,156.91
CHG_HG on TOP (solid shape): 283.32,24.87 283.32,23.48 283.19,23.35 282.05,23.35 281.29,24.11 281.29,24.49 281.79,25 283.19,25
CHG_LG on TOP (solid shape): 279.76,20.05 279.76,17.76 279.63,17.63 279.13,17.63 279,17.76 279,20.05 279.13,20.17 279.63,20.17
CHG_LX on TOP (solid shape): 287.03,26.42 287.05,26.4 287.1,26.37 287.14,26.34 287.2,26.32 287.25,26.3 287.3,26.3 287.36,26.3 287.41,26.3 287.47,26.32 287.52,26.34 287.56,26.37 287.61,26.4 287.63,26.42 289.87,26.42 290.43,25.86 290.43,21.57 290.18,21.32 275.57,21.32 275.19,21.7 275.19,24.55 281.16,24.55 281.16,24.06 282,23.22 283.24,23.22 283.45,23.42 283.45,24.93 283.24,25.13 281.74,25.13 281.16,24.55 275.19,24.55 275.19,26.01 275.6,26.42
CHG_RC on TOP (solid shape): 282.05,20.94 282.05,19.54 281.92,19.41 281.54,19.41 281.41,19.54 281.41,20.05 281.29,20.17 280.65,20.17 280.65,20.18 280.12,20.18 279.84,20.45 279.84,20.9 280.01,21.06 281.92,21.06
CORE_PLLVDD on TOP (solid shape): outline of 156 points within 135.44,77.26 142.82,79.95
CORE_PLLVDD_GPU on TOP (solid shape): 151.96,92.97 151.96,91.7 151.92,91.65 151.34,91.65 150.98,92.02 150.98,92.72 151.1,92.84 151.27,92.84 151.44,93.01 151.92,93.01
CORE_PLLVDD_GPU on TOP (solid shape): 136.49,80.87 137.67,80.87 137.78,80.76 137.78,80.22 137.64,80.08 135.25,80.08 135.01,80.32 135.01,80.72 135.32,81.03 136.33,81.03
CORE_PLLVDD_GPU on IN4 (solid shape): 152.61,84.11 152.61,84.06 152,83.45 151.62,83.45 151.57,83.5 151.57,84.41 151.62,84.46 152.25,84.46
DDR_BST on TOP (solid shape): 28.96,54.59 28.96,53.15 27.84,52.03 27.84,51.8 27.82,51.77 27.6,51.77 27.6,52.5 28.1,52.99 28.1,54.65 28.26,54.81 28.75,54.81
DDR_BST_R on TOP (solid shape): 31.73,54.34 31.73,53.96 31.53,53.75 31.53,53.63 29.8,53.63 29.8,54.52 29.88,54.59 31.48,54.59
DDR_HG on TOP (solid shape): 26.4,74.43 26.4,73.64 26.14,73.39 25.25,73.39 25.13,73.51 25.13,74.05 25.65,74.57 26.26,74.57
DDR_HG on TOP (solid shape): 29.83,53.19 29.83,52.72 28.46,51.36 28.07,51.36 28.04,51.39 28.04,51.96 28.53,52.45 28.53,52.46 28.82,52.75 29.29,53.22 29.8,53.22
DDR_HG on IN4 (solid shape): 26.44,74.41 26.44,73.42 26.37,73.36 26.32,73.29 26.29,73.26 25.38,73.26 25.24,73.4 25.24,74.18 25.61,74.54 26.3,74.54
DDR_LG on TOP (solid shape): 30.43,51.16 30.43,50.77 29.84,50.46 29.6,50.22 28.81,50.22 28.76,50.27 28.76,50.39 29.05,50.68 29.98,51.42 30.18,51.42
DDR_LG on TOP (solid shape): 33.76,68.69 33.76,66.78 33.76,66.78 33.76,66.3 33.48,66.02 32.89,66.02 32.43,66.48 32.43,67.15 32.67,67.39 32.9,67.39 33,67.49 33,68.69 33.13,68.82 33.64,68.82
DDR_LX on TOP (solid shape): 31.88,53.12 31.88,52.07 31.75,51.94 30.48,51.94 29.43,51.32 28.68,50.57 28.54,50.57 28.48,50.63 28.48,51.08 30.66,53.27 31.73,53.27
DDR_LX on TOP (solid shape): 33.51,74.18 33.51,69.58 33.25,69.32 28.94,69.32 28.43,69.83 26.65,69.83 26.27,69.45 25,69.45 24.75,69.7 24.75,72.5 25,72.75 26.5,72.75 27.02,73.02 26.65,73.48 26.65,74.78 26.02,75.42 26.02,76.99 26.68,77.65 30.03,77.65
DDR_LX on IN4 (solid shape): 30.77,54.03 30.77,52.07 30.49,51.8 30.04,51.8 29.57,52.26 29.57,54.01 29.83,54.26 30.54,54.26
DDR_RC on TOP (solid shape): 28.17,69.32 28.17,68.82 28.05,68.69 27.54,68.69 27.29,68.43 27.29,67.93 27.16,67.8 25.99,67.8 25.86,67.93 25.86,68.59 26.22,68.94 26.4,68.94 26.9,69.45 28.05,69.45
FB_PLL_AVDD on TOP (solid shape): 153.5,59.05 153.5,57.39 153.24,57.13 152.43,57.13 152.27,57.29 152.27,59.03 152.37,59.13 153.42,59.13
FB_PLL_AVDD on TOP (solid shape): 168,84.31 168,83.63 167.44,83.07 167.18,83.07 167.12,83.24 166.99,83.35 166.99,83.53 167.28,83.83 167.28,84.3 167.34,84.36 167.95,84.36
FB_PLL_AVDD on IN3 (solid shape): outline of 611 points within 152.85,57.4 158.47,84.13
FB_PLL_VDD on TOP (solid shape): 150.84,60.8 151,60.7 151.2,60.7 151.46,60.44 151.46,57.58 150.95,57.08 149.57,57.08 149.39,57.26 149.39,60.68 149.51,60.8
FB_REFPLL_AVDD_GPU on TOP (solid shape): 153.75,60.56 153.75,59.62 153.49,59.36 152.33,59.36 152.28,59.4 152.28,60.71 152.44,60.88 153.43,60.88
FB_REFPLL_AVDD_GPU on TOP (solid shape): 162.71,104.15 162.72,104.15 162.89,103.97 163.18,103.97 163.24,103.91 163.24,103.55 163.15,103.46 162.4,103.46 162.27,103.59 162.27,104 162.04,104.23 162.04,104.46 162.11,104.53 162.33,104.53
GPC_PLLVDD on TOP (solid shape): 136.45,83.36 136.54,83.3 136.53,83.19 136.54,82.67 137.06,82.65 137.13,82.67 137.2,82.64 137.64,82.57 137.85,82.96 137.87,83.04 137.95,83.07 138.07,83.09 138.18,83.15 138.29,83.11 138.41,83.1 138.57,83.07 138.73,83.12 138.9,83.02 139.1,83.03 139.34,83.04 139.53,83.2 140.96,83.2 141.1,83.07 141.1,82.28 140.54,81.72 139.76,81.72 139.63,81.59 138.16,81.59 138.08,81.67 137.12,81.67 137.04,81.7 137.02,81.77 136.9,82.07 136.6,82.17 136.56,82.17 136.41,82.15 136.29,82.07 136.15,82.16 135.99,82.18 135.95,82.18 135.81,82.16 135.7,82.09 135.66,82.07 135.62,82.09 135.5,82.16 135.36,82.18 135.34,82.18 135.22,82.16 135.11,82.11 135.01,82.1 134.95,82.19 134.95,83.2 135.11,83.36
HDA_SPKR_RN on BOTTOM (solid shape): 14.78,17.14 15.79,17.14 15.83,17.1 15.83,16.72 15.58,16.47 14.84,16.47 14.69,16.31 14.18,16.31 14.08,16.42 14.08,17.05 14.2,17.18 14.74,17.18
HG_C on TOP (solid shape): 100.13,161.3 100.13,160.75 99.82,160.43 99.29,160.43 99.04,160.18 99.04,159.77 98.02,158.76 97.09,158.76 97.03,158.81 97.03,159.7 97.09,159.75 97.8,159.75 98.08,160.03 98.08,160.43 99.25,161.6 99.83,161.6
IFP_IOVDD on TOP (solid shape): 144.34,92.34 145.45,92.34 145.6,92.19 146.52,92.19 146.56,92.23 146.61,92.19 146.81,92.19 146.88,92.18 146.94,92.19 147.43,92.19 147.44,92.18 147.56,92.15 147.68,92.16 147.69,92.16 148.81,92.16 148.95,92.3 149,92.3 149.19,92.26 149.38,92.34 150.26,92.34 150.38,92.27 150.51,92.26 150.54,92.26 151.31,91.48 151.95,91.48 152.06,91.37 152.06,85.83 151.92,85.69 151.52,85.69 151.33,85.89 150.94,85.89 150.87,85.95 150.87,86.37 150.58,86.67 150.27,86.67 150.1,86.85 150.1,87.16 150.16,87.23 150.85,87.23 150.93,87.31 150.93,87.92 150.98,87.98 150.98,88.29 151.02,88.31 151.15,88.81 150.65,88.92 150.56,88.85 150.5,88.77 150.49,88.74 150.29,88.74 150.15,88.88 150.15,89.13 150.25,89.24 150.72,89.24 150.92,89.43 150.92,89.89 151.11,90.08 151.11,90.39 151.14,90.91 150.61,90.89 150.35,90.89 150.12,91.12 150.12,91.31 149.79,91.64 149.41,91.64 149.38,91.68 146.03,91.68 145.96,91.75 144.27,91.75 143.94,91.42 143.94,86.96 143.85,86.86 143.42,86.86 143.39,86.89 143.39,92.43 143.43,92.47 144.2,92.47
IFP_PLLVDD on TOP (solid shape): outline of 333 points within 134.92,82.28 142.98,86.65
IFPAB_PLLVDD_R on TOP (solid shape): 149.93,90.6 149.93,89.59 149.79,89.45 149.35,89.45 149.2,89.59 145.86,89.59 145.79,89.53 144.7,89.53 144.68,89.52 144.46,89.52 144.46,89.14 144.46,86.86 144.46,86.86 144.46,86.1 144.46,86.09 144.46,85.9 143.95,85.39 143.66,85.39 143.54,85.5 143.54,86.22 143.55,86.23 143.55,86.53 143.69,86.67 143.96,86.67 144.07,86.78 144.07,87.93 144.07,87.93 144.07,88.18 144.07,88.18 144.07,89.33 144.07,89.33 144.07,89.71 144.07,89.71 144.07,89.99 144.23,90.14 144.55,90.14 144.71,90.05 144.89,90.06 145.01,90.12 145.1,90.23 146.58,90.23 146.71,90.08 146.91,90.03 147.05,90.07 147.17,90.16 147.25,90.19 147.6,90.03 147.88,90.16 147.95,90.2 148.03,90.17 148.1,90.11 148.19,90.07 148.39,90.08 148.55,90.18 148.63,90.22 148.71,90.18 149.13,90.06 149.34,90.45 149.33,90.51 149.3,90.57 149.3,90.67 149.39,90.72 149.41,90.72 149.42,90.73 149.8,90.73
IFPCD_PLLVDD_R on TOP (solid shape): 149.98,88.42 149.98,87.61 149.75,87.38 149.33,87.38 149.2,87.51 146.01,87.51 145.65,87.15 145.65,86.96 145.45,86.77 145.43,86.77 145.06,86.59 145.1,86.18 145.1,85.62 144.09,84.6 144.09,83.71 143.87,83.5 143.57,83.5 143.53,83.54 143.53,84.49 143.52,84.49 143.52,84.89 143.83,85.2 144.08,85.2 144.15,85.26 144.15,85.41 144.21,85.47 144.21,85.47 144.59,85.85 144.59,86.14 144.59,86.15 144.59,87.06 145.65,88.12 146.59,88.12 146.87,87.95 147.18,88.08 147.26,88.12 147.34,88.09 147.61,87.95 147.88,88.07 147.95,88.1 148.03,88.07 148.3,87.96 148.56,88.09 148.64,88.12 148.72,88.08 149.19,87.99 149.32,88.46 149.32,88.56 149.41,88.61 149.79,88.61
IFPCDEF_PLLVDD_R on TOP (solid shape): 149.89,86.35 149.89,85.29 149.75,85.14 149.08,85.14 149.01,85.15 148.93,85.14 147.04,85.14 147.03,85.15 146.9,85.17 146.77,85.15 146.76,85.14 146.12,85.14 146.04,85.07 145.98,85.02 145.93,84.96 145.72,84.75 145.72,84.56 145.68,84.48 145.59,84.47 145.44,84.48 145.29,84.44 145.25,84.43 145.22,84.45 144.69,84.54 144.69,84 144.69,83.07 143.87,82.25 143.44,82.25 143.37,82.32 143.37,83.2 143.44,83.27 143.95,83.27 143.95,83.27 144.15,83.27 144.22,83.34 144.22,83.97 144.22,83.98 144.22,84.55 145.12,85.45 146.65,85.45 146.65,85.46 146.69,85.46 147.09,85.86 147.47,85.86 147.48,85.86 147.61,85.84 147.74,85.86 147.74,85.86 148.86,85.86 148.87,85.86 149.25,85.93 149.34,86.3 149.34,86.31 149.34,86.36 149.43,86.45 149.79,86.45
LAN_GND on TOP (solid shape): 310.62,138.95 310.62,137.9 310.37,137.65 310.04,137.65 305.87,141.82 305.87,142.11 306.13,142.36 307.21,142.36
LAN_GND on TOP (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.38,137.87 312.47,137.12 312.95,136.67 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.88,136.59 318.88,136.13 316.59,136.13 316.59,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.59,155.21 316.59,155.68 318.88,155.68 318.88,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on BOTTOM (solid shape): 300.21,155.46 300.21,144.33 301.09,143.45 305.13,143.45 307.45,141.13 308.16,141.13 310.75,138.54 310.75,137.75 310.55,137.55 310.07,137.55 309.35,138.27 309.34,138.27 308.67,138.94 308.67,138.94 307.99,139.63 307.98,139.63 307.53,140.08 307.53,140.08 306.74,140.88 306.74,140.88 306.28,141.33 306.28,141.34 304.76,142.86 300.31,142.86 299.19,143.98 299.19,148.17 299.46,148.44 299.46,149.56 299.45,149.56 299.45,149.71 299.19,149.97 299.19,155.58 299.35,155.73 299.93,155.73
LAN_GND on BOTTOM (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.38,137.87 312.47,137.12 312.95,136.67 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.88,136.59 318.88,136.13 316.46,136.13 316.46,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.46,155.21 316.46,155.68 318.88,155.68 318.88,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on GND1 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on IN1 (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.55,138.21 312.37,137.85 312.64,136.89 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.5,136.59 318.5,136.13 316.85,136.13 316.85,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.85,155.21 316.85,155.68 318.5,155.68 318.5,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on GND2 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on IN2 (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.55,138.21 312.37,137.85 312.64,136.89 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.5,136.59 318.5,136.13 316.85,136.13 316.85,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.85,155.21 316.85,155.68 318.5,155.68 318.5,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on GND3 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on VCC1 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on VCC2 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on GND4 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on IN3 (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.55,138.21 312.37,137.85 312.64,136.89 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.5,136.59 318.5,136.13 316.85,136.13 316.85,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.85,155.21 316.85,155.68 318.5,155.68 318.5,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on GND5 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LAN_GND on IN4 (solid shape): 322.14,154.71 314.22,154.71 313.96,155 313.6,155.18 312.64,154.91 312.37,153.95 312.55,153.59 312.84,153.33 312.84,138.47 312.55,138.21 312.37,137.85 312.64,136.89 313.6,136.62 313.96,136.8 314.22,137.09 322.14,137.09 322.14,135.62 321.64,135.62 321.64,136.59 318.5,136.59 318.5,136.13 316.85,136.13 316.85,136.59 314.47,136.59 312.28,136.53 312.34,138.72 312.34,153.08 312.28,155.27 314.47,155.21 316.85,155.21 316.85,155.68 318.5,155.68 318.5,155.21 321.64,155.21 321.64,156.32 322.14,156.32
LAN_GND on GND6 (solid shape): 322.14,154.71 314.22,154.71 312.64,154.91 312.84,153.33 312.84,138.47 312.64,136.89 314.22,137.09 322.14,137.09 322.14,135.62 312,135.62 304.76,142.86 300.31,142.86 299.19,143.98 299.19,155.58 299.93,156.32 322.14,156.32
LG_C on TOP (solid shape): 102.54,159.51 102.54,158.55 102.21,158.22 101.65,158.22 101.58,158.29 101.58,159.45 101.77,159.64 102.4,159.64
LG_C on TOP (solid shape): 89.9,155.3 91.34,155.3 91.38,155.26 91.38,154.58 91.25,154.45 88.62,154.45 88.22,154.85 88.22,155.38 88.43,155.59 89.62,155.59
PEX_VDD on TOP (solid shape): 126.84,130.44 127.87,130.44 128.48,129.84 128.48,125.12 128.37,125.02 126.1,125.02 125.12,124.04 123.88,124.04 123.79,124.13 123.79,132.61 123.87,132.69 124.59,132.69
PEX_VDD on TOP (solid shape): 151.3,101.05 151.3,100.16 151.42,100.03 151.98,100.03 152.03,99.98 152.03,98.73 151.86,98.56 151.19,98.56 150.53,97.9 149.67,97.9 149.56,98.01 149.56,98.57 149.44,98.68 149.44,99.07 149.48,99.15 149.99,99.3 149.96,99.75 149.87,99.83 149.8,99.87 149.71,99.96 149.71,100.41 149.61,100.51 149.59,100.51 149.44,100.67 149.44,100.97 149.59,101.12 151.22,101.12
PEX_VDD on TOP (solid shape): 141.59,90.74 141.7,90.74 141.71,90.74 141.84,90.71 141.97,90.74 141.98,90.74 142.56,90.74 142.6,90.7 142.6,86.95 142.55,86.9 141.4,86.9 140.18,88.12 137.17,88.12 136.13,87.08 136.13,85.83 135.87,85.58 135.32,85.58 135.15,85.75 135.15,88.88 135.3,89.03 136.96,89.03 137.96,90.02 138.08,90.02 138.11,90 138.77,89.82 138.54,90.45 138.54,90.6 139.18,91.24 141.09,91.24
PEX_VDD on BOTTOM (solid shape): 128.51,129.45 128.51,125.5 128.23,125.22 127.1,125.22 126.73,125.58 121.14,125.58 120.88,125.84 120.88,129.42 121.25,129.79 128.17,129.79
PEX_VDD on IN1 (solid shape): outline of 4323 points within 126.69,92.86 151.75,131.28
PEX_VDD on IN4 (solid shape): outline of 375 points within 133.14,90.42 142.53,96.78
PH1_A on BOTTOM (solid shape): 78.97,158.73 78.97,151.62 77.7,150.35 77.7,149.08 75.8,147.17 75.8,144.13 75.29,143.62 71.86,143.62 71.61,143.87 71.61,145.78 71.86,145.78 71.86,145.04 71.89,145.02 72.07,145.02 72.09,145.04 72.09,145.78 72.37,145.78 72.37,145.04 72.4,145.02 72.55,145.02 72.57,145.04 72.57,145.78 72.96,145.78 73.02,145.84 73.02,146.34 73.79,146.34 73.82,146.36 73.82,146.51 73.79,146.54 73.02,146.54 73.02,146.82 73.79,146.82 73.82,146.84 73.82,147.02 73.79,147.05 73.02,147.05 73.02,147.33 73.79,147.33 73.82,147.35 73.82,147.53 73.79,147.56 73.02,147.56 73.02,147.84 73.79,147.84 73.82,147.86 73.82,148.01 73.79,148.04 73.02,148.04 73.02,148.32 73.79,148.32 73.82,148.34 73.82,148.52 73.79,148.55 73.02,148.55 73.02,148.83 73.79,148.83 73.82,148.85 73.82,149.03 73.79,149.05 73.02,149.05 73.02,149.33 73.79,149.33 73.82,149.36 73.82,149.51 73.79,149.54 73.02,149.54 73.02,149.85 74.28,151.11 74.28,152.38 74.53,152.64 75.8,152.64 76.31,153.14 76.31,158.73 76.69,159.11 78.59,159.11
PH1_B on TOP (solid shape): 51.2,169.99 51.2,169.73 50.43,169.73 50.4,169.7 50.4,169.55 50.43,169.53 51.2,169.53 51.2,169.25 50.43,169.25 50.4,169.22 50.4,169.04 50.43,169.02 51.2,169.02 51.2,168.74 50.43,168.74 50.4,168.71 50.4,168.54 50.43,168.51 51.2,168.51 51.2,168.23 50.43,168.23 50.4,168.21 50.4,168.05 50.43,168.03 51.2,168.03 51.2,167.75 50.43,167.75 50.4,167.72 50.4,167.55 50.43,167.52 51.2,167.52 51.2,167.24 50.43,167.24 50.4,167.22 50.4,167.04 50.43,167.01 51.2,167.01 51.2,166.73 50.43,166.73 50.4,166.71 50.4,166.55 50.43,166.53 51.2,166.53 51.2,166.19 51.36,166.03 51.64,166.03 51.64,165.26 51.67,165.23 51.82,165.23 51.85,165.26 51.85,166.03 52.13,166.03 52.13,165.26 52.15,165.23 52.33,165.23 52.36,165.26 52.36,166.03 52.64,166.03 52.64,165.04 50.6,163 50.6,159.98 50.65,159.93 50.65,157.08 50.4,156.83 48.37,156.83 48.11,157.08 48.11,169.81 48.37,170.06 51.12,170.06
PH2_A on BOTTOM (solid shape): 77.07,177.25 77.07,177.02 76.33,177.02 76.31,176.99 76.31,176.82 76.33,176.79 77.07,176.79 77.07,176.51 76.33,176.51 76.31,176.49 76.31,176.33 76.33,176.31 77.07,176.31 77.07,176 77.22,175.85 77.6,175.85 77.63,175.83 77.63,175.09 77.65,175.06 77.81,175.06 77.83,175.09 77.83,175.85 78.11,175.85 78.11,175.09 78.14,175.06 78.31,175.06 78.34,175.09 78.34,175.85 78.62,175.85 78.62,175.09 78.64,175.06 78.82,175.06 78.85,175.09 78.85,175.85 79.13,175.85 79.13,175.09 79.15,175.06 79.31,175.06 79.33,175.09 79.33,175.85 79.61,175.85 79.61,175.09 79.64,175.06 79.81,175.06 79.84,175.09 79.84,175.85 80.12,175.85 80.12,175.09 80.14,175.06 80.32,175.06 80.35,175.09 80.35,175.85 80.63,175.85 80.63,175.09 80.65,175.06 80.8,175.06 80.83,175.09 80.83,175.85 82.38,175.85 82.78,176.26 83.29,176.26 83.42,176.13 83.42,174.23 83.01,173.82 80.85,173.82 79.02,171.98 79.02,168.88 78.9,168.76 76.69,168.76 76.43,169.02 76.43,170.67 75.04,172.07 75.04,177.02 75.29,177.27 77.04,177.27
PH2_B on TOP (solid shape): outline of 81 points within 62.05,158.35 68.21,168.47
PH3_A on BOTTOM (solid shape): 76.31,167.37 78.72,167.37 78.97,167.11 78.97,160.13 78.59,159.75 75.22,159.75 74.53,160.43 74.53,162.19 74.3,162.41 72.88,162.41 71.86,163.43 71.86,164.32 72.12,164.32 72.12,163.58 72.13,163.57 72.31,163.57 72.35,163.61 72.35,164.35 72.62,164.35 72.62,163.6 72.65,163.57 72.79,163.57 72.83,163.61 72.83,164.37 73.18,164.37 73.29,164.47 73.29,164.85 73.31,164.88 74.05,164.88 74.07,164.9 74.07,165.06 74.05,165.08 73.29,165.08 73.29,165.36 74.05,165.36 74.07,165.39 74.07,165.56 74.05,165.59 73.29,165.59 73.29,165.87 74.05,165.87 74.07,165.89 74.07,166.07 74.05,166.1 73.29,166.1 73.29,166.38 74.05,166.38 74.07,166.4 74.07,166.55 74.05,166.58 73.29,166.58 73.29,166.86 74.05,166.86 74.07,166.89 74.07,167.06 74.05,167.09 73.29,167.09 73.29,167.37 74.05,167.37 74.07,167.39 74.07,167.57 74.05,167.6 73.29,167.6 73.29,167.88 74.05,167.88 74.07,167.9 74.07,168.05 74.05,168.08 73.41,168.08 73.39,168.1 73.39,168.38 75.29,168.38
PH_C on TOP (solid shape): 96.73,159.72 96.73,158.43 97.03,158.12 98.13,158.12 98.69,158.68 100.24,158.68 100.32,158.6 100.32,158.32 100.27,158.27 99.92,158.27 99.28,157.63 99.28,157.25 99.23,157.2 98.68,157.2 98.35,156.87 98.34,156.87 98.01,156.54 98,156.54 97.81,156.43 97.7,156.23 97.7,156.22 96.96,155.48 96.96,153.99 94.61,151.64 93.27,151.64 92.82,151.19 92.82,147.78 92.54,147.5 90.77,147.5 90.47,147.81 90.47,153.03 92.02,154.58 92.02,157.5 92.84,158.33 92.84,159.49 93.1,159.75 96.7,159.75
PS_NVVDD_PHASE1 on TOP (solid shape): 181.06,165.13 181.06,164.55 181.16,164.45 182.77,164.45 182.82,164.4 182.82,164.29 182.74,164.21 181.63,164.21 181.13,163.71 181.13,163.51 181.1,163.47 180.27,163.47 180.12,163.62 180.12,165.16 180.17,165.21 180.98,165.21
PS_NVVDD_PHASE1 on TOP (solid shape): outline of 130 points within 171.68,167.95 185.46,181.34
PS_NVVDD_PHASE1 on BOTTOM (solid shape): 185.46,176.55 185.46,172.29 184.67,171.49 184.67,167.97 184.27,167.58 175.5,167.58 174.84,168.24 174.84,176.24 175.47,176.87 185.14,176.87
PS_NVVDD_PHASE2 on TOP (solid shape): 143.37,165.16 143.37,165.05 143.29,164.97 142.19,164.97 141.69,164.47 141.69,164.27 141.65,164.23 140.82,164.23 140.82,164.9 141.13,165.21 143.32,165.21
PS_NVVDD_PHASE2 on TOP (solid shape): 136.99,174.69 136.99,173.7 142.02,168.67 142.02,167.63 141.16,166.78 132.14,166.78 127.92,171 127.92,172.33 130.21,172.33 130.21,172.28 130.23,172.22 130.25,172.17 130.28,172.12 130.31,172.08 130.35,172.04 130.4,172.01 130.45,171.99 130.5,171.97 130.56,171.96 130.62,171.96 130.67,171.97 130.72,171.99 130.77,172.01 130.82,172.04 130.86,172.08 130.9,172.12 130.93,172.17 130.95,172.22 130.96,172.28 130.97,172.33 130.97,172.39 130.96,172.44 130.94,172.5 130.91,172.55 130.88,172.59 130.84,172.63 130.8,172.66 130.75,172.69 130.7,172.71 130.64,172.72 130.59,172.73 130.53,172.72 130.48,172.71 130.43,172.69 130.38,172.66 130.33,172.63 130.29,172.59 130.26,172.55 130.24,172.5 130.22,172.44 130.21,172.39 130.21,172.33 127.92,172.33 127.92,174.42 128.23,174.73 131.07,174.73 131.3,174.51 131.3,172.98 131.73,172.55 132.39,172.55 132.53,172.69 132.54,172.69 133.02,173.17 133.02,174.26 133.52,174.76 136.92,174.76
PS_NVVDD_PHASE2 on BOTTOM (solid shape): 146.63,175.73 147.71,175.73 147.79,175.64 147.79,173.55 145.26,171.02 145.26,168.62 144.2,167.56 138.5,167.56 137.89,166.96 135.79,166.96 135.54,167.21 135.54,176.33 135.93,176.72 145.64,176.72
PS_NVVDD_PHASE3 on TOP (solid shape): 157.8,165.16 157.8,165.05 157.72,164.97 156.61,164.97 156.12,164.47 156.12,164.27 156.08,164.23 155.25,164.23 155.25,164.9 155.56,165.21 157.75,165.21
