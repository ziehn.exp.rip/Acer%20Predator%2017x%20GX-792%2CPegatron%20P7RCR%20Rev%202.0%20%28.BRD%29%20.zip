# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
VX_WTOB_4P_49_2HOLD_RA
  rect 0.787x1.803 smd: 1(1.875,3.948) 2(0.625,3.948) 3(-0.625,3.948) 4(-1.875,3.948)
  rect 2.007x2.489 smd: 5(-4.075,0) 6(4.075,0)
VX_WTOB_5P_39_2HOLD_ENTE
  rect 0.61x1.549 smd: 1(2,2.425) 2(1,2.425) 3(0,2.425) 4(-1,2.425) 5(-2,2.425)
  rect 1.194x2.007 smd: 6(-3.3,0) 7(3.3,0)
VX_WTOB_10P_59_4HOLD_RA_TYU
  rect 0.838x2.21 smd: 1(6.75,0.9) 2(5.25,0.9) 3(3.75,0.9) 4(2.25,0.9) 5(0.75,0.9) 6(-0.75,0.9) 7(-2.25,0.9) 8(-3.75,0.9) 9(-5.25,0.9) 10(-6.75,0.9)
  rect 0.66x1.295 smd: 11(8.125,0) 12(-8.125,0)
  rect 0.66x2.489 smd: 13(8.125,-2.65) 14(-8.125,-2.65)
VX_WTOB_10P_79_2HD_RA_CUIL
  rect 0.559x1.803 smd: 1(9,5.275) 2(7,5.275) 3(5,5.275) 4(3,5.275) 5(1,5.275) 6(-1,5.275) 7(-3,5.275) 8(-5,5.275) 9(-7,5.275) 10(-9,5.275)
  rect 1.295x2.057 smd: 11(12.1,0) 12(-12.1,0)
VX_WTOB_20P_20_6HOLD_ENTERY
  round 0.914 hole 0.914 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(4.75,2.125) 2(4.25,2.125) 3(3.75,2.125) 4(3.25,2.125) 5(2.75,2.125) 6(2.25,2.125) 7(1.75,2.125) 8(1.25,2.125) 9(0.75,2.125) 10(0.25,2.125) 11(-0.25,2.125) 12(-0.75,2.125) 13(-1.25,2.125) 14(-1.75,2.125) 15(-2.25,2.125) 16(-2.75,2.125) 17(-3.25,2.125) 18(-3.75,2.125) 19(-4.25,2.125) 20(-4.75,2.125)
  rect 1.295x1.397 smd: 21(5.8,2) 22(-5.8,2) 23(5.8,-2) 24(-5.8,-2)
VX_WTOB_40P_20_6HD_STAR
  round 0.864 hole 0.864 unplated: (-10.5,0) (10.5,0)
  rect 0.305x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
VX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
VX_XTAL_4P_126X98_RAK
  rect 1.397x1.143 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
VX_XTAL_4P_126X98_TXC_H35
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
VX_XTAL_4P_272X55
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
1.0VSUS_BST: R8200.2 U8200.10(BST)
1.0VSUS_BST_R: C8207.2 R8200.1
1.0VSUS_EN: C8205.1 D8200.1(ANODE) R8201.2 U8200.15(EN2)
1.0VSUS_FB: R8205.2 R8206.1 R8207.2 U8200.13(FB)
1.0VSUS_FB_R: JP8200.1 R8205.1
1.0VSUS_LX: C8207.1 L8200.1 R8202.2 R8208.1 T8200.1 U8200.9(SW)
1.0VSUS_RC: C8208.1 R8202.1
1.5VS_EN: C8402.1 R8402.2 U8400.3(SHDN#)
1.5VS_FB: C8400.2 R8401.1 R8403.2 U8400.4(SET)
1.5VS_IN: C8404.1 SR8400.1 U8400.1(IN)
1.8VO_VGA_BST: R8607.2 U8601.10(BST)
1.8VO_VGA_EN: C8607.1 D8601.1(ANODE) R8602.2 U8601.13(EN)
1.8VO_VGA_FB: R8601.1 R8604.2 R8605.1 U8601.12(FB)
1.8VO_VGA_FB_R: C8605.1 JP8601.1 R8604.1
1.8VO_VGA_LX: C8604.1 L8601.2 R8603.2 R8606.2 T8606.1 U8601.8(SW1) U8601.9(SW2) U8601.15(SW3) U8601.16(SW4)
1.8VO_VGA_RC: C8610.1 R8603.1
1.8VO_VGA_VOUT: C8611.1 JP8603.1 U8601.7(VOUT)
1V0_VGA_BST: R9603.2 U9600.10(BST)
1V0_VGA_BST_R: C9609.2 R9603.1
1V0_VGA_EN: C9603.1 D7407.2(CATHODE) D9600.1(ANODE) R9602.2 U9600.13(EN)
1V0_VGA_FB: R9604.2 R9605.1 R9606.2 U9600.12(FB)
1V0_VGA_FB_R: C9601.1 JP9601.1 R9606.1
1V0_VGA_FB_R1: C9601.2 R9600.1 R9605.2
1V0_VGA_LX: C9609.1 L9600.2 R9600.2 R9601.2 T9603.1 U9600.8(SW1) U9600.9(SW2) U9600.15(SW3) U9600.16(SW4)
1V0_VGA_RC: C9611.1 R9601.1
1V0_VGA_VOUT: C9608.1 JP9602.1 U9600.7(VOUT)
1V8_AON_EN: D7401.3(CATHODE) D8601.2(CATHODE) R7484.1 R8602.1
1V8_MAIN_EN: D7403.1(ANODE1) D7404.1(ANODE) D7405.2(ANODE2) D7406.1(ANODE1) R74109.1 U7411.4(Y) U7416.2(B)
1V8_MAIN_EN_G: R7491.2 U7410.3(D) U7411.2(B)
1V8_MAIN_PG: D7401.2(ANODE2) R7487.2 U7409.3(D) U7414.1(A)
2.5VO_BST: R9500.2 U9500.10(BST)
2.5VO_EN: C9511.1 R9503.2 SR9500.2 U9500.13(EN)
2.5VO_FB: R9504.1 R9505.2 R9506.2 U9500.12(FB)
2.5VO_VOUT: C9503.1 JP9502.1 U9500.7(VOUT)
3V_BST: SR8101.2 U8100.9(VBST2)
3V_BST_R: C8108.2 SR8101.1
3V_FB: C8114.1 R8105.2 R8107.2 U8100.4(VFB2)
3V_FB_R: C8114.2 C8116.2 JP8105.1 R8105.1
3V_HG: Q8104.4(G) T8103.1 U8100.10(DRVH2)
3V_LG: Q8103.4(G) T8101.1 U8100.11(DRVL2)
3V_LX: C8108.1 L8101.1 Q8103.5(D) Q8104.1(S_1) Q8104.2(S_2) Q8104.3(S_3) R8101.2 T8105.1 U8100.8(SW2)
3V_RC: C8112.1 R8101.1
5V_BST: SR8100.1 U8100.17(VBST1)
5V_BST_R: C8107.1 SR8100.2
5V_FB: C8113.2 R8104.2 R8106.2 U8100.2(VFB1)
5V_FB_R: C8113.1 C8115.1 JP8103.2 R8104.1
5V_HG: Q8102.4(G) T8102.1 U8100.16(DRVH1)
5V_LG: Q8101.4(G) T8106.1 U8100.15(DRVL1)
5V_LX: C8107.2 L8100.2 Q8101.5(D) Q8102.1(S_1) Q8102.2(S_2) Q8102.3(S_3) R8100.2 T8104.1 U8100.18(SW1)
5V_RC: C8111.1 R8100.1
5V_VO1: JP8104.2 U8100.14(VO1)
+0.6VO: C8300.1 C8301.1 C8302.1 C8327.1 C8328.1 JP8300.1 JP8301.2 T8308.1 T8309.1 T8310.1 U8300.20(VTT)
+1.0V: C1003.2 C1006.2 C9101.1 C9136.1 R0707.1 R0708.2 R0729.2 R0738.1 R0739.1 R0747.1 R2450.1 R4427.1 R4428.1 T9100.1 U0300.H28(VCCPLL_1) U0300.H30(VCCST) U0300.J28(VCCPLL_2) U9100.14(OUT1)
+1.0VO: C8209.1 C8210.1 C8211.1 C8212.1 C8213.1 C8216.1 C9107.1 JP8200.2 JP8202.2 L8200.2 T8201.1 U8200.6(VDDQ) U9100.1(IN1) U9100.7(IN2)
+1.0VO_VGA: C9600.1 C9602.1 C9607.1 C9613.1 C9614.1 JP9600.1 JP9601.2 JP9602.2 L9600.1 T9602.1
+1.0VO_VGA_PWRGD: D7402.2(ANODE2) D7406.2(ANODE2) D7407.1(ANODE) R7411.2 R9207.1 T9208.1 U9600.4(PG)
+1.0VS: C1004.1 C1005.1 C9110.1 R0706.2 T9102.1 U0300.G30(VCCSTG_1) U0300.H29(VCCSTG_2) U9100.8(OUT2)
+1.0VSUS: C2608.1 C2609.1 C80134.1 JP2601.2 JP2602.1 JP8202.1 L2602.1 L2603.1 R2512.2 R2607.1 R2611.1 R4410.1 R80147.1 R80148.1 R80149.1 R80150.1 SR2602.1 SR2604.1 SR4401.1 SR4402.1 T4401.1 T8202.1 T8204.1 U2000.N17(VCCCLK1) U2000.R17(VCCCLK2_1) U2000.R19(VCCCLK3) U2000.U20(VCCCLK4) U2000.U21(VCCMPHY_1P0_1) U2000.U23(VCCMPHY_1P0_2) U2000.U25(VCCMPHY_1P0_3) U2000.U26(VCCMPHY_1P0_4) U2000.V17(VCCCLK2_2) U2000.V26(VCCMPHY_1P0_5)
+1.0VSUS_PWRGD: SR9210.1 T9210.1 U8200.12(PG)
+1.2VO_DDR: C8311.1 C8312.1 C8313.1 C8315.1 C8316.1 C8317.1 CE8301.1 JP8302.1 JP8303.1 JP8304.1 JP8305.1 JP8306.1 JP8307.1 L8300.2 SR8300.1 T8302.1 T8303.1 T8304.1
+1.5VO: C8400.1 C8401.1 D8804.1(ANODE) JP8400.1 R8401.2 T8400.1 U8400.5(OUT)
+1.5VS: JP8400.2 L3600.1
+1.8VO_VGA: C8603.1 C8606.1 C8608.1 C8609.1 C8616.1 JP8601.2 JP8602.1 JP8603.2 L8601.1 Q9107.3(DRAIN) R9712.2 R9714.2 R9719.2 T8604.1 T8609.1 T8610.1
+1.8VO_VGA_PWRGD: R7469.1 R9216.1 T9213.1 U8601.4(PG)
+1V8_AON: C7601.1 C7602.1 C7634.1 C7635.1 C7661.1 C7662.1 C7701.1 C7702.1 C7735.1 C7736.1 C7761.1 C7762.1 C7801.1 C7802.1 C7834.1 C7837.1 C7861.1 C7862.1 C7901.1 C7902.1 C7934.1 C7937.1 C7961.1 C7962.1 C8614.1 C8615.1 C75156.1 C75157.1 C75158.1 C75159.1 JP8602.2 R5734.2 R5735.2 R7001.1 R7205.1 R7208.2 R7414.1 R7419.1 R7423.1 R7437.1 R7438.1 R7439.1 R7440.2 R7443.1 R7444.1 R7445.1 R7449.1 R7450.1 R7457.1 R7458.1 R7460.1 R7466.1 R7475.1 R7477.1 R7497.1 R8902.1 R9701.1 R9724.1 R74101.1 R74103.1 R74107.2 R74108.2 SR7401.1 SR7402.1 T8602.1 T8605.1 T8607.1 U7000.BA10(1V8_AON_1) U7000.BB14(1V8_AON_2) U7000.BC14(1V8_AON_3) U7002.5(VCC) U7003.5(VCC) U7412.5(VCC) U7413.5(G) U7417.2(G) U7600.A3(VPP_1) U7600.W3(VPP_2) U7601.A3(VPP_1) U7601.W3(VPP_2) U7700.A3(VPP_1) U7700.W3(VPP_2) U7701.A3(VPP_1) U7701.W3(VPP_2) U7800.A3(VPP_1) U7800.W3(VPP_2) U7801.A3(VPP_1) U7801.W3(VPP_2) U7900.A3(VPP_1) U7900.W3(VPP_2) U7901.A3(VPP_1) U7901.W3(VPP_2)
+1V8_MAIN: C7006.1 C7008.1 C7013.1 C7016.1 C7017.1 C7018.1 C7053.1 C7055.1 C9135.1 L7100.2 L7201.1 L7202.1 L7205.1 Q9107.2(SOURCE) R5738.2 R5739.2 R7462.1 R7463.1 R7488.1 R7505.1 R74100.1 SR7002.2 T9115.1 U7000.BB26(PEX_HVDD_1) U7000.BB27(PEX_HVDD_2) U7000.BB29(PEX_HVDD_3) U7000.BB32(PEX_HVDD_4) U7000.BC26(PEX_HVDD_5) U7000.BC27(PEX_HVDD_6) U7000.BC29(PEX_HVDD_7) U7000.BC30(PEX_HVDD_8) U7000.BC32(PEX_HVDD_9) U7000.BD27(PEX_HVDD_10) U7000.BD30(PEX_HVDD_11) U7001.2(G)
+1V_DCPDSW: C2622.1 U2000.BA29(DCPDSW_1P0)
+1V_PRIM_W12MIL: C2600.1 C2601.1 JP2601.1 JP2602.2 U2000.AA23(VCCPRIM_1P0_3) U2000.AA26(VCCPRIM_1P0_4) U2000.AA28(VCCPRIM_1P0_5) U2000.AC17(VCCPRIM_1P0_6) U2000.AC23(VCCPRIM_1P0_7) U2000.AC26(VCCPRIM_1P0_8) U2000.AC28(VCCPRIM_1P0_9) U2000.AD15(VCCPRIM_1P0_10) U2000.AE23(VCCPRIM_1P0_11) U2000.AE26(VCCPRIM_1P0_12) U2000.AJ20(VCCPRIM_1P0_13) U2000.AJ21(VCCPRIM_1P0_14) U2000.AJ23(VCCPRIM_1P0_15) U2000.AJ25(VCCPRIM_1P0_16) U2000.AL22(VCCPRIM_1P0_17) U2000.Y23(VCCPRIM_1P0_1) U2000.Y25(VCCPRIM_1P0_2)
+2.5V_PWRGD: SR9207.1 T9200.1 U9500.4(PG)
+2.5VO: C9506.1 C9507.1 C9508.1 C9509.1 C9510.1 JP9500.2 JP9501.2 JP9502.2 L9500.1 T9503.1
+3V: C4400.1 C9119.1 CON4400.10 CON4400.12 T9105.1 U9102.14(OUT1)
+3V3_FLASH: C1129.1 C1206.1 R1103.2 R1104.2 R1105.2 R1106.2 R1155.2 R1223.1 R1224.1 R1225.1 U1103.8(VCC) U1201.G1(LDO_3V3)
+3V3_MAIN: C9133.1 C9716.1 C9719.1 Q7204.1(GATE) Q7205.1(GATE) Q7401.1(GATE) Q7402.1(GATE) Q9105.2(SOURCE) R1301.1 R1408.1 R5719.1 R7216.1 R7217.1 R7218.1 R7225.1 R7226.1 R7230.1 R7405.2 R7406.2 R7407.2 R7408.2 R7409.2 R7410.2 R7411.1 R7495.2 R8701.1 R8702.1 R8703.1 R9707.2 SR7417.1 T9114.1 U9702.4(VS) U9702.16(VPU)
+3V3_MAIN_EN: R74110.2 SR5706.1 SR9104.1 U7414.4(Y)
+3V3_MAIN_PG: C7410.1 D7405.1(ANODE1) SR7417.2 U7416.1(A)
+3V3_TBTA_SX: C1205.1 U1201.H2(VOUT_3V3)
+3V_WLAN: C5300.1 C5303.1 C5306.2 C5307.1 CON5300.2 CON5300.4 CON5300.72 CON5300.74 L5300.2 L5302.2 R5300.1 R5305.2 R5306.2 R5308.1 R5349.2 R5354.2
+3VA: CON5602.20 D6005.2(CATHODE) D6006.2(CATHODE) JP8106.2 JP9300.1 JP9301.1 JP9302.1 JP9303.1 R2619.2 R4412.1 R4592.1 R5704.1 R5707.1 R5709.1 R5712.1 R5715.1 R5723.1 R5727.1 R5736.1 R5740.1 R5744.1 R6001.1 R8811.2 SR3001.1 SR8102.2 T8121.1
+3VA_EC: C3000.1 C3001.1 C3002.1 C3003.1 C3004.1 C3019.1 C3020.1 C3023.1 C3024.1 C3025.1 D5004.1(CATHODE1) R3001.1 R3005.1 R3010.1 R3025.1 R3027.1 R3031.1 R3042.1 R3053.1 R3061.1 R3065.1 R3070.1 R3071.1 R5004.1 R5014.2 R30101.1 SR3001.2 SR3013.1 U3002.26(VSTBY1) U3002.50(VSTBY2) U3002.92(VSTBY3) U3002.114(VSTBY4) U3002.121(VSTBY5) U3002.127(VSTBY(PLL))
+3VACC: C3021.1 SR3013.2 U3002.74(AVCC)
+3VAPLL: C3005.1 R3017.1 R3025.2 U3002.106(VSTBY_FSPI)
+3VO: C8110.1 C9115.1 C9122.1 CE8101.1 JP8102.2 JP8105.2 JP8108.2 JP8109.2 JP8112.2 L8101.2 Q9105.3(DRAIN) R7442.1 R7448.1 R7453.1 R7455.1 R7469.2 R7485.1 R7487.1 R7490.1 R7491.1 R8203.2 R9404.2 SR8200.1 SR8400.2 SR9400.1 T8124.1 T8125.1 U7411.5(VCC) U7414.5(VCC) U7415.5(VCC) U7416.5(VCC) U9101.1(VIN1_1) U9101.2(VIN1_2) U9101.6(VIN2_1) U9101.7(VIN2_2) U9102.1(IN1)
+3VS: C1504.1 C1513.1 C1516.2 C1517.2 C2403.1 C2620.1 C3009.1 C3602.1 C4536.1 C4540.1 C4541.1 C4638.1 C4639.1 C5000.2 C5007.2 C5600.1 C5801.1 C5802.1 C5803.1 C9112.1 C9113.1 CON5602.18 IC221.1 IU203.5(VIN) L5302.1 R0704.1 R1159.1 R1243.1 R1304.1 R1409.1 R1501.1 R1502.1 R1503.1 R1504.1 R1505.1 R1506.1 R1514.1 R1602.2 R2106.1 R2202.1 R2203.1 R2204.1 R2205.1 R2206.1 R2207.1 R2208.1 R2209.1 R2210.1 R2244.1 R2245.1 R2246.1 R2247.1 R2249.1 R2251.1 R2314.1 R2316.1 R2318.1 R2320.1 R2324.1 R2360.1 R2364.1 R2365.1 R2379.1 R2380.1 R2405.2 R2449.2 R2451.1 R2497.1 R3081.1 R3102.2 R3107.2 R3109.1 R3111.1 R3141.1 R3143.1 R3145.1 R3147.1 R3170.2 R3172.2 R3603.2 R3604.1 R3608.1 R3632.1 R4501.1 R4517.2 R4518.1 R4526.1 R4587.2 R4593.1 R4629.1 R5000.1 R5001.1 R5002.1 R5003.1 R5007.1 R5008.1 R5011.1 R5012.1 R5013.1 R5018.1 R5019.1 R5021.1 R5022.1 R5603.1 R5801.2 R5806.2 R5808.1 R6101.1 R6103.1 R6113.1 R6115.1 R6117.1 R6119.1 R6121.1 R6123.1 R6746.1 R7007.1 R9200.1 R9203.1 SR1301.1 SR2607.2 SR3104.2 SR3601.1 SR3602.1 SR4501.1 SR4503.1 SR4601.1 SR5106.1 SR5107.1 SR5109.1 SR6202.1 SR6703.1 T9104.1 U1501.6(VDD1) U1501.16(VDD2) U2301.2(G) U2301.5(G) U2401.5(VCC) U3002.11(VCC) U3600.36(CPVDD) U4502.5(IN) U4602.4(EN) U4602.5(IN) U5000.1(VCC) U5003.5(VCC) U5800.7(VDD) U9101.8(VOUT2_1) U9101.9(VOUT2_2) U9101.13(VOUT1_1) U9101.14(VOUT1_2)
+3VS_CAM: C4539.1 CON4500.31 SR4501.2 T4508.1
+3VS_DMIC: C4545.1 CON4500.27 SR4503.2 T4507.1
+3VS_DPOUT: C4640.1 C4641.1 CON4601.20 U4602.1(OUT)
+3VS_DPSW: C1413.1 C1414.2 R1402.1 R1403.1 R1405.1 R1407.1 R1408.2 R1409.2 R1414.1 R1415.1 U1401.1(VDD33_1) U1401.6(VDD33_2) U1401.12(VDD33_3) U1401.25(VDD33_4) U1401.32(VDD33_5) U1401.36(VDD33_6)
+3VS_EDP: C4515.1 C4516.1 C4532.1 C4542.1 C4546.1 CON4500.17 CON4500.18 CON4500.19 R4523.1 R4525.1 T4504.1 U4502.1(OUT)
+3VS_GSENSOR: R5808.2 U5800.3(VDDIO)
+3VS_HDMI: C1314.1 C1315.1 C1316.1 R1301.2 R1304.2 R1312.1 R1313.1 R1319.1 R1322.1 R1324.1 R1326.1 R1328.1 R1329.1 R1330.1 U1301.11(VCC_1) U1301.37(VCC_2)
+3VS_IO: C6712.1 C6715.1 CON6701.2 IU203.1(VOUT) R6740.2 SR6703.2
+3VS_S0: C1155.1 C1156.1 C1157.1 C1158.1 C1188.1 L1106.2 R1111.2 R1119.2 R1130.2 R1134.2 R1143.2 R1144.2 R1159.2 R1164.2 U1101.A2(VCC3P3_SVR_1) U1101.A3(VCC3P3_SVR_2) U1101.B3(VCC3P3_SVR_3) U1101.H9(VCC3P3A)
+3VS_S0_TBT: C1187.1 C1191.1 C1192.1 L1106.1 U1101.R13(VCC3P3_S0)
+3VS_SSD2: C5116.1 C5117.1 C5118.2 C5119.1 C5125.1 C5126.1 C5127.1 C5128.1 C5138.1 C5139.1 C5162.1 C5168.1 CON5103.2 CON5103.4 CON5103.70 CON5103.72 CON5103.74 SR5107.2
+3VS_SSD3: C5173.1 C5175.1 C5176.1 C5177.1 C5178.1 C5179.1 C5180.1 C5181.2 C5182.1 C5183.1 C5184.1 C5185.1 CON5104.2 CON5104.4 CON5104.70 CON5104.72 CON5104.74 SR5109.2
+3VS_SSD_PCIE: C5120.1 C5133.1 C5134.1 C5135.1 C5136.1 C5137.1 C5161.1 CON5102.2 CON5102.4 CON5102.12 CON5102.14 CON5102.16 CON5102.18 CON5102.70 CON5102.72 CON5102.74 R5115.1 SR5106.2
+3VS_TP: C3104.1 Q2301.1(GATE) R2310.1 R2312.1 R2313.1 R3072.1 R3073.1 R3169.2 R3170.1 SR3107.1 SR3110.2
+3VS_TPM: C6202.1 C6203.1 C6204.1 C6205.1 C6206.1 SR6202.2 U6200.10(VDD1) U6200.19(VDD2) U6200.24(VDD3)
+3VS_TYPEC: C1203.1 C1204.1 R1227.2 R1228.2 R1230.2 R1231.2 R1232.2 SR1206.2 U1201.B1(VDDIO) U1201.H1(VIN_3V3)
+3VS_VGA: C4601.1 C4602.1 C4603.1 C4604.1 C4605.1 C4606.1 C4607.1 C4608.1 C4612.1 C4613.1 C4636.2 C4637.1 R4607.1 SR4601.2 U4601.3(VDD_1) U4601.6(VDD_2) U4601.9(VDD_3) U4601.12(VDD_4) U4601.15(VDD_5) U4601.24(VDD_10) U4601.27(VDD_9) U4601.30(VDD_8) U4601.33(VDD_7) U4601.36(VDD_6)
+3VS_WLAN: Q5303.1(GATE) Q5304.1(GATE) R5307.2 R5309.2
+3VSUS: C0702.1 C0703.2 C2404.2 C2405.2 C2611.1 C2612.1 C2616.1 C2617.1 C2621.1 C2626.1 IC220.1 IU202.5(VIN) JP8102.1 JP8108.1 JP8109.1 JP8112.1 L2601.2 Q2601.3(DRAIN) Q2602.1(EMITTER1) Q5300.2(SOURCE) R0755.1 R1160.1 R1242.1 R2100.1 R2102.1 R2103.1 R2104.1 R2105.1 R2107.1 R2108.1 R2113.1 R2114.1 R2115.1 R2116.1 R2117.1 R2118.1 R2119.1 R2120.1 R2157.1 R2243.1 R2248.1 R2259.1 R2302.1 R2303.1 R2304.1 R2305.1 R2309.1 R2323.1 R2327.1 R2328.1 R2329.1 R2330.1 R2331.1 R2332.1 R2333.1 R2334.1 R2335.1 R2357.1 R2358.1 R2363.1 R2371.1 R2378.1 R2381.1 R2406.1 R2407.1 R2408.1 R2409.1 R2410.1 R2411.1 R2412.1 R2414.1 R2415.1 R2416.1 R2417.1 R2420.1 R2421.1 R2422.1 R2423.1 R2428.1 R2429.1 R2430.1 R2431.1 R2432.1 R2433.1 R2434.1 R2435.1 R2436.1 R2437.1 R2442.1 R2444.1 R2446.1 R2447.1 R2463.1 R2464.1 R2465.1 R2466.1 R2469.1 R2472.1 R2473.1 R2601.1 R2608.1 R2616.2 R2617.2 R2804.2 R3167.1 R3621.1 R4411.1 R5208.1 R5717.1 R6745.1 R8837.1 R8838.1 R9202.1 SP2601.2 SR1206.1 SR2601.2 SR2603.2 SR2606.2 SR3101.2 SR3109.2 SR3305.1 SR6201.2 SR6702.1 T8112.1 T8113.1 U0702.5(VCC) U0703.5(VCC) U2000.BA20(VCCRTCPRIM_3P3) U2402.5(VCC) U2403.5(VCC) U2404.5(VCC) U9200.5(VCC) U9201.5(VCC)
+3VSUS_IO: C6716.1 IU202.1(VOUT) SR6701.2 SR6702.2
+3VSUS_LAN: C3309.1 C3310.1 C3311.1 C3312.1 C3322.1 C3323.1 R3301.2 R3307.1 SR3305.2 U3300.1(VDD33) U3300.16(AVDD33)
+3VSUS_LC: C1185.1 R1112.1 R1113.1 R1114.1 R1115.1 U1101.R6(VCC3P3_LC)
+3VSUS_PGPPA: C2630.1 R2250.1 SP2601.1 U2000.BA31(VCCPGPPA)
+3VSUS_SPI: C3100.1 C3101.1 C4404.2 CON4402.1 CON4402.3 R3101.1 R3116.1 R3117.2 R3124.1 SR3101.1 U3101.8(VCC)
+3VSUS_SX: C1109.1 C1110.1 C1111.1 C1186.1 R1131.2 R1132.2 R1135.2 R1138.2 R1140.2 R1141.2 R1145.2 R1146.2 R1160.2 R1161.1 R1164.1 U1101.F8(VCC3P3_SX) U1102.5(VCC) U1104.5(VCC) U1105.5(VCC)
+3VSUS_TPM: C6200.1 C6201.1 SR6201.1 U6200.5(VSB)
+5V_FAN0: C5003.1 CON5000.4 U5001.3(VOUT)
+5V_FAN1: C5001.1 CON5001.4 U5002.3(VOUT)
+5V_LED: CON1.6 LR800.2
+5V_LED_RLED1_Q2: LLED802.2(CATHODE) LQ803.3(D)
+5V_LED_RLED2: LLED802.1(ANODE) LR802.1
+5V_RLED1: LLED800.1(ANODE) LR800.1
+5V_RLED1_Q: LLED800.2(CATHODE) LQ800.3(DRAIN)
+5V_RYLED_R: LLED801.2(CATHODE) LQ801.3(DRAIN)
+5V_RYLED_R1: LLED801.1(ANODE) LR803.1
+5V_RYLED_Y: LLED803.2(CATHODE) LQ802.3(DRAIN)
+5V_RYLED_Y1: LLED803.1(ANODE) LR801.1
+5V_USB: C5501.1 C5505.1 CE5503.1 CON5501.1(VBUS) D5506.1(ANODE) U5501.1(VOUT)
+5VA: CON5602.27 JP8100.2 R5302.2 T8114.1
+5VA_LED: CON1.7 LR801.2 LR803.2
+5VAO: C8100.1 JP8100.1 T8100.1 U8100.13(VREG5)
+5VO: C8109.1 C9105.1 C9114.1 C9121.1 CE8100.1 JP8101.1 JP8103.1 JP8104.1 JP8110.1 JP8111.1 L8100.1 SR8104.2 SR8302.1 T8108.1 T8109.1 U9100.4(VBIAS) U9101.4(VBIAS) U9102.4(VBIAS) U9102.7(IN2)
+5VO_1_1: C8120.1 D8102.3(ANODE2)
+5VO_1_2: C8119.1 D8102.1(ANODE1) SR8104.1
+5VO_2_2: C8122.2 D8103.3(ANODE2)
+5VS: C1320.1 C3633.1 C4801.1 C8068.2 C8069.2 C8070.2 C8722.1 C8727.1 C8732.1 C8737.1 C9125.1 C80025.2 C80082.2 CON3104.13 CON3110.1 CON3110.2 CON5602.26 D5000.3(CATHODE) D5002.3(CATHODE) L3606.2 R3714.2 R8006.1 R8007.1 R8008.1 R8032.1 R8034.1 R8091.1 R8717.1 R8718.1 R8719.1 R8720.1 R8749.1 R8905.1 R9710.1 R80103.1 SR1501.1 SR4502.1 SR8000.2 SR8002.2 SR8003.1 SR8004.1 SR8005.1 SR8006.1 SR8007.1 SR8017.1 T9106.1 U1302.3(VBIAS) U4801.3(IN) U5001.2(VIN) U5002.2(VIN) U5004.2(VIN) U8001.29(PVCC) U8002.29(PVCC) U8003.29(PVCC) U8004.29(PVCC) U8006.29(PVCC) U8702.4(VCC) U8703.4(VCC) U8704.4(VCC) U8705.4(VCC) U9102.8(OUT2)
+5VS_AVDD: C3605.1 C3606.1 L3606.1 U3600.26(AVDD1)
+5VS_FAN2: C5009.1 CON5002.3 U5004.3(VOUT)
+5VS_HDD: C5106.1 C5107.1 C5147.1 C5160.1 C5167.1 CON5100.7 CON5100.8 CON5100.9 R1519.1 SR1501.2
+5VS_HDD_2: CON5100.2 CON5100.3 R1519.2
+5VS_HDMI: C4806.1 CON4800.18 D4800.3(ANODE) U4801.2(OUT)
+5VS_LED: CON1.8 LR802.2 LR804.1
+5VS_LGF: C4538.1 CON4500.37 SR4502.2 T4509.1
+5VSUS: C3608.1 C3609.1 C3711.1 C5200.2 C5507.1 C6700.1 CE6703.1 CON5602.19 CON6701.3 CON6701.4 CON6701.5 JP1201.2 JP8101.2 JP8110.2 JP8111.2 L3601.1 R3713.2 R5207.1 R5209.1 R5718.1 T8117.1 T8118.1 U4501.5(VDD) U5200.1(IN) U5501.5(VIN)
+5VSUS_CHARGING: C5201.1 C5202.1 C5502.1 C5503.1 C5506.1 CE5502.1 CON5500.1(VBUS) D5505.1(ANODE) U5200.12(OUT)
+5VSUS_PVDD: C3700.1 C3701.1 R3707.2 R3708.2 R3713.1 R3714.1 U3700.3(PVDD1) U3700.4(PVDD2)
+5VSUS_TYPEC: C1201.2 C1209.1 C1210.1 C1211.1 C1212.1 JP1201.1 R1201.1 R1205.1 U1201.A11(PP_5V0_1) U1201.B11(PP_5V0_2) U1201.C11(PP_5V0_3) U1201.D11(PP_5V0_4) U1201.H10(PP_CABLE) U1202.1(IN)
+10VO: C8121.1 D8102.2(CATHODE) D8103.1(ANODE1) T8120.1
+12V: Q9103.4(COLLECTOR2) R9108.1 T9110.1
+12VO: C8123.1 D8103.2(CATHODE) JP8107.1 T8126.1
+12VS: Q9102.4(COLLECTOR2) R9107.1 T9107.1
+12VSUS: JP8107.2 Q9102.3(EMITTER2) Q9103.3(EMITTER2) Q9104.3(EMITTER2) Q9106.3(EMITTER2) T8127.1
+AVDDH: C3317.1 C3318.1 C3319.1 U3300.9(AVDDH_REG) U3300.22(AVDDH)
+AVDDL: C3308.2 C3315.1 C3316.1 C3320.1 C3321.1 L3301.2 L3302.1 U3300.6(AVDDL_REG) U3300.13(AVDDL1) U3300.19(AVDDL2) U3300.31(AVDDL3)
+AVDDVCO: C3303.1 C3304.1 C3305.1 L3301.1 U3300.34(AVDDL4)
+DVDDIO_AUDIO_W10MIL: C2629.1 L2601.1 R2608.2 U2000.BA15(VCCHDA)
+DVDDL: C3300.1 C3301.1 C3302.1 C3306.2 C3307.2 L3300.1 L3302.2 U3300.37(DVDDL_REG)
+V1P0A_VCCAMPHYPLL_W25MIL: C2613.1 C2614.1 C2615.1 SR2604.2 U2000.A43(VCCAMPHYPLL_1P0_1) U2000.B43(VCCAMPHYPLL_1P0_2) U2000.C44(VCCPCIE3PLL_1P0_1) U2000.C45(VCCPCIE3PLL_1P0_2)
+V1P0A_VCCAPLL_W15MIL: C2618.1 C2619.1 C2628.1 L2603.2 R2607.2 U2000.AJ5(VCCUSB2PLL_1P0_1) U2000.AL5(VCCUSB2PLL_1P0_2) U2000.AN19(VCCHDAPLL_1P0)
+V1P0A_VCCF24_W15MIL: C2605.1 C2606.1 C2607.1 SR2602.2 U2000.K2(VCCCLK5_1) U2000.K3(VCCCLK5_2)
+VBUS1: C1217.2 C1218.1 C1219.1 C1220.1 C1222.1 C1225.1 C1226.1 C1227.1 C1228.1 CE1225.1 CON1201.A4(VBUS2) CON1201.A9(VBUS1) CON1201.B4(VBUS3) CON1201.B9(VBUS4) D1209.2(CATHODE) R1247.2 U1201.A10(SENSEN) U1201.B10(SENSEP) U1201.H11(VBUS_1) U1201.J10(VBUS_2) U1201.J11(VBUS_3) U1201.K11(VBUS_4)
+VCC_RTC: C2826.1 D2801.3(CATHODE) R2448.1 R2810.1 R2812.1 R6006.1 SR2605.2
+VCC_SYS_HV: T1205.1 T1206.1 U1201.A6(PP_HV_1) U1201.A7(PP_HV_2) U1201.A8(PP_HV_3) U1201.B7(PP_HV_4)
+VCCDSW: Q2601.2(SOURCE) Q2602.4(EMITTER2) R2601.2 R2617.1 U2000.BA24(VCCDSW_3P3_2) U2000.W15(VCCDSW_3P3_1)
+VCCGT: C0963.1 C0964.1 C0965.1 C0966.1 C0967.1 C0968.1 C0969.1 C0970.1 C0971.1 C0972.1 C0973.1 C0974.1 C0975.1 C0976.1 C0977.1 C0978.1 C0979.1 C0980.1 C0981.1 C0982.1 C0983.1 C0984.1 C0985.1 C0986.1 C0987.1 C0988.1 C0989.1 C0990.1 C0991.1 C0992.1 C0993.1 C0994.1 C0995.1 C0996.1 C0997.1 C0998.1 C0999.1 C09100.1 C09101.1 C09102.1 C09103.1 C09104.1 C09105.1 C09106.1 C09107.1 C09108.1 C09109.1 C09110.1 C09111.1 C09112.1 C09113.1 C09114.1 C09115.1 C09116.1 C09117.1 C09118.1 C09119.1 C09120.1 C09121.1 C09122.1 C09123.1 C09124.1 C09125.1 C09126.1 C09127.1 C09128.1 C09129.1 C09130.1 C80004.2 C80008.2 C80009.2 C80010.2 C80012.2 C80013.2 C80017.2 C80022.2 C80023.2 C80024.2 C80032.2 C80039.2 C80040.2 C80057.2 C80062.2 C80068.2 C80069.2 C80077.2 C80095.2 C80098.2 C80102.2 C80112.2 C80113.2 C80114.2 C80115.2 C80116.2 C80117.2 C80118.2 C80119.2 C80121.2 C80124.1 C80125.1 CE8004.1 CE8007.1 JP8057.2 JP8060.2 L8003.2 L8004.2 R0904.1 R8019.1 U0300.AJ29(VCCGT_1) U0300.AJ30(VCCGT_2) U0300.AJ31(VCCGT_3) U0300.AJ32(VCCGT_4) U0300.AJ33(VCCGT_5) U0300.AJ34(VCCGT_6) U0300.AJ35(VCCGT_7) U0300.AJ36(VCCGT_8) U0300.AK31(VCCGT_9) U0300.AK32(VCCGT_10) U0300.AK33(VCCGT_11) U0300.AK34(VCCGT_12) U0300.AK35(VCCGT_13) U0300.AK36(VCCGT_14) U0300.AK37(VCCGT_15) U0300.AK38(VCCGT_16) U0300.AL13(VCCGT_17) U0300.AL29(VCCGT_18) U0300.AL30(VCCGT_19) U0300.AL31(VCCGT_20) U0300.AL32(VCCGT_21) U0300.AL35(VCCGT_22) U0300.AL36(VCCGT_23) U0300.AL37(VCCGT_24) U0300.AL38(VCCGT_25) U0300.AM13(VCCGT_26) U0300.AM14(VCCGT_27) U0300.AM29(VCCGT_28) U0300.AM30(VCCGT_29) U0300.AM31(VCCGT_30) U0300.AM32(VCCGT_31) U0300.AM33(VCCGT_32) U0300.AM34(VCCGT_33) U0300.AM35(VCCGT_34) U0300.AM36(VCCGT_35) U0300.AN13(VCCGT_36) U0300.AN14(VCCGT_37) U0300.AN31(VCCGT_38) U0300.AN32(VCCGT_39) U0300.AN33(VCCGT_40) U0300.AN34(VCCGT_41) U0300.AN35(VCCGT_42) U0300.AN36(VCCGT_43) U0300.AN37(VCCGT_44) U0300.AN38(VCCGT_45) U0300.AP13(VCCGT_46) U0300.AP14(VCCGT_47) U0300.AP29(VCCGT_48) U0300.AP30(VCCGT_49) U0300.AP31(VCCGT_50) U0300.AP32(VCCGT_51) U0300.AP35(VCCGT_52) U0300.AP36(VCCGT_53) U0300.AP37(VCCGT_54) U0300.AP38(VCCGT_55) U0300.AR29(VCCGT_56) U0300.AR30(VCCGT_57) U0300.AR31(VCCGT_58) U0300.AR32(VCCGT_59) U0300.AR33(VCCGT_60) U0300.AR34(VCCGT_61) U0300.AR35(VCCGT_62) U0300.AR36(VCCGT_63) U0300.AT14(VCCGT_64) U0300.AT31(VCCGT_65) U0300.AT32(VCCGT_66) U0300.AT33(VCCGT_67) U0300.AT34(VCCGT_68) U0300.AT35(VCCGT_69) U0300.AT36(VCCGT_70) U0300.AT37(VCCGT_71) U0300.AT38(VCCGT_72) U0300.AU14(VCCGT_73) U0300.AU29(VCCGT_74) U0300.AU30(VCCGT_75) U0300.AU31(VCCGT_76) U0300.AU32(VCCGT_77) U0300.AU35(VCCGT_78) U0300.AU36(VCCGT_79) U0300.AU37(VCCGT_80) U0300.AU38(VCCGT_81) U0300.AV29(VCCGT_82) U0300.AV30(VCCGT_83) U0300.AV31(VCCGT_84) U0300.AV32(VCCGT_85) U0300.AV33(VCCGT_86) U0300.AV34(VCCGT_87) U0300.AV35(VCCGT_88) U0300.AV36(VCCGT_89) U0300.AW14(VCCGT_90) U0300.AW31(VCCGT_91) U0300.AW32(VCCGT_92) U0300.AW33(VCCGT_93) U0300.AW34(VCCGT_94) U0300.AW35(VCCGT_95) U0300.AW36(VCCGT_96) U0300.AW37(VCCGT_97) U0300.AW38(VCCGT_98) U0300.AY29(VCCGT_99) U0300.AY30(VCCGT_100) U0300.AY31(VCCGT_101) U0300.AY32(VCCGT_102) U0300.AY35(VCCGT_103) U0300.AY36(VCCGT_104) U0300.AY37(VCCGT_105) U0300.AY38(VCCGT_106) U0300.BA13(VCCGT_107) U0300.BA14(VCCGT_108) U0300.BA29(VCCGT_109) U0300.BA30(VCCGT_110) U0300.BA31(VCCGT_111) U0300.BA32(VCCGT_112) U0300.BA33(VCCGT_113) U0300.BA34(VCCGT_114) U0300.BA35(VCCGT_115) U0300.BA36(VCCGT_116) U0300.BB13(VCCGT_117) U0300.BB14(VCCGT_118) U0300.BB31(VCCGT_119) U0300.BB32(VCCGT_120) U0300.BB33(VCCGT_121) U0300.BB34(VCCGT_122) U0300.BB35(VCCGT_123) U0300.BB36(VCCGT_124) U0300.BB37(VCCGT_125) U0300.BB38(VCCGT_126) U0300.BC29(VCCGT_127) U0300.BC30(VCCGT_128) U0300.BC31(VCCGT_129) U0300.BC32(VCCGT_130) U0300.BC35(VCCGT_131) U0300.BC36(VCCGT_132) U0300.BC37(VCCGT_133) U0300.BC38(VCCGT_134) U0300.BD13(VCCGT_135) U0300.BD14(VCCGT_136) U0300.BD29(VCCGT_137) U0300.BD30(VCCGT_138) U0300.BD31(VCCGT_139) U0300.BD32(VCCGT_140) U0300.BD33(VCCGT_141) U0300.BD34(VCCGT_142) U0300.BD35(VCCGT_143) U0300.BD36(VCCGT_144) U0300.BE31(VCCGT_145) U0300.BE32(VCCGT_146) U0300.BE33(VCCGT_147) U0300.BE34(VCCGT_148) U0300.BE35(VCCGT_149) U0300.BE36(VCCGT_150) U0300.BE37(VCCGT_151) U0300.BE38(VCCGT_152) U0300.BF13(VCCGT_153) U0300.BF14(VCCGT_154) U0300.BF29(VCCGT_155) U0300.BF30(VCCGT_156) U0300.BF31(VCCGT_157) U0300.BF32(VCCGT_158) U0300.BF35(VCCGT_159) U0300.BF36(VCCGT_160) U0300.BF37(VCCGT_161) U0300.BF38(VCCGT_162) U0300.BG29(VCCGT_163) U0300.BG30(VCCGT_164) U0300.BG31(VCCGT_165) U0300.BG32(VCCGT_166) U0300.BG33(VCCGT_167) U0300.BG34(VCCGT_168) U0300.BG35(VCCGT_169) U0300.BG36(VCCGT_170) U0300.BH33(VCCGT_171) U0300.BH34(VCCGT_172) U0300.BH35(VCCGT_173) U0300.BH36(VCCGT_174) U0300.BH37(VCCGT_175) U0300.BH38(VCCGT_176) U0300.BJ37(VCCGT_177) U0300.BJ38(VCCGT_178) U0300.BL36(VCCGT_179) U0300.BL37(VCCGT_180) U0300.BM36(VCCGT_181) U0300.BM37(VCCGT_182) U0300.BN36(VCCGT_183) U0300.BN37(VCCGT_184) U0300.BN38(VCCGT_185) U0300.BP37(VCCGT_186) U0300.BP38(VCCGT_187) U0300.BR37(VCCGT_188) U0300.BT37(VCCGT_189)
+VCCIO: C1020.1 C1021.1 C1022.1 C9414.1 C9415.1 JP9400.1 JP9402.2 R0300.1 R0600.1 R0700.1 R0744.1 R0745.1 R0754.1 R4409.1 T9401.1 T9402.1 U0300.AG12(VCCIO_1) U0300.G15(VCCIO_2) U0300.G17(VCCIO_3) U0300.G19(VCCIO_4) U0300.G21(VCCIO_5) U0300.H15(VCCIO_6) U0300.H16(VCCIO_7) U0300.H17(VCCIO_8) U0300.H19(VCCIO_9) U0300.H20(VCCIO_10) U0300.H21(VCCIO_11) U0300.H26(VCCIO_12) U0300.H27(VCCIO_13) U0300.J15(VCCIO_14) U0300.J16(VCCIO_15) U0300.J17(VCCIO_16) U0300.J19(VCCIO_17) U0300.J20(VCCIO_18) U0300.J21(VCCIO_19) U0300.J26(VCCIO_20) U0300.J27(VCCIO_21)
+VCCIO_PWRGD: SR9209.1 T9209.1 U9400.12(PG)
+VCCPFUSE_W20MIL: C2610.1 SR2603.1 U2000.AN5(VCCPRIM_3P3_1) U2000.BD3(VCCPRIM_3P3_2) U2000.BE3(VCCPRIM_3P3_3) U2000.BE4(VCCPRIM_3P3_4)
+VCCPGPPCD_W15MIL: SR2601.1 U2000.BA45(VCCPGPPD1) U2000.BB45(VCCPGPPD2) U2000.BC44(VCCPGPPD3) U2000.BC45(VCCPGPPD4)
+VCCPLL_OC: C1001.1 C1002.1 SR1002.2 U0300.BH13(VCCPLL_OC_1) U0300.G11(VCCPLL_OC_2)
+VCCRTC_W8MIL: C2624.1 C2625.1 SR2605.1 U2000.BA22(VCCRTC)
+VCCSA: C1017.1 C1018.1 C1019.1 C1023.1 C80029.2 C80031.2 C80044.2 C80049.2 C80059.2 C80126.1 C80127.1 C80128.2 C80129.2 C80130.2 C80131.2 C80132.2 JP8061.2 L8005.2 R8075.2 U0300.J30(VCCSA_1) U0300.K29(VCCSA_2) U0300.K30(VCCSA_3) U0300.K31(VCCSA_4) U0300.K32(VCCSA_5) U0300.K33(VCCSA_6) U0300.K34(VCCSA_7) U0300.K35(VCCSA_8) U0300.L31(VCCSA_9) U0300.L32(VCCSA_10) U0300.L35(VCCSA_11) U0300.L36(VCCSA_12) U0300.L37(VCCSA_13) U0300.L38(VCCSA_14) U0300.M29(VCCSA_15) U0300.M30(VCCSA_16) U0300.M31(VCCSA_17) U0300.M32(VCCSA_18) U0300.M33(VCCSA_19) U0300.M34(VCCSA_20) U0300.M35(VCCSA_21) U0300.M36(VCCSA_22)
AGND: C3600.2 C3601.2 C3605.2 C3606.2 C3607.2 C3612.2 C3613.2 C3645.2 C3646.2 C3647.2 C3709.2 C6704.2 C6705.2 CON6700.16 CON6700.23 D3600.2(VC) R3600.2 R3629.2 R3630.2 R3631.2 R3711.1 R3712.1 U3600.25(AVSS1) U3600.38(AVSS2)
