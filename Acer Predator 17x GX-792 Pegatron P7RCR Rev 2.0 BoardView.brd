# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_SATA_TXP0_C: length 1.7
  BOTTOM w0.133: C5132.2 29.79,26.85 30.1,26.85 30.2,26.95 CON5102.49
PCIE_SATA_TXP1: length 212.6
  IN4 w0.114: v2(215.78,53.56) 215.44,53.22 215.3,53.22 214.89,52.81 214.43,52.81 214.15,53.09 208.29,53.09 207.52,52.33 206.66,52.33 200.7,46.37 200.7,45.17 197.51,41.97 197.12,41.97 195.02,39.87 194.05,39.87 192.29,38.11 191.69,38.11 189.19,35.61 188.25,35.61 187.79,35.15 147.59,35.15 146.49,36.25 140.26,36.25 138.14,38.37 121.46,38.37 120.49,37.41 110.69,37.41 109.23,35.95 102.06,35.95 101.3,35.19 56.03,35.19 55.56,34.72 33.72,34.72 33.41,35.03 32.05,35.03 30.76,36.32 26.86,36.32 25.77,35.23 25.77,31.16 27.11,29.83 v2(27.86,29.83)
  BOTTOM w0.089: U2000.B32 217.89,54.24 217.61,54.24 217.46,54.08 216.76,54.08
  BOTTOM w0.133: 216.76,54.08 216.3,54.08 v2(215.78,53.56) ; C5151.1 28.43,29.9 27.93,29.9 v2(27.86,29.83)
PCIE_SATA_TXP1_C: length 1.7
  BOTTOM w0.133: C5151.2 29.82,30.02 30.06,30.02 30.13,29.95 CON5102.37
PCIE_SATA_TXP2: length 203.7
  IN4 w0.114: v2(213.98,51.76) 213.98,51.88 213.67,52.19 212.77,52.19 212.27,51.69 208.74,51.69 208.25,51.2 207.16,51.2 201.81,45.85 201.81,44.71 197.96,40.86 197.58,40.86 195.76,39.04 195.76,38.78 195.71,38.74 194.86,37.89 194.46,37.89 191.07,34.51 188.71,34.51 188.25,34.05 146.89,34.05 145.81,35.12 139.44,35.12 137.73,36.84 121.65,36.84 121.05,36.24 111.27,36.24 109.06,34.03 56.43,34.03 55.87,33.47 33.32,33.47 33.14,33.29 29.69,33.29 29.53,33.13 28.18,33.13 27.95,32.9 v6(27.95,32.65)
  BOTTOM w0.089: U2000.B33 217.8,53.67 217.74,53.6 217.16,53.6 216.72,53.16 215.22,53.16
  BOTTOM w0.133: v2(213.98,51.76) 213.98,51.91 215.22,53.16 ; C5154.1 28.24,33.01 28.04,33.01 27.95,32.93 v6(27.95,32.65)
PCIE_SATA_TXP2_C: length 1.7
  BOTTOM w0.133: C5154.2 29.86,32.98 30.07,32.98 30.11,32.95 CON5102.25
PCIE_SATA_TXP3: length 209.2
  IN4 w0.114: v6(27.77,34.8) 27.91,34.94 28.52,34.94 28.62,34.84 28.62,34.49 28.45,34.32 27.54,34.32 26.97,33.75 26.97,31.74 27.61,31.1 29.27,31.1 30.7,32.53 108.76,32.53 111.68,35.45 121.76,35.45 122.39,36.08 137.19,36.08 139.13,34.13 145.63,34.13 146.48,33.29 188.66,33.29 189.12,33.74 191.39,33.74 194.77,37.13 195.18,37.13 196.48,38.42 196.52,38.47 196.52,38.73 197.78,39.99 198.35,39.99 203.17,44.82 203.17,45.41 208.15,50.39 208.53,50.39 208.97,50.83 212.12,50.83 212.29,51 214.9,51 215.63,51.73 v2(215.63,52.46)
  BOTTOM w0.133: C5159.1 28.23,35.03 28,35.03 v6(27.77,34.8) ; U2000.A35 217.39,53.08 217.05,52.74 216.12,52.74 215.82,52.45 215.64,52.45 v2(215.63,52.46)
PCIE_SATA_TXP3_C: length 2.4
  BOTTOM w0.133: C5159.2 29.56,35.2 29.83,35.2 30.06,35.43 30.06,35.81 30.2,35.95 CON5102.13
PCIE_TXN7_WLAN: length 120.6
  IN4 w0.102: v2(207.52,64.4) 207.52,64.75 207.58,64.8 210.17,64.8 212.32,66.96 212.32,67.44 216.15,71.27 218.97,71.27 224.72,77.02 232.82,77.02 233.42,76.43 237.92,76.43 238.51,77.02 251.11,77.02 256.38,82.29 257.63,82.29 261.31,85.98 268.81,85.98 269.72,86.89 279.55,86.89 280.83,88.17 281.46,88.17 281.92,87.71 283.32,87.71 283.98,88.37 286.49,88.37 287.19,87.68 291.36,87.68 293.36,89.68 296.31,89.68 296.56,89.94 296.56,90.19 v2(296.78,90.41)
  BOTTOM w0.121: v1(203.14,58.86) 202.92,58.86 ; 202.92,58.86 202.92,61.06 204.93,63.07 205.98,63.07 206.87,63.96 207.09,63.96 v2(207.52,64.4) ; 202.92,58.86 202.92,57.67 204.02,56.57 206.16,56.57 207.71,58.13 208.42,58.13 C2021.1 ; CON5300.37 296.75,90.99 296.61,90.84 296.61,90.58 v2(296.78,90.41)
PCIE_TXN7_WLAN_C: length 10.4
  BOTTOM w0.089: U2000.B20 214.37,60.62 214.35,60.61
  BOTTOM w0.121: v1(211.18,59.44) 211.4,59.44 ; 211.4,59.44 211.4,58.75 210.78,58.13 210.49,58.13 210.37,58.25 210.37,58.38 210.47,58.48 210.47,58.68 210.37,58.78 C2021.2 ; 211.4,59.44 211.4,59.79 211.85,60.24 213.09,60.24 213.42,60.56 214.3,60.56 214.35,60.61
PCIE_TXN8_WIGI: length 133.9
  IN1 w0.102: v2(303.26,89.16) 303.26,89.22 303.49,89.45 303.68,89.45 303.79,89.34 303.79,86.88 300.51,83.6 299.75,83.6 298.05,81.9 296.35,81.9 295.29,80.84 295.29,78.94 294.37,78.01 294.37,75.62 292.97,74.23 292.97,71.07 287.01,65.11 282.84,65.11 281.39,66.56 276.94,66.56 275.91,67.58 272.71,67.58 272.14,67.01 264.6,67.01 257.58,74.04 257.58,74.75 255.11,77.21 249.62,77.21 248.98,76.56 238.87,76.56 238.42,76.12 232.37,76.12 231.17,74.92 231.17,70.66 232.06,69.77 232.06,67.58 232.06,67.57 232.1,67.53 232.1,64.38 230.85,63.14 218.5,63.14 218.41,63.05 213.21,63.05 211.47,61.31 210.69,61.31 v2(210.45,61.55)
  BOTTOM w0.121: v2(210.45,61.55) 210.72,61.27 210.95,61.27 C2003.1 ; CON5300.59 302.25,90.98 302.38,90.85 302.38,89.78 302.6,89.56 302.86,89.56 v2(303.26,89.16)
PCIE_TXN8_WIGI_C: length 6.8
  BOTTOM w0.089: U2000.B19 217.89,61.06 217.61,61.06 217.5,60.99 216.57,60.99 216.47,61.09 215.67,61.09 215.64,61.12 215.62,61.12
  BOTTOM w0.121: C2003.2 212.43,61.48 212.53,61.37 212.53,61.22 212.45,61.14 212.45,60.99 212.55,60.9 212.81,60.9 213.16,61.25 215.2,61.25 215.32,61.12 215.62,61.12
PCIE_TXP7_WLAN: length 120.6
  IN4 w0.102: v2(296.14,90.41) 296.35,90.2 296.35,90.03 296.22,89.9 293.27,89.9 291.27,87.89 287.28,87.89 286.58,88.59 283.89,88.59 283.23,87.93 282.01,87.93 281.55,88.39 280.74,88.39 279.46,87.1 269.63,87.1 268.72,86.19 261.22,86.19 257.54,82.51 256.29,82.51 251.02,77.24 238.42,77.24 237.83,76.64 233.51,76.64 232.91,77.24 224.63,77.24 218.88,71.48 216.06,71.48 212.11,67.53 212.11,67.05 210.08,65.02 207.49,65.02 207.37,64.9 206.91,64.45 v2(206.91,64.4)
  BOTTOM w0.121: v2(206.91,64.4) 206.91,64.33 205.88,63.3 205.24,63.3 ; 205.24,63.3 v1(205.24,63.52) ; 205.24,63.3 204.83,63.3 202.69,61.16 202.69,57.57 203.92,56.34 206.26,56.34 207.81,57.89 C2020.1 ; v2(296.14,90.41) 296.37,90.63 296.37,90.84 296.25,90.96 CON5300.35
PCIE_TXP7_WLAN_C: length 10.4
  BOTTOM w0.089: 214.38,60.34 214.39,60.34 214.49,60.44 217.6,60.44 217.67,60.37 217.98,60.37 218.23,60.62 U2000.C20
  BOTTOM w0.121: C2020.2 210.87,57.89 211.64,58.66 211.64,59.69 211.95,60 212.88,60 ; 214.38,60.34 214.37,60.33 213.51,60.33 213.19,60 212.88,60 ; 212.88,60 v1(212.88,59.78)
PCIE_TXP8_WIGI: length 134
  IN1 w0.102: v2(303.26,89.8) 303.38,89.67 303.76,89.67 304.01,89.43 304.01,86.79 300.6,83.38 299.84,83.38 298.14,81.68 296.44,81.68 295.51,80.75 295.51,78.85 294.58,77.92 294.58,75.53 293.19,74.14 293.19,70.98 287.1,64.89 282.75,64.89 281.3,66.34 276.85,66.34 275.83,67.37 272.8,67.37 272.23,66.8 264.51,66.8 257.36,73.95 257.36,74.66 255.02,76.99 249.71,76.99 249.07,76.35 238.96,76.35 238.51,75.9 232.46,75.9 231.39,74.83 231.39,70.75 232.28,69.86 232.28,67.66 232.31,67.62 232.31,64.29 230.94,62.92 218.59,62.92 218.5,62.83 213.3,62.83 211.56,61.09 210.65,61.09 v2(210.45,60.89)
  BOTTOM w0.121: v2(210.45,60.89) 210.59,61.04 210.78,61.04 C2002.1 ; CON5300.61 302.75,90.97 302.62,90.83 302.62,89.88 302.7,89.8 v2(303.26,89.8)
PCIE_TXP8_WIGI_C: length 6.8
  BOTTOM w0.089: 215.62,60.88 215.64,60.88 215.67,60.91 216.39,60.91 216.49,60.81 217.57,60.81 217.66,60.87 218.09,60.87 218.36,61.14 U2000.C19
  BOTTOM w0.121: 215.62,60.88 215.23,60.88 215.1,61.01 213.26,61.01 212.91,60.66 C2002.2
PDB: length 94.9
  TOP w0.102: v2(15.86,9.89) 17,8.74 22.21,8.74 v1(22.56,9.1) 23.18,9.72 28.81,9.72 28.99,9.9 31.62,9.9 v2(32.11,10.4) ; R3608.2 19.97,23.22 19.77,23.43 Q3602.3 19.54,24.49 18.65,23.6 18.4,23.6 17.86,23.07 17.86,21.75 17.61,21.5 D3601.1 17.61,20.45 v2(17.76,20.3) ; U3600.47 5.65,27.77 5.21,27.34 5.14,27.34 4.91,27.11 4.91,26.68 v2(5.31,26.27)
  IN2 w0.102: v2(32.11,10.4) 32.42,10.7 34.22,10.7 35,9.92 48.93,9.92 51.95,12.94 54.82,12.94 v2(55.96,14.08)
  IN3 w0.102: v2(5.31,26.27) 5.31,25.71 9.58,21.44 11.82,21.44 12.53,20.73 15.27,20.73 15.63,21.09 17.48,21.09 17.76,20.81 v2(17.76,20.3) 15.86,18.4 v2(15.86,9.89)
  BOTTOM w0.102: v2(55.96,14.08) 55.96,11.41 56.85,10.52 65.78,10.52 66.57,11.31 SR3701.1
PECI_PCH: length 9.9
  TOP w0.121: v1(227.95,72.52) 228.31,72.89 228.31,73.15 v2(228.51,73.34) 228.25,73.6 R0746.1
  BOTTOM w0.102: U2000.AL3 231.88,69.1 231.88,69.44 231.98,69.64 231.98,70.76
  BOTTOM w0.121: v2(228.51,73.34) C2201.1 R2235.1 229.57,73.72 229.57,73.18 230,72.75 230.41,72.75 230.98,72.19 230.98,72 231.98,70.99 231.98,70.76
PEG_RCOMP: length 14
  BOTTOM w0.127: U0300.G2 111.07,103.11 112.74,101.43 117.99,101.43 119.23,100.18 R0600.2 120.78,99.6 v1(122.71,99.6)
PEG_RXN_0: length 23.3
  TOP w0.121: 124.42,98.13 127.12,98.13 127.22,98.23 127.22,98.4 127.1,98.52 127.1,98.69 127.2,98.79 C0631.2 ; 124.42,98.13 v1(124.42,98.35) ; 124.42,98.13 124.08,98.13 122.26,99.96 122.08,99.96 120.68,101.35 120.68,103.66 118.5,105.84 115.18,105.84 114.69,106.34 114.69,108.39 114.35,108.72 112.9,108.72 v3(112.74,108.89)
  BOTTOM w0.089: U0300.E10 112.41,109.21 v3(112.74,108.89)
PEG_RXN_1: length 20.8
  TOP w0.121: v1(119.67,105.93) 119.83,106.09 ; 119.83,106.09 119.99,105.93 119.99,105.5 121.16,104.32 121.16,102.16 123.35,99.98 124.11,99.98 124.97,99.12 C0629.2 ; 119.83,106.09 119.37,106.55 115.71,106.55 115.17,107.1 115.17,108.79 114.91,109.05 113.36,109.05 v3(112.73,109.67)
  BOTTOM w0.089: v3(112.73,109.67) 112.41,109.99 U0300.E11
PEG_RXN_2: length 23.2
  TOP w0.121: 124.16,101.03 123.72,101.03 122.06,102.69 122.06,104.7 121.42,105.34 121.42,106.93 121.31,107.04 121.31,107.71 120.05,108.97 118.73,108.97 118.22,109.48 116.65,109.48 116.27,109.86 115.37,109.86 114.89,110.34 112.99,110.34 v3(112.09,111.25) ; 124.16,101.03 v1(124.16,101.25) ; 124.16,101.03 124.67,101.03 124.94,100.75 127.32,100.75 C0627.2
  BOTTOM w0.089: U0300.E12 112.41,110.93 v3(112.09,111.25)
PEG_RXN_3: length 20.1
  TOP w0.121: C0625.2 125.06,101.25 123.27,103.04 123.27,104.12 121.88,105.51 121.88,106.13 121.97,106.23 121.97,107.22 ; v1(121.75,107.22) 121.97,107.22 ; 121.97,107.22 121.97,107.66 119.82,109.8 118.88,109.8 118.45,110.24 115.39,110.24 115.01,110.62 113.37,110.62 v3(112.74,111.25)
  BOTTOM w0.114: U0300.E13 112.41,111.57 v3(112.74,111.25)
PEG_RXN_4: length 23.6
  TOP w0.121: 112.58,111.91 111.8,111.91 111.67,112.04 111.67,112.3 111.75,112.37 112.02,112.37 112.09,112.45 v3(112.09,112.82) ; 112.58,111.91 114.31,111.91 114.73,111.49 116.19,111.49 116.49,111.19 118.9,111.19 119.14,110.95 119.39,110.95 119.94,110.95 122.87,108.03 122.87,106.94 123.1,106.7 123.1,105.55 124.16,104.49 124.16,103.63 124.96,102.83 127.27,102.83 C0623.2 ; 112.58,111.91 v1(112.58,112.13)
  BOTTOM w0.089: v3(112.09,112.82) 112.41,112.5 U0300.E14
PEG_RXN_5: length 19.8
  TOP w0.121: 117.3,111.96 117.73,111.96 118.08,111.61 119.08,111.61 119.31,111.38 119.56,111.38 119.56,111.38 120.12,111.38 123.29,108.2 123.29,107.12 123.53,106.88 123.53,105.73 124.59,104.67 124.59,103.81 125.06,103.33 C0621.2 ; 117.3,111.96 v1(117.3,111.74) ; 117.3,111.96 116.08,111.96 115.92,111.8 115.03,111.8 114.64,112.2 113.36,112.2 v3(112.74,112.82)
  BOTTOM w0.089: v3(112.74,112.82) 112.41,113.15 U0300.E15
PEG_RXN_6: length 22
  TOP w0.121: v1(124.64,106.61) 124.42,106.61 ; 124.42,106.61 124.42,107.25 124.19,107.49 124.19,108.57 120.25,112.51 118.45,112.51 117.92,113.04 117.07,113.04 116.9,112.87 116.16,112.87 115.97,113.05 115.03,113.05 114.63,113.45 112.9,113.45 v3(112.74,113.61) ; 124.42,106.61 124.42,106.1 125.61,104.91 127.16,104.91 127.47,104.59 127.62,104.59 127.72,104.69 127.72,105.17 127.78,105.24 C0619.2
  BOTTOM w0.089: v3(112.74,113.61) 112.74,113.95 112.68,114 U0300.E16
PEG_RXN_7: length 19.2
  TOP w0.121: v3(112.74,114.4) 112.95,114.19 112.95,114.02 113.19,113.77 114.92,113.77 115.32,113.37 116.03,113.37 116.28,113.61 116.62,113.61 ; 116.62,113.61 v1(116.62,113.4) ; 116.62,113.61 117.95,113.61 118.63,112.94 120.43,112.94 124.61,108.75 124.61,107.66 125.09,107.18 125.09,106.06 125.3,105.85 125.61,105.85 C0617.2
  BOTTOM w0.089: v3(112.74,114.4) 112.41,114.72 U0300.E17
PEG_RXN_8: length 19.8
  TOP w0.121: 119.34,113.83 121.3,113.83 122.03,113.1 122.03,112.64 125.51,109.16 125.51,108.03 125.66,107.88 125.81,107.88 C0615.2 ; 119.34,113.83 119,113.83 118.3,114.53 116.58,114.53 116.48,114.63 115.33,114.63 114.91,115.05 113.16,115.05 112.64,115.58 111.83,115.58 v3(111.44,115.19) ; 119.34,113.83 v1(119.34,114.05)
  BOTTOM w0.089: U0300.F18 111.44,115.25 v3(111.44,115.19)
PEG_RXN_9: length 19.9
  TOP w0.121: 126.63,108.95 v1(126.63,109.17) ; 126.63,108.95 127.49,108.95 C0613.2 ; 126.63,108.95 126.24,108.95 126.17,109.02 126.17,109.44 122.69,112.92 122.69,113.38 121.58,114.49 120.55,114.49 120.3,114.75 119.23,114.75 118.38,115.6 117.42,115.6 117.01,115.19 115.49,115.19 115.12,115.56 113.31,115.56 113.18,115.69 113.18,115.77 v3(113.39,115.97)
  BOTTOM w0.089: U0300.D19 113.25,116.55 113.34,116.55 113.39,116.5 v3(113.39,115.97)
PEG_RXN_10: length 19.7
  TOP w0.121: v1(122.76,113.93) 122.92,114.08 ; 122.92,114.08 123.11,113.89 123.11,113.09 125.62,110.59 125.82,110.59 C0611.2 ; 122.92,114.08 122.09,114.92 120.73,114.92 120.48,115.17 119.41,115.17 118.55,116.03 117.25,116.03 116.91,115.69 116.1,115.69 115.75,116.03 113.94,116.03 113.59,116.39 111.81,116.39 111.44,116.75 v3(111.44,117.55)
  BOTTOM w0.089: U0300.F20 111.76,117.22 v3(111.44,117.55)
PEG_RXN_11: length 19.3
  TOP w0.121: C0605.2 127.35,112.25 127.29,112.19 127.29,111.86 127.23,111.79 125.69,111.79 124.01,113.47 124.01,114.26 122.46,115.81 121.73,115.81 121.47,116.07 119.78,116.07 118.92,116.92 118.14,116.92 ; 118.14,116.92 116.85,116.92 116.74,116.81 114.47,116.81 114.2,117.09 113.11,117.09 113.07,117.13 113.07,117.23 v3(113.39,117.55) ; 118.14,116.92 v1(118.14,117.14)
  BOTTOM w0.089: U0300.D21 113.39,117.62 v3(113.39,117.55)
PEG_RXN_12: length 17.8
  TOP w0.121: v3(112.09,118.33) 112.48,117.94 114.66,117.94 ; v1(114.66,117.72) 114.66,117.94 ; 114.66,117.94 115.02,117.94 115.35,117.6 115.83,117.6 116.09,117.35 116.72,117.35 116.97,117.6 118.85,117.6 119.96,116.49 121.65,116.49 121.9,116.24 122.64,116.24 124.43,114.44 124.43,113.66 125.41,112.68 C0609.2
  BOTTOM w0.089: U0300.F22 112.09,118.4 v3(112.09,118.33)
PEG_RXN_13: length 18.7
  TOP w0.121: 122.59,117.13 122.28,117.13 122.02,117.39 120.33,117.39 119.22,118.5 115.65,118.5 115.19,118.96 112.9,118.96 v3(112.74,119.12) ; 122.59,117.13 v1(122.59,117.35) ; 122.59,117.13 123.06,117.13 125.86,114.33 127.49,114.33 C0608.2
  BOTTOM w0.089: v3(112.74,119.12) 112.8,119.06 113.26,119.06 113.37,119.17 113.37,119.41 113.26,119.51 U0300.D23
PEG_RXN_14: length 17.5
  TOP w0.121: C0602.2 125.84,115.47 125.49,115.47 123.15,117.81 120.5,117.81 118.76,119.56 118.5,119.56 ; 118.5,119.56 117.66,119.56 117.53,119.44 115.91,119.44 115.83,119.51 111.84,119.51 v3(111.44,119.91) ; 118.5,119.56 v1(118.5,119.34)
  BOTTOM w0.089: U0300.F24 111.76,120.24 v3(111.44,119.91)
PEG_RXN_15: length 19.3
  TOP w0.121: v3(112.74,120.7) 112.74,120.38 112.81,120.31 114.15,120.31 ; v1(114.15,120.53) 114.15,120.31 ; 114.15,120.31 114.54,120.31 115.17,120.94 115.93,120.94 116.26,120.61 119.43,120.61 119.95,121.12 122.05,121.12 126.37,116.8 127.49,116.8 C0600.2
  BOTTOM w0.089: v3(112.74,120.7) 112.74,120.7 112.74,121.26 112.82,121.34 112.98,121.34 113.06,121.25 U0300.D25
PEG_RXP_0: length 23.4
  TOP w0.121: C0630.2 126.17,97.9 ; 126.17,97.9 v1(126.17,97.68) ; 126.17,97.9 123.98,97.9 122.16,99.72 121.98,99.72 120.45,101.26 120.45,103.57 118.41,105.61 115.09,105.61 114.45,106.24 114.45,108.29 114.26,108.49 112.49,108.49 v3(112.09,108.89)
  BOTTOM w0.089: U0300.F10 111.76,109.21 v3(112.09,108.89)
PEG_RXP_1: length 20.8
  TOP w0.121: v1(114.66,109.5) 114.66,109.28 ; 114.66,109.28 113.5,109.28 113.39,109.39 v3(113.39,109.67) ; 114.66,109.28 115.01,109.28 115.4,108.89 115.4,107.2 115.81,106.79 119.46,106.79 120.22,106.03 120.22,105.6 121.4,104.42 121.4,102.26 123.45,100.21 124.21,100.21 125.07,99.35 125.33,99.35 125.41,99.43 125.41,99.92 125.49,100.01 C0628.2
  BOTTOM w0.089: U0300.D11 113.06,110 v3(113.39,109.67)
PEG_RXP_2: length 23.2
  TOP w0.121: v1(119.31,108.52) 119.31,108.74 ; 119.31,108.74 119.95,108.74 121.08,107.62 121.08,106.94 121.18,106.83 121.18,105.25 121.82,104.6 121.82,102.6 123.63,100.79 124.57,100.79 124.85,100.51 127.26,100.51 C0626.2 ; 119.31,108.74 118.63,108.74 118.12,109.25 116.55,109.25 116.17,109.63 115.28,109.63 114.79,110.11 112.9,110.11 112.41,110.6 112.23,110.6 v3(112.09,110.46)
  BOTTOM w0.089: U0300.F12 112.09,110.53 v3(112.09,110.46)
PEG_RXP_3: length 20.1
  TOP w0.121: 119.41,110.04 v1(119.41,110.26) ; 119.41,110.04 118.98,110.04 118.54,110.48 115.49,110.48 115.11,110.85 113.48,110.85 113.39,110.95 v3(113.39,111.25) ; 119.41,110.04 119.92,110.04 122.21,107.75 122.21,106.13 122.11,106.03 122.11,105.61 123.5,104.22 123.5,103.14 125.16,101.49 125.36,101.49 125.43,101.55 125.43,102.08 125.48,102.14 C0624.2
  BOTTOM w0.089: 113.38,111.26 v3(113.39,111.25)
  BOTTOM w0.114: 113.38,111.26 113.06,111.57 U0300.D13
PEG_RXP_4: length 23.6
  TOP w0.121: 122.87,105.72 122.87,105.45 123.93,104.39 123.93,103.53 124.86,102.6 127.31,102.6 C0622.2 ; 122.87,105.72 122.87,106.61 122.63,106.84 122.63,107.93 119.84,110.72 119.29,110.72 119.04,110.72 118.81,110.95 116.39,110.95 116.09,111.26 114.64,111.26 114.22,111.68 111.71,111.68 111.44,111.94 v3(111.44,112.82) ; 122.87,105.72 v1(122.65,105.72)
  BOTTOM w0.089: U0300.F14 111.76,112.5 v3(111.44,112.82)
PEG_RXP_5: length 19.8
  TOP w0.121: v1(125.04,104.48) 124.82,104.48 ; 124.82,104.48 124.82,104.76 123.76,105.82 123.76,106.98 123.53,107.21 123.53,108.3 120.21,111.61 120.12,111.61 120.12,111.61 119.66,111.61 119.66,111.61 119.41,111.61 119.18,111.85 118.18,111.85 117.83,112.2 115.98,112.2 115.82,112.04 115.13,112.04 114.73,112.43 113.46,112.43 113.39,112.51 v3(113.39,112.82) ; 124.82,104.48 124.82,103.9 125.16,103.57 125.37,103.57 125.5,103.69 125.5,104.18 125.54,104.22 C0620.2
  BOTTOM w0.089: U0300.D15 113.06,113.15 v3(113.39,112.82)
PEG_RXP_6: length 22.1
  TOP w0.121: 119.84,112.28 v1(119.84,112.06) ; 119.84,112.28 120.15,112.28 123.95,108.48 123.95,107.39 124.19,107.15 124.19,106 125.51,104.67 127.06,104.67 127.38,104.35 C0618.2 ; 119.84,112.28 118.35,112.28 117.83,112.8 117.17,112.8 117,112.63 116.06,112.63 115.87,112.82 114.93,112.82 114.53,113.22 112.48,113.22 v3(112.09,113.61)
  BOTTOM w0.089: U0300.F16 112.09,113.68 v3(112.09,113.61)
PEG_RXP_7: length 19.3
  TOP w0.121: 114.66,114 115.02,114 115.42,113.6 115.93,113.6 116.18,113.85 118.05,113.85 118.73,113.17 120.53,113.17 124.85,108.85 124.85,107.76 125.33,107.28 125.33,106.15 125.4,106.08 125.62,106.08 C0616.2 ; 114.66,114 v1(114.66,114.22) ; 114.66,114 113.29,114 113.18,114.11 113.18,114.19 v3(113.39,114.4)
  BOTTOM w0.089: v3(113.39,114.4) 113.39,114.92 113.33,114.98 113.25,114.98 U0300.D17
PEG_RXP_8: length 19.8
  TOP w0.121: v3(112.09,115.19) 112.09,114.87 112.17,114.78 112.43,114.78 112.51,114.86 112.51,115.12 112.56,115.18 112.7,115.18 113.07,114.82 114.81,114.82 115.23,114.39 116.38,114.39 116.49,114.29 118.21,114.29 118.9,113.6 120.96,113.6 ; 120.96,113.6 121.2,113.6 121.79,113.01 121.79,112.55 125.27,109.07 125.27,107.94 125.56,107.65 125.77,107.65 C0614.2 ; 120.96,113.6 v1(120.96,113.38)
  BOTTOM w0.089: U0300.E18 112.41,115.23 112.37,115.19 v3(112.09,115.19)
PEG_RXP_9: length 19.9
  TOP w0.121: C0612.2 127.39,108.71 126.15,108.71 125.93,108.93 125.93,109.34 122.45,112.82 122.45,113.28 121.48,114.26 120.46,114.26 120.2,114.51 119.13,114.51 118.28,115.37 117.96,115.37 ; 117.96,115.37 117.52,115.37 117.11,114.95 115.58,114.95 115.58,114.95 115.39,114.95 115.02,115.32 113.22,115.32 112.93,115.6 112.93,115.78 v3(112.74,115.97) ; 117.96,115.37 v1(117.96,115.15)
  BOTTOM w0.089: v3(112.74,115.97) 112.41,116.3 U0300.E19
PEG_RXP_10: length 19.7
  TOP w0.121: C0606.2 125.86,110.82 125.72,110.82 123.35,113.19 123.35,113.99 122.19,115.15 120.83,115.15 120.57,115.41 119.51,115.41 118.65,116.26 117.15,116.26 116.81,115.92 116.49,115.92 ; 116.49,115.92 v1(116.49,116.14) ; 116.49,115.92 116.2,115.92 115.85,116.27 114.04,116.27 113.68,116.62 111.9,116.62 111.68,116.85 111.68,117.01 111.79,117.13 112.1,117.13 112.18,117.21 112.18,117.45 v3(112.09,117.54)
  BOTTOM w0.089: v3(112.09,117.54) 112.41,117.22 U0300.E20
PEG_RXP_11: length 19.3
  TOP w0.121: 121.04,115.83 119.68,115.83 118.83,116.69 116.94,116.69 116.84,116.58 114.38,116.58 114.1,116.85 113.01,116.85 112.84,117.03 112.84,117.45 v3(112.74,117.54) ; 121.04,115.83 121.38,115.83 121.63,115.58 122.36,115.58 123.77,114.16 123.77,113.38 125.59,111.56 127.34,111.56 127.53,111.36 C0610.2 ; 121.04,115.83 v1(121.04,115.61)
  BOTTOM w0.089: v3(112.74,117.54) 112.41,117.87 U0300.E21
PEG_RXP_12: length 17.8
  TOP w0.121: v3(112.74,118.34) 112.9,118.17 115.11,118.17 115.45,117.84 115.93,117.84 116.19,117.58 116.62,117.58 116.87,117.84 118.94,117.84 120.05,116.73 121.75,116.73 122,116.47 122.73,116.47 124.67,114.54 124.67,113.76 124.92,113.51 ; C0604.2 125.63,113.57 125.54,113.48 125.54,113.36 125.69,113.22 125.69,112.97 125.63,112.92 125.51,112.92 124.92,113.51 ; v1(125.08,113.67) 124.92,113.51
  BOTTOM w0.089: v3(112.74,118.34) 112.74,118.4 U0300.E22
PEG_RXP_13: length 18.7
  TOP w0.121: C0603.2 127.44,114.1 125.77,114.1 122.97,116.9 122.18,116.9 121.92,117.15 120.23,117.15 119.12,118.26 116.44,118.26 ; v1(116.44,118.04) 116.44,118.26 ; 116.44,118.26 115.56,118.26 115.09,118.73 112.49,118.73 v3(112.09,119.12)
  BOTTOM w0.089: U0300.E23 112.41,119.44 v3(112.09,119.12)
PEG_RXP_14: length 17.4
  TOP w0.121: v3(112.09,119.91) 112.25,119.75 115.93,119.75 116,119.67 116.49,119.67 ; 116.49,119.67 117.44,119.67 117.56,119.79 118.86,119.79 120.6,118.05 123.24,118.05 125.58,115.71 125.79,115.71 C0601.2 ; 116.49,119.67 v1(116.49,119.89)
  BOTTOM w0.089: U0300.E24 112.55,120.3 112.72,120.13 112.72,119.99 112.64,119.91 v3(112.09,119.91)
PEG_RXP_15: length 19.3
  TOP w0.121: 121.39,120.89 120.05,120.89 119.53,120.37 116.17,120.37 115.83,120.71 115.27,120.71 114.63,120.07 112.71,120.07 v3(112.09,120.7) ; 121.39,120.89 v1(121.39,120.67) ; 121.39,120.89 121.95,120.89 126.27,116.56 127.5,116.56 C0607.2
  BOTTOM w0.089: U0300.E25 112.09,120.76 v3(112.09,120.7)
PET0_N: length 3.7
  TOP w0.089: U1101.V22 291.91,35.93 291.91,35.48 291.83,35.4 291.83,34.86
  TOP w0.121: C1102.2 290.69,33.38 290.69,33.49 291.83,34.63 291.83,34.86
PET0_P: length 3.8
  TOP w0.089: 291.59,34.86 291.59,34.93 291.62,34.96 291.62,35.34 291.45,35.51 291.45,35.8 291.53,35.88 291.63,35.88 291.69,35.83 U1101.V23
  TOP w0.121: 291.59,34.86 291.59,34.72 290.46,33.59 290.46,33.41 C1101.2
PET1_N: length 3
  TOP w0.089: 293.46,34.63 293.46,34.71 293.48,34.73 293.48,35.31 293.3,35.49 293.3,35.92 U1101.P22
  TOP w0.121: 293.46,34.63 293.46,34.18 293.33,34.04 293.33,33.74 C1104.2
PET1_P: length 2.9
  TOP w0.089: U1101.P23 293.53,35.81 293.59,35.88 293.7,35.88 293.76,35.81 293.76,35.5 293.69,35.42 293.69,35.04 293.69,35.03 293.69,34.62
  TOP w0.121: 293.69,34.62 293.69,34.08 293.56,33.95 293.56,33.81 C1103.2
PET2_N: length 3.2
  TOP w0.089: 295.29,34.86 295.29,34.87 295.31,34.9 295.31,35.33 295.14,35.51 295.14,35.92 U1101.K22
  TOP w0.121: 295.29,34.86 295.29,34.43 295.79,33.92 295.79,33.67 C1106.2
PET2_P: length 3.2
  TOP w0.089: 295.52,34.79 295.52,35.03 295.51,35.04 295.51,35.37 295.6,35.46 295.6,35.82 295.55,35.87 295.4,35.87 295.37,35.84 U1101.K23
  TOP w0.121: C1105.2 296.02,33.73 296.02,34.02 295.52,34.52 295.52,34.79
PET3_N: length 3.7
  TOP w0.089: 297.15,34.75 297.15,34.94 297.13,34.97 297.13,35.35 296.98,35.5 296.98,35.92 U1101.F22
  TOP w0.121: C1108.2 298.18,33.43 298.18,33.56 297.15,34.58 297.15,34.75
PET3_P: length 3.7
  TOP w0.089: U1101.F23 297.21,35.81 297.29,35.89 297.36,35.89 297.44,35.8 297.44,35.47 297.33,35.35 297.33,35.05 297.36,35.02 297.36,34.84 297.39,34.8 297.39,34.79
  TOP w0.121: 297.39,34.79 297.39,34.68 298.41,33.66 298.41,33.45 C1107.2
PEX_CLKREQ#: length 203.4
  TOP w0.121: R2431.2 243.23,53.55 242.62,53.55 242.38,53.3 242.38,53.04 242.14,52.81 240.85,52.81 240.78,52.88 239.88,52.88 239.54,53.23 239.25,53.23 238.07,54.41 v2(237.45,54.41)
  IN1 w0.083: v2(237.45,54.41) 236.97,53.93 232.45,53.93 230.99,52.47 230.99,50.27 230.54,49.82 228.9,49.82 228.44,49.36 220.45,49.36 219.39,50.43 218.65,50.43 217.74,49.51 215.3,49.51 214.92,49.13 210.34,49.13 206.13,44.92 206.13,43.11 201.58,38.56 201.58,36.6 195.71,30.73 174.89,30.73 174.53,31.08 166.84,31.08 166.55,30.79 161.68,30.79 161.5,30.97 144.13,30.97 143.78,31.33 143.77,31.33 140.32,34.78 138.54,34.78 137.75,35.57 134.09,35.57 133.71,35.18 130.63,35.18 130.52,35.28 123.38,35.28 v2(123.25,35.41)
  BOTTOM w0.121: U7001.6 129.48,92.58 128.78,93.28 v1(126.57,93.28) 125.46,92.16 125.46,82.25 R7007.2 125.08,67.27 126.83,65.51 126.83,64.17 127.17,63.82 127.17,54.79 125.06,52.67 125.06,49.37 123.64,47.96 123.64,46.38 123.49,46.23 123.49,45.26 122.98,44.76 122.98,43.74 123.25,43.48 v2(123.25,35.41) ; v2(237.45,54.41) 237.45,54.41 237.54,54.51 U2000.BC32
PEX_CLKREQ#_Q: length 14.5
  BOTTOM w0.102: 140.75,93.02 140.76,93.03 143.73,93.03 144.25,93.55 U7000.BL26
  BOTTOM w0.121: 140.75,93.02 138.46,93.02 137.89,92.45 137.89,92.11 137.57,91.79 136.92,91.79 135.89,92.82 135.49,92.82 v1(134.91,93.4) 133.77,92.27 R7001.2 132.71,92.27 132.4,92.58 U7001.1
PEX_PLL_HVDD_SVDD: length 22
  TOP w0.432: SR7002.1 135.58,95.5 135.41,95.66 C7026.1 134.47,95.66 v2(134.22,95.41)
  TOP w0.508: v1(137.31,94.53) 137.31,94.81 136.62,95.5 SR7002.1
  IN1 w0.457: v2(134.22,95.41) 134.25,95.43 139.05,95.43 139.48,95.87 150.73,95.87 151.12,96.26 v3(151.12,96.66)
  BOTTOM w0.254: U7000.BB30 151.06,96.66 v3(151.12,96.66)
PEX_RST#: length 55.4
  IN4 w0.102: v2(142.27,63.56) 140.06,61.35 137.73,61.35 137.34,61.74 137.34,65.94 135.75,67.53 135.62,67.53 133.41,69.74 133.41,85.05 133.61,85.25 133.61,88.48 v2(134.47,89.34)
  BOTTOM w0.102: v2(142.27,63.56) 142.53,63.31 R7006.1 R7496.1 144.14,63.12 U7003.4 ; U7000.BK26 144.8,93.2 144.37,93.2 143.86,92.69 143.29,92.69 143,92.4 138.73,92.4 138.51,92.18 138.51,91.85 137.83,91.17 136.66,91.17 136.03,91.8 v1(135.62,91.8) 134.31,91.8 134.04,91.54 134.04,90.02 133.86,89.85 R7005.2 134.1,89.34 v2(134.47,89.34)
PEX_RST#_R: length 41.1
  IN4 w0.102: v2(143.82,68.19) 143.52,67.9 142.72,67.9 141.09,66.26 137.45,66.26 135.97,67.74 135.7,67.74 133.61,69.83 133.61,84.79 133.91,85.09 133.91,88.06 134.93,89.08 134.93,89.57 134.75,89.75 133.84,89.75 133.18,90.41 v2(133.18,91.24)
  BOTTOM w0.102: U7002.4 132.91,89.81 133.03,89.92 133.03,90.62 133.11,90.71 R7005.1 133.6,91.16 133.51,91.24 v2(133.18,91.24) ; R7004.1 143.4,67.77 v2(143.82,68.19) 143.59,68.42 143.59,68.71 v1(143.06,69.25)
PEX_TERMP: length 7.2
  BOTTOM w0.102: v1(138.53,107.94) 138.88,107.94 139.83,106.99 R7009.1 140.32,106.48 140.9,105.9 142.99,105.9 143.08,105.81 143.96,105.81 144.3,106.15 U7000.BL44
PEX_VDD: length 6.9
  IN1 w0.102: 148.62,99.04 148.62,98.53 ; 145.85,105.52 145.85,104.78 ; 147.22,102.06 147.22,100.46
  BOTTOM w0.254: v3(149.64,98.86) 149.64,98.74 U7000.BD33 ; U7000.BC33 v3(150.39,98.79) ; v3(151.09,99.51) U7000.BB35 ; U7000.BC35 v3(150.41,99.49) ; U7000.BC36 v3(150.4,100.9) ; v3(151.1,98.8) U7000.BB33 ; U7000.BD36 v3(149.71,100.91) ; U7000.BB36 v3(151.12,100.92)
  vias: v1(139.4,90.15) v2(139.86,90.99) v2(140.47,90.99) v3(141.05,90.96) v4(127.23,128.15) v4(127.23,127.26) v4(127.23,126.37) v4(128.12,128.15) v4(128.12,127.26) v4(128.12,126.37) v4(133.53,95.87) v4(133.51,94.95)
PLTRST#: length 318.3
  TOP w0.102: U3002.22 152.47,33.72 151.01,32.27 v2(151.01,30.41) 151.01,23.25 149.18,21.42 v2(149.18,20.97) ; U2401.2 229.93,29.6 230.03,29.5 230.03,29.05 229.93,28.95 U2401.1 229.34,28.51 229.44,28.4 230.08,28.4 230.35,28.67 230.35,29.18 v2(230.56,29.39) 230.69,29.27 230.69,28 230.87,27.82 231.63,27.82 231.84,28.03 U6200.16 ; v2(39.99,29.37) 39.06,30.3 34.72,30.3 34.55,30.13 34.55,29.51 34.21,29.17 SR5104.1 ; D2402.1 v2(252.58,68.38) ; SR2405.1 247.11,58.04 247.94,58.87 247.94,59.16 248.7,59.93 251.06,59.93 251.75,59.24 v2(251.75,58.99) ; v2(184.08,20.84) 184.37,20.55 184.37,18.96 v1(183.57,18.17) R3137.2
  IN1 w0.102: v2(251.75,58.99) 253.07,57.67 253.07,44.35 252.61,43.89 252.61,43.04 253.15,42.5 254.45,42.5 255.73,41.21 255.73,35.82 252.43,32.52 247.64,32.52 243.78,28.66 231.3,28.66 v2(230.56,29.39) 230.13,28.96 209.16,28.96 206.66,26.47 206.66,25.57 202.71,21.62 193.07,21.62 192.87,21.42 184.66,21.42 v2(184.08,20.84) 182.89,19.64 176.12,19.64 175.51,20.25 172.8,20.25 172.19,19.64 167.35,19.64 165.47,21.52 162.97,21.52 162.75,21.75 149.96,21.75 v2(149.18,20.97) ; v2(151.01,30.41) 150.48,29.88 143.91,29.88 139.77,34.02 138.18,34.02 137.24,34.96 134.33,34.96 133.11,33.74 128.4,33.74 128.33,33.81 114.43,33.81 107.89,27.27 46.27,27.27 44.18,29.37 v2(39.99,29.37)
  IN2 w0.102: v2(252.58,68.38) 252.41,68.56 248.95,68.56 248.65,68.26 248.65,62.26 249.58,61.32 250.3,61.32 250.42,61.2 250.42,60.56 251.75,59.24 v2(251.75,58.99)
PLTRST#_BUF: length 345.8
  TOP w0.102: Q5002.2 128.63,28.68 126.85,26.91 122.9,26.91 122.24,27.57 121.56,27.57 120.76,26.76 v2(120.76,23.73) ; U2401.4 226.64,30.25 225.96,30.92 225.96,33.22 v2(223.82,35.36) ; 298.05,93.45 298.23,93.28 R5319.2 ; 298.05,93.45 298.23,93.63 298.23,94.35 299.09,95.21 D5303.2 299.12,95.67 299.12,98.08 299.32,98.28 R5355.2 300.34,98.86 300.34,99.55 300.05,99.83 D5308.2 ; 298.05,93.45 292.64,93.45 291.5,92.31 287.99,92.31 287.19,93.11 SR3304.1 v2(286.37,90.28)
  IN3 w0.102: v2(258.55,39.5) 258.55,39.83 264.8,46.08 266.49,46.08 269.88,49.47 269.88,55.02 273.06,58.19 v2(273.06,59.8) 274.47,59.8 276.31,61.64 276.31,63.51 276.17,63.64 276.17,64.84 276.76,65.43 278.27,65.43 280.85,68.01 280.85,69.51 281.64,70.3 281.64,73.48 283.97,75.81 283.97,80.91 285.12,82.06 285.12,85.99 284.44,86.67 284.44,88.35 v2(286.37,90.28)
  IN4 w0.102: v2(258.55,39.5) 257.49,40.56 256.66,40.56 255.52,39.42 255.52,38.54 255.19,38.21 249.82,38.21 248.98,37.37 243.69,37.37 243.17,36.85 229.54,36.85 227.63,34.94 224.24,34.94 v2(223.82,35.36) 223.78,35.41 214.03,35.41 209.13,30.51 206.51,30.51 201.07,25.06 196.15,25.06 193.47,22.38 184.53,22.38 184,21.84 176.11,21.84 175.22,22.74 171.79,22.74 170.24,21.19 166.45,21.19 165.49,20.23 143.73,20.23 140.91,23.04 121.24,23.04 120.76,23.53 v2(120.76,23.73)
  BOTTOM w0.102: v2(120.76,23.73) 121.79,24.77 121.79,25.22 122.74,26.17 122.74,32.34 123.04,32.65 123.04,33.87 123.87,34.69 123.87,43.73 123.6,44 123.6,44.5 124.11,45.01 124.11,45.97 124.26,46.12 124.26,47.7 125.68,49.11 125.68,52.41 127.79,54.53 127.79,64.14 127.45,64.49 127.45,66.19 126.13,67.51 126.13,80.41 129.66,83.94 129.66,87.38 129.39,87.65 SR7001.1 ; U1104.2 279.81,55.15 280.04,54.92 280.42,54.92 280.73,55.23 280.73,56.63 279.87,57.49 279.13,57.49 278.29,58.33 278.29,58.52 R1116.1 277.48,58.93 277.35,59.06 277.35,60.79 276.97,61.17 v1(274.53,61.17) 273.98,61.17 273.06,60.25 v2(273.06,59.8)
PLTRST#_BUF_AR: length 10.3
  BOTTOM w0.102: v1(277.98,60.76) 277.88,60.66 R1116.2 278.19,59.79 278.49,59.49 278.49,58.41 279.21,57.69 279.95,57.69 281.01,56.64 281.01,56.29 281.2,56.1 U1104.4 281.8,55.64 281.74,55.58 281.74,54.96 281.99,54.71 282.37,54.71 282.91,54.17 SR1101.2
PLTRST_CPU#: length 369.3
  TOP w0.121: v2(57.61,127.79) v1(58.58,127.79)
  IN1 w0.083: v2(57.61,127.79) 58.1,127.31 65.12,127.31 68.11,130.31 69.78,130.31 71.13,128.96 71.63,128.96 73.36,127.24 v3(73.54,127.24)
  IN2 w0.083: v2(57.61,127.79) 57.61,127.17 54.57,124.12 54.57,113.31 53.4,112.14 50.51,112.14 50.02,112.63 v2(47.5,112.63)
  IN3 w0.083: v2(226.9,75.35) 224.14,75.35 223.13,74.34 222.83,74.34 216.48,68 214.68,68 212.59,65.91 212.59,65.14 210.56,63.11 209.99,63.11 208.98,62.1 207.42,62.1 205.12,59.8 203.26,59.8 201.88,58.42 201.88,52.39 202.33,51.94 202.33,47.59 197.31,42.56 196.75,42.56 192.46,38.28 171.73,38.28 170.94,37.49 151.25,37.49 149.86,38.88 148.76,38.88 144.44,43.2 135.66,43.2 134.72,42.26 132.8,42.26 129.7,39.16 122.17,39.16 118.62,35.61 102.61,35.61 96.3,29.29 61.22,29.29 58.35,26.43 45.23,26.43 39.69,31.96 39.69,40.46 35.44,44.71 35.44,53.88 34.46,54.86 34.46,58.18 35.23,58.95 35.23,70.98 50.1,85.85 50.1,92.56 47.22,95.43 47.22,112.35 v2(47.5,112.63)
  BOTTOM w0.102: 231.76,70.19 231.78,70.17 231.78,69.68 231.68,69.49 231.68,69.42 U2000.AK2
  BOTTOM w0.121: U0300.BP35 75.31,127.57 74.87,127.57 74.76,127.46 73.77,127.46 v3(73.54,127.24) ; v2(226.9,75.35) 227.12,75.35 227.25,75.23 227.25,74.34 R2474.1 227.93,73.65 227.93,73.33 228.34,72.93 229.51,72.93 229.91,72.52 230.28,72.52 230.71,72.1 230.71,71.95 231.76,70.9 231.76,70.19 ; R4418.2 58.05,126.74 58.05,127.51 57.77,127.79 v2(57.61,127.79)
PM_CLKRUN#: length 146.7
  TOP w0.102: v2(247.53,59.04) 247.15,58.66 245.9,58.66 245.63,58.93 R2251.2 245.18,59.31 244.07,59.31 243.94,59.44 242.52,59.44 242.11,59.04 241.8,59.04 241.75,58.99 241.6,58.99 241.18,58.57 240.86,58.57 240.54,58.25 238.1,58.25 237.73,58.61 236.51,58.61 v2(236.1,59.02) ; U6200.15 231.19,30.43 231.76,31 234.88,31 v2(235.46,30.41) ; v2(162.51,15.69) 162.51,16.84 162.15,17.19 162.15,19.34 160.89,20.61 160.89,21.05 160.63,21.31 159.69,21.31 159.45,21.07 159.45,20.33 159.66,20.11 U3002.93
  IN1 w0.102: v2(247.53,59.04) 247.53,58.36 247.89,58 247.89,48.65 247.42,48.17 247.42,44.16 245.03,41.78 242.67,41.78 240.47,39.57 240.47,38.27 235.46,33.27 v2(235.46,30.41)
  IN4 w0.102: v2(162.51,15.69) 163.07,15.13 179.11,15.13 180.4,16.42 186.33,16.42 186.56,16.65 206.13,16.65 209.02,19.54 209.02,20.98 210.72,22.68 210.86,22.68 211.68,23.51 228.65,23.51 231.37,26.23 231.37,26.92 233.88,29.43 234.48,29.43 v2(235.46,30.41)
  BOTTOM w0.102: v1(235.46,31.05) v2(235.46,30.41) ; v2(236.1,59.02) 236.1,59.35 U2000.AW22
PM_DOWN: length 364.6
  IN1 w0.083: v2(53.73,115.73) 54.2,115.26 56.03,115.26 60.64,119.87 66.33,119.87 69.7,123.25 72.96,123.25 73.91,124.2 73.91,127.73 73.11,128.53 73.11,128.79 v3(72.52,129.37)
  IN3 w0.083: v2(53.73,115.73) 52.84,114.84 52.84,114.56 52.53,114.26 52.08,114.26 47.97,110.15 47.97,95.27 50.49,92.75 50.49,85.69 35.83,71.03 35.83,44.91 40.87,39.87 40.87,31.34 45.39,26.81 58,26.81 60.87,29.68 96.02,29.68 102.34,36 118.45,36 122,39.55 129.54,39.55 133.15,43.15 134.72,43.15 135.19,43.61 135.19,43.93 135.48,44.22 135.59,44.22 135.95,44.58 146.21,44.58 151.01,39.78 151.01,39.37 151.73,38.65 170.46,38.65 171.66,39.85 192.39,39.85 196.26,43.73 196.26,44.01 198.69,46.44 199.54,46.44 200.49,47.39 200.49,59.32 204.43,63.26 208.26,63.26 209.43,64.43 210.23,64.43 211.43,65.62 211.43,66.39 211.96,66.92 211.96,67.79 216.07,71.9 217.6,71.9 221.2,75.51 222.65,75.51 223.67,76.53 230.83,76.53 231.63,75.72 231.63,72.2 v2(230.26,70.83)
  BOTTOM w0.121: v3(72.52,129.37) 71.25,130.64 v1(69.81,130.64) 69.59,130.42 R0731.1 ; v2(230.26,70.83) 230.77,70.33 230.77,69.48 U2000.AH2
PM_PWRBTN#: length 390.4
  TOP w0.102: v2(157.98,14.73) 157.66,15.04 157.66,17.14 157.96,17.44 157.96,18.38 157.82,18.52 157.51,18.52 157.26,18.77 U3002.87 157.26,20.99 152.51,25.75 152.51,29.65 v2(153.19,30.33) ; v2(234.42,64.49) 234.96,65.02 234.96,65.78 235.37,66.2 236.96,66.2 238.77,68 v1(238.77,69.73) 238.77,71.1 C2400.1 v2(239.5,72.51) R2447.2 ; v2(54.72,37.83) 54.29,37.4 54.29,36.99 59.68,31.6 59.68,24.38 56.65,21.34 v2(56.65,20.63)
  IN1 w0.102: v2(153.19,30.33) 153.73,29.8 161.55,29.8 162.11,29.24 164.72,29.24 165.33,29.85 195.97,29.85 202.46,36.34 202.46,38.14 206.93,42.6 206.93,43.53 211.73,48.33 215.46,48.33 215.7,48.57 217.51,48.57 217.82,48.26 220.04,48.26 220.33,48.55 228.77,48.55 229.22,49 230.96,49 231.42,49.46 233.71,49.46 235.21,50.96 235.99,50.96 236.35,51.32 236.35,52.18 238.08,53.91 238.08,66.39 237.34,67.13 237.34,69.3 238.77,70.73 238.77,71.78 v2(239.5,72.51)
  IN4 w0.102: v2(157.98,14.73) 156.97,15.74 146.17,15.74 145.13,14.71 131.69,14.71 129.86,16.53 124.12,16.53 120.9,19.75 119.43,19.75 117.96,21.22 117.53,21.22 116.97,20.66 67.72,20.66 65.95,22.44 58.04,22.44 56.65,21.05 v2(56.65,20.63) ; v2(54.72,37.83) 54.72,38.46 48.37,44.81 40.38,44.81 36.56,48.64 36.56,51.19 34.37,53.38 34.37,63.89 38.18,67.7 38.18,81.02 44.07,86.9 44.51,86.9 51.97,94.37 51.97,96.1 54.74,98.86 57.4,98.86 57.69,99.15 57.69,99.6 61.58,103.49 61.58,110.09 60.81,110.85 60.81,117.49 v2(60.57,117.74)
  BOTTOM w0.102: U2000.AT13 234.67,64.24 v2(234.42,64.49) ; R4415.2 59.31,123.61 60.84,122.08 60.84,118 v2(60.57,117.74)
PM_RSMRST#: length 378.1
  TOP w0.102: v2(166.79,27.56) 166.6,27.38 166.6,26.62 166.5,26.52 165.41,26.52 165.36,26.58 R3066.2 165,26.93 164.97,26.9 163.56,26.9 163.35,27.11 U3002.112 ; v2(241.31,74.08) 241.63,74.08 242.55,75 SR2408.1
  IN1 w0.102: v2(166.79,27.56) 166.79,27.18 167.2,26.77 196.31,26.77 204.75,35.21 205.47,35.21 208.77,38.51 208.77,41.02 209.35,41.6 209.35,42.53 211.91,45.09 221.03,45.09 221.68,44.43 222.29,44.43 222.58,44.14 232.78,44.14 233.64,45 236.75,45 237.52,45.77 238.48,45.77 241.2,48.5 241.2,52.42 241.31,52.52 241.31,52.53 243.21,54.44 243.21,67.27 243.87,67.93 243.87,68.27 246.7,71.1 246.94,71.1 247.38,71.54 247.38,71.87 245.62,73.63 241.75,73.63 v2(241.31,74.08)
  IN2 w0.102: v2(59.07,120.81) 57.82,119.56 57.82,113.99 54.14,110.31 50.56,110.31 50.07,109.81 48.34,109.81 41.38,102.86 41.38,88.73 41.05,88.4 41.05,77.69 33.97,70.6 33.97,48.28 31.86,46.18 31.86,43.49 32.72,42.63 32.72,40.01 34.75,37.98 34.75,33.78 35.56,32.98 40.25,32.98 45.62,27.6 69.44,27.6 70.45,28.61 103.79,28.61 104.6,29.42 107.77,29.42 109.75,27.44 120.35,27.44 121.85,28.94 124.1,28.94 126.41,31.25 127.08,31.25 129.67,31.25 135.12,25.8 161.11,25.8 162.29,26.98 165.33,26.98 165.51,27.16 166.39,27.16 v2(166.79,27.56)
  BOTTOM w0.102: R4406.2 58.44,123.28 59.3,122.43 59.3,121.04 v2(59.07,120.81) v1(60.17,119.71)
PM_SUSB#: length 279.3
  TOP w0.102: v2(153.8,37.03) 153.8,37.36 R3062.2 153.14,37.2 153.38,36.97 153.38,36.58 154.06,35.89 U3002.18 ; v2(134.98,12.3) 135.06,12.22 v1(135.67,12.22) R3074.1 ; SR2401.1 234.66,74.77 235.25,75.36 v2(235.36,75.36)
  IN1 w0.102: v2(137.81,15.49) 139.48,17.15 142.2,17.15 143.92,18.88 146.69,18.88 147.83,20.02 165.77,20.02 167,18.79 191.31,18.79 193.71,21.19 202.89,21.19 207.09,25.39 207.09,26.29 208.35,27.54 229.32,27.54 229.82,28.04 243.81,28.04 247.84,32.06 252.87,32.06 254.19,33.38 255.96,33.38 256.39,33.81 256.39,35.58 257.85,37.04 260.51,37.04 v2(260.92,37.45) 260.92,37.85 260.28,38.49 258.05,38.49 257.65,38.89 257.65,39.92 254.24,43.34 254.24,44.06 253.32,44.98 253.32,60.83 253.6,61.11 253.6,64.88 248.95,69.53 v2(248.95,73.99)
  IN2 w0.102: v2(273.89,49.94) 273.49,49.54 273.35,49.54 265.93,42.12 265.44,42.12 260.92,37.59 v2(260.92,37.45) ; v2(235.36,75.36) 236.26,76.26 237.88,76.26 238.67,77.05 245.35,77.05 v2(246.11,77.81)
  BOTTOM w0.102: U1105.2 274.43,49.41 v2(273.89,49.94) 273.89,50.6 273.27,51.23 R1117.1 ; v2(153.8,37.03) 153.4,37.43 151.95,37.43 148.06,33.55 148.06,29.83 148.95,28.94 150.22,28.94 150.98,28.18 150.98,22.21 150.73,21.95 SR0702.1 147.34,21.41 147.1,21.17 146.36,21.17 141.17,15.98 138.31,15.98 v2(137.81,15.49) 134.98,12.66 v2(134.98,12.3) ; U2403.2 248.77,73.82 v2(248.95,73.99) 248.95,74.41 248.77,74.58 247.89,74.58 247.63,74.32 247.63,73.87 247.4,73.64 R2491.1
  BOTTOM w0.121: R2491.1 246.59,73.64 246.41,73.82 246.41,75.01 246.67,75.27 246.67,76.08 246.11,76.64 v2(246.11,77.81)
PM_SUSC#: length 258.8
  TOP w0.102: U3002.21 152.86,36.85 152.25,37.46 151.71,37.46 151.49,37.68 R3063.2 151.19,38.02 151.09,38.12 151.09,39.63 150.55,40.16 143.52,40.16 v2(135.82,32.46) ; v2(134.35,12.3) 134.78,12.73 144.91,12.73 R3075.1
  IN1 w0.102: v2(251.85,63.62) 251.85,60.64 251.42,60.21 251.2,60.21 250.58,59.59 250.58,58.61 252.28,56.9 252.28,54.94 251.72,54.38 251.72,52.71 251.89,52.55 251.89,47.7 252.43,47.15 252.43,44.54 252.26,44.37 252.26,42.69 252.68,42.27 254.35,42.27 255.5,41.12 255.5,35.92 252.98,33.4 250.96,33.4 250.51,32.95 247.45,32.95 243.59,29.09 231.81,29.09 230.88,30.02 209.6,30.02 201.82,22.23 184.4,22.23 183.79,22.84 181.66,22.84 179.52,20.71 172.62,20.71 172.1,20.19 169.94,20.19 169.64,20.49 169.64,20.76 169.13,21.27 166.31,21.27 165.83,21.75 163.07,21.75 162.84,21.98 145.01,21.98 142.03,18.99 136.09,18.99 v2(135.54,19.54)
  IN2 w0.102: v2(251.85,63.62) 251.99,63.48 256.15,63.48 256.17,63.46 256.51,63.46 256.54,63.48 257.99,63.48 259.8,65.29 260.93,65.29 261.54,65.89 265.57,65.89 265.73,66.05 266.86,66.05 269.02,68.21 v2(271.53,68.21)
  BOTTOM w0.102: SR2402.1 249.47,64.65 250.01,64.12 250.68,64.12 251.11,63.68 251.78,63.68 v2(251.85,63.62) ; SR3108.1 272.42,58.15 271.38,59.19 271.38,68.05 v2(271.53,68.21) ; v2(135.82,32.46) 134.35,30.99 v1(134.35,29.53) 134.35,24.11 132.87,22.64 132.87,22.19 135.52,19.54 v2(135.54,19.54) 136.18,18.9 136.18,16.97 136.96,16.19 136.96,15.07 134.35,12.45 v2(134.35,12.3)
PM_SYNC: length 334.2
  IN2 w0.083: v3(76.66,127.55) 76.61,127.61 71.73,127.61 70.78,126.66 70.78,120.7 70.85,120.63 70.85,112.52 69.04,110.7 65.28,110.7 60.45,105.86 53.53,105.86 47.94,100.27 47.94,94.51 48.77,93.68 48.77,77.55 38.41,67.19 38.41,46.03 45.73,38.72 50.32,38.72 56.05,32.99 100.55,32.99 v2(102.57,35.01)
  IN3 w0.083: v2(102.57,35.01) 102.79,35.22 118.78,35.22 122.33,38.77 129.87,38.77 132.96,41.87 134.88,41.87 135.82,42.81 144.28,42.81 148.6,38.49 149.7,38.49 151.56,36.63 161.67,36.63 162.14,37.1 171.1,37.1 171.9,37.89 192.62,37.89 196.91,42.18 197.47,42.18 202.79,47.5 202.79,52.88 202.27,53.4 202.27,58.26 203.42,59.41 206.42,59.41 208.15,61.15 208.59,61.15 210.16,62.72 210.72,62.72 212.97,64.98 212.97,65.69 214.81,67.52 216.55,67.52 221.46,72.43 223.61,72.43 225.96,74.78 v2(226.22,74.78)
  BOTTOM w0.102: U0300.BM34 76.99,127.23 v3(76.66,127.55)
  BOTTOM w0.121: v1(228.06,75.94) 226.79,75.94 226.22,75.37 v2(226.22,74.78) R2228.2
PM_SYNC_R: length 8.8
  BOTTOM w0.089: U2000.AJ4 230.98,68.52 231.3,68.84 231.3,69.61 231.22,69.69 231.22,70.29
  BOTTOM w0.121: 231.22,70.29 231.22,70.81 230.55,71.48 230.09,71.48 229.39,72.18 v1(229.39,72.3) 229.05,72.64 227.34,72.64 227.1,72.89 227.1,73.65 R2228.1
PRE_SEL: length 11.4
  TOP w0.102: U1301.16 297.2,80.92 v2(296.91,80.63) 296.91,80.45 296.5,80.04 296.5,79.71 295.94,79.15 R1323.1 295.51,79.94 v1(295.41,80.04)
  BOTTOM w0.102: R1322.2 291.24,81.34 291.43,81.15 292.83,81.15 293.41,80.56 294.03,80.56 295.26,80.56 295.81,81.12 296.41,81.12 v2(296.91,80.63)
PROC_AUDIO_CLK: length 207
  IN3 w0.083: v2(211.72,76.49) 211.01,76.49 209.19,74.67 204.33,74.67 198.1,68.44 198.1,65.4 193.97,61.27 193.97,54.12 189.22,49.37 189.22,48.26 185.48,44.52 170.46,44.52 170.08,44.89 155.65,44.89 151.76,48.77 151.76,50.58 148.87,53.47 147.93,53.47 146.58,52.11 140.25,52.11 139.41,52.96 139.41,53.36 134.08,58.69 132.49,58.69 125.7,65.48 125.7,71.56 121.6,75.65 121.6,85.11 122.25,85.76 122.25,87.33 122.25,87.65 122.25,87.65 122.25,88.04 121.19,89.09 121.19,104.17 122.01,104.98 122.01,109.79 117.68,114.11 117.68,120.12 115.95,121.85 111.85,121.85 v3(111.44,122.27)
  BOTTOM w0.121: R2311.1 232.37,75.15 232.37,76.13 230.94,77.56 v1(229,77.56) 222.82,77.56 222.67,77.41 213.3,77.41 212.37,76.49 v2(211.72,76.49) ; U0300.G27 111.44,122.34 v3(111.44,122.27)
PROC_AUDIO_SDI: length 206.8
  IN3 w0.083: v2(211.23,75.97) 209.47,74.21 204.52,74.21 198.56,68.24 198.56,65.21 194.43,61.08 194.43,53.92 189.69,49.18 189.69,48.07 185.67,44.05 170.27,44.05 169.89,44.43 155.45,44.43 151.3,48.58 151.3,50.39 148.68,53 148.14,53 146.79,51.65 140.06,51.65 139.79,51.92 138.94,52.77 138.94,53.17 133.88,58.23 132.29,58.23 125.24,65.29 125.24,71.36 121.14,75.46 121.14,85.31 121.78,85.95 121.78,87.52 121.78,87.85 120.73,88.9 120.73,104.36 121.54,105.18 121.54,108.69 117.23,113.01 117.23,113.92 117.22,113.92 117.22,119.93 115.76,121.39 111.46,121.39 v3(110.78,120.7)
  BOTTOM w0.114: v3(110.78,120.7) 110.78,120.76 U0300.G25
  BOTTOM w0.121: v2(211.23,75.97) 212.56,75.97 213.5,76.91 222.88,76.91 223.03,77.06 v1(230.73,77.06) 231.68,76.11 231.68,75 R2307.1
PROC_AUDIO_SDO: length 208.5
  TOP w0.114: R0302.2 118.29,121.6 v2(118.42,121.72)
  TOP w0.121: v1(119.11,121.93) 118.62,121.93 v2(118.42,121.72)
  IN3 w0.083: v2(118.42,121.72) 118.42,114.22 122.62,110.03 122.62,104.94 121.65,103.98 121.65,89.29 122.71,88.23 122.71,85.57 122.06,84.92 122.06,75.87 126.16,71.77 126.16,65.67 132.68,59.16 134.27,59.16 139.87,53.56 139.87,53.15 140.44,52.58 146.39,52.58 147.74,53.93 149.07,53.93 152.23,50.77 152.23,50.39 152.23,49 155.87,45.36 170.27,45.36 170.65,44.98 185.29,44.98 188.76,48.45 188.76,49.56 193.5,54.31 193.5,61.47 197.63,65.59 197.63,68.63 204.14,75.13 209,75.13 210.86,76.99 v2(212.12,76.99)
  BOTTOM w0.121: v2(212.12,76.99) 212.17,76.99 213.09,77.91 222.46,77.91 222.61,78.06 231.32,78.06 233.25,76.13 233.25,73.68 233.56,73.37 233.56,72.82 233.7,72.68 233.7,72.23 233.38,71.91 233.38,70.16 233.25,70.03 233.25,69.51 U2000.AN2
PROC_AUDIO_SDO_R: length 7.4
  TOP w0.121: R0302.1 116.52,121.88 113.8,121.88 113.39,122.28 113.39,122.54 v1(112.68,123.25) 111.44,124.49 v3(111.44,124.63)
  BOTTOM w0.121: v3(111.44,124.63) 111.11,124.31 U0300.G29
PROCHOT#: length 498.4
  TOP w0.121: v2(262.94,35.39) 262.94,34.92 SR8811.2
  IN2 w0.083: v2(44.23,87.51) 44.23,88.48 43.41,89.3 43.41,100.87 45.93,103.4 46.53,103.4 51.41,108.28 54.98,108.28 60.34,113.65 v2(60.34,114.41)
  IN3 w0.083: v2(44.23,87.51) 44.23,86.98 36.58,79.33 36.58,77.61 30.89,71.91 20.89,71.91 17.89,68.91 17.89,61.83 16.37,60.31 16.37,54.3 22.7,47.97 22.7,46.86 26.45,43.11 26.45,36.76 25.93,36.24 25.93,24.96 27.46,23.43 27.46,20.89 28.56,19.79 30.86,19.79 33.42,17.23 40.27,17.23 41.27,16.22 47.39,16.22 48.61,17.44 60.88,17.44 62.85,19.41 109.56,19.41 112.1,21.95 115.73,21.95 116.25,22.47 116.71,22.47 120.19,25.95 134.56,25.95 135.23,25.28 145.98,25.28 146.29,24.97 168.45,24.97 168.95,25.47 185.26,25.47 186.45,24.28 186.45,24.02 186.68,23.79 187.09,23.79 188.02,24.73 189.49,24.73 190.34,23.89 196.16,23.89 197.56,25.28 201.66,25.28 205.61,29.23 219.97,29.23 224.67,24.53 225.46,24.53 226.51,25.58 226.51,26.81 229.9,30.2 231.94,30.2 232.14,30 243.44,30 246.61,33.17 249.35,33.17 250.69,34.51 252.51,34.51 253.4,35.41 257.52,35.41 258.11,35.99 258.56,35.99 259.38,35.18 261.26,35.18 261.88,35.8 262.54,35.8 v2(262.94,35.39)
  IN4 w0.083: v2(58.91,189.94) 57.81,188.84 57.81,182.31 54.61,179.11 54.61,178.41 52.97,176.77 48.94,176.77 47.17,175 47.17,156.98 47.77,156.37 53.45,156.37 54.59,155.23 54.59,148.42 55.3,147.71 55.3,135.79 54.2,134.7 53.43,134.7 51.87,133.14 51.87,122.87 v2(60.34,114.41)
  BOTTOM w0.121: R80150.2 70.14,127.54 70.03,127.54 R0727.1 69.37,127.99 R0706.1 68.01,127.15 67.32,127.85 Q0702.3 66.53,126.43 65.77,125.67 65.77,124.49 63.4,122.13 63.4,119.64 63.2,119.44 v1(63.2,118.24) 63.2,115.58 62.03,114.41 v2(60.34,114.41) ; v2(58.91,189.94) 58.68,189.71 SR8009.1
PROCHOT#_R: length 6.9
  BOTTOM w0.076: 73.11,125.05 73.32,124.84 73.83,124.84 74.2,125.2 74.62,125.2 75.03,124.8
  BOTTOM w0.089: 75.03,124.8 U0300.BR30
  BOTTOM w0.121: R0727.2 71.37,127.99 v1(71.41,127.95) 71.67,127.68 71.67,127.58 72.2,127.05 72.2,125.96 73.11,125.05
PROG1: length 7.6
  BOTTOM w0.102: v1(54.31,190.87) 53.86,190.87 53.8,190.81 R8028.1 52.64,190.13 52.64,189.57 53.14,189.06 53.14,187.61 53.31,187.44 54.4,187.44 54.72,187.12 54.95,187.12 55.37,186.69 U8000.40
PROG2: length 6.2
  BOTTOM w0.102: U8000.39 54.97,186.69 54.75,186.92 54.64,186.92 54.34,187.21 53.26,187.21 52.77,187.7 52.77,188.52 v1(52.71,188.58) 52.43,188.86 R8041.1
PROG3: length 6.9
  BOTTOM w0.102: U8000.38 54.57,186.69 54.27,186.99 53.19,186.99 52.57,187.61 52.57,188.01 51.44,189.14 v1(51.05,189.14) 50.65,189.54 R8046.1
PROG4: length 7.7
  BOTTOM w0.102: R8087.1 49.76,190.18 v1(49.41,189.82) 49.73,189.82 50.89,188.66 51.63,188.66 52.36,187.93 52.36,187.53 53.11,186.78 54.01,186.78 54.17,186.62 U8000.37
PROG5: length 9.6
  BOTTOM w0.102: U8000.36 52.96,185.74 52.16,186.54 52.16,187.84 51.66,188.34 50.77,188.34 49.78,189.34 49.26,189.34 48.88,189.72 R8085.1 48.06,191.62 v1(47.78,191.62)
PRSNT#: length 3
  TOP w0.102: U4601.20 298.68,107.39 v1(297.9,106.61) 297.9,106.1 R4611.1
PS_NVVDD_PHASE1: length 8.9
  TOP w0.432: R74104.2 185.07,172.78
  TOP w0.635: 180.7,165.03 180.7,168.26
  BOTTOM w0.635: 185.27,175.11 185.91,175.75 185.91,178.42 186.51,179.02
  vias: v1(183.75,173.72) v4(174.99,171.69) v4(174.99,170.8) v4(174.99,169.91) v4(174.99,169.02) v4(175.88,171.69) v4(175.88,170.8) v4(175.88,169.91) v4(175.88,169.02) v4(176.76,171.69) v4(176.76,170.8) v4(176.76,169.91) v4(176.76,169.02) v4(182.12,171.3) v4(182.12,170.42) v4(182.12,169.53) v4(182.12,168.64) v4(183.01,171.3) v4(183.01,170.42) v4(183.01,169.53) v4(183.01,168.64) v4(183.95,170.42) v4(183.95,169.53) v4(183.95,168.64)
PS_NVVDD_PHASE2: length 3.3
  TOP w0.635: 141.26,168.13 141.26,164.85
  vias: v1(139.53,169.3) v4(135.74,170.03) v4(135.74,169.15) v4(135.74,168.26) v4(135.74,167.37) v4(136.63,170.03) v4(136.63,169.15) v4(136.63,168.26) v4(136.63,167.37) v4(137.52,170.03) v4(137.52,169.15) v4(137.52,168.26) v4(137.52,167.37)
PS_NVVDD_PHASE3: length 3.4
  TOP w0.635: 155.68,168.13 155.68,164.78
  vias: v1(154.62,174.38) v4(150.09,171.18) v4(150.09,170.29) v4(150.09,169.4) v4(150.09,168.51) v4(150.98,171.18) v4(150.98,170.29) v4(150.98,169.4) v4(150.98,168.51) v4(151.87,171.18) v4(151.87,170.29) v4(151.87,169.4) v4(151.87,168.51) v4(157.21,171.3) v4(157.21,170.42) v4(157.21,169.53) v4(157.21,168.64) v4(158.1,171.3) v4(158.1,170.42) v4(158.1,169.53) v4(158.1,168.64) v4(158.98,171.3) v4(158.98,170.42) v4(158.98,169.53) v4(158.98,168.64)
PS_NVVDD_PHASE4: length 3.3
  TOP w0.635: 168.76,168.13 168.76,164.83
  vias: v1(162.77,174.33) v4(163.05,171.3) v4(163.05,170.42) v4(163.05,169.53) v4(163.05,168.64) v4(163.94,171.3) v4(163.94,170.42) v4(163.94,169.53) v4(163.94,168.64) v4(164.83,171.3) v4(164.83,170.42) v4(164.83,169.53) v4(164.83,168.64) v4(170.67,171.43) v4(170.67,170.54) v4(170.67,169.65) v4(170.67,168.76) v4(171.56,171.43) v4(171.56,170.54) v4(171.56,169.65) v4(171.56,168.76) v4(172.45,171.43) v4(172.45,170.54) v4(172.45,169.65) v4(172.45,168.76)
PS_NVVDD_STBY: length 4.6
  TOP w0.102: R7444.2 145.98,69.83 145.98,70.44 146.21,70.67 146.21,71.58 146.01,71.79 R7478.2 146.16,72.17 146.42,72.17 146.8,72.54 146.8,73.21 v1(146.79,73.21)
PSI: length 5.3
  TOP w0.102: v1(250.04,77.73) 250.45,78.14 250.45,79.97 250.25,80.17 R8902.2 R8903.1 249.41,80.42 249.41,80.96 249.17,81.19 U8900.4
PSYS: length 7.7
  BOTTOM w0.102: U8000.1 59.44,185.74 59.54,185.85 59.54,186.34 59.96,186.76 59.96,190.31 R8021.2 C8010.2 58.28,190.73 v1(57.69,191.32)
PV: length 1.6
  TOP w0.254: U9702.10 90.53,180.55 90.44,180.45 R9707.1
PWM1_A: length 54.7
  TOP w0.254: v2(51.92,180.37) 54.13,178.16 64.54,178.16 66.45,176.25 66.45,173.29 68.22,171.52 68.22,168.01 68.46,167.77 68.46,166.78 67.16,165.49 67.16,164.74 67.42,164.49 67.42,162.97 68.94,161.45 68.94,148.6 67.19,146.84 67.19,146.34 67.62,145.9 v2(67.67,145.9)
  BOTTOM w0.102: U8001.1 68.55,144.57 v1(68.28,144.3)
  BOTTOM w0.203: v2(51.92,180.37) 52.18,180.63 52.76,180.63 53.19,181.06 53.19,181.16 53.38,181.34 U8000.25
  BOTTOM w0.254: U8001.1 68.16,146.19 67.88,145.9 v2(67.67,145.9)
