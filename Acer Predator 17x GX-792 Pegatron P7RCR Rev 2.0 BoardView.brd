# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EXP_TXN5_C: length 26.4
  BOTTOM w0.089: 142.52,98.07 142.47,98.07 ; 142.55,98.07 142.58,98.1 142.82,98.1 143.15,98.43 143.28,98.43 143.36,98.36 143.36,98.13 143.44,98.05 143.69,98.05 143.75,98.11 U7000.BM33
  BOTTOM w0.121: C7025.1 126.52,109.33 126.63,109.43 126.63,109.55 126.4,109.78 126.4,109.87 126.51,109.98 126.76,109.98 126.95,109.79 128.78,109.79 129.51,109.06 129.51,106.42 131.53,104.41 131.53,103.55 137.01,98.07 142.47,98.07 ; 142.55,98.07 142.52,98.07
EXP_TXN6: length 15.4
  BOTTOM w0.076: 115.92,113.49 115.87,113.44 115.65,113.44 115.41,113.69 114.09,113.69 114.03,113.74 114.03,113.94 114.09,114 U0300.B16
  BOTTOM w0.121: 126.35,111.01 123.65,111.01 121.16,113.49 115.92,113.49 ; 126.35,111.01 126.96,111.01 C7030.2 ; 126.35,111.01 v1(126.35,111.22)
EXP_TXN6_C: length 24.9
  BOTTOM w0.089: U7000.BK33 144.76,98.84 144.33,98.84 144.02,99.15 142.88,99.15 142.7,98.97 142.45,98.97 142.42,98.99 142.4,98.99
  BOTTOM w0.121: 142.4,98.99 137.35,98.99 132.42,103.92 132.42,104.84 130.56,106.7 130.56,109.94 129.14,111.36 C7030.1
EXP_TXN7: length 11.3
  BOTTOM w0.076: 116.57,113.97 116.56,113.97 116.51,114.02 116.17,114.02 115.76,114.42 114.92,114.42 114.55,114.79 U0300.B17
  BOTTOM w0.121: 116.57,113.97 121.36,113.97 123.59,111.74 C7032.2
EXP_TXN7_C: length 28.5
  BOTTOM w0.089: 143.08,99.42 143.1,99.42 143.12,99.45 143.31,99.45 143.42,99.34 144.03,99.34 144.19,99.49 144.6,99.49 144.67,99.57 144.67,99.73 144.55,99.85 U7000.BL35
  BOTTOM w0.121: 143.08,99.42 137.53,99.42 132.85,104.1 132.85,105.02 131.01,106.85 131.01,110.4 129.09,112.32 126.38,112.32 126.3,112.4 125.93,112.4 125.86,112.32 125.86,111.94 125.66,111.74 C7032.1
EXP_TXN8: length 15.2
  BOTTOM w0.076: U0300.C18 114.02,115.88 114.49,115.88 114.68,115.69 114.68,115.47 114.89,115.26 115.35,115.26 115.55,115.06 116.06,115.06 116.12,115.12 116.16,115.12
  BOTTOM w0.121: 126.42,113.57 126.98,113.57 C7034.2 ; 126.42,113.57 123.14,113.57 121.59,115.12 116.16,115.12 ; 126.42,113.57 v1(126.42,113.79)
EXP_TXN8_C: length 24.2
  BOTTOM w0.121: U7000.BM36 143.53,100.33 137.88,100.33 133.74,104.47 133.74,105.39 131.91,107.22 131.91,111.24 129.61,113.53 128.55,113.53 C7034.1
EXP_TXN9: length 11.2
  BOTTOM w0.121: C7036.2 124.44,115.37 124.24,115.37 124.11,115.25 124.11,114.63 124,114.52 123.9,114.52 122.4,116.02 116.58,116.02 116.36,116.25 115.13,116.25 U0300.A19
EXP_TXN9_C: length 28.6
  BOTTOM w0.102: U7000.BK36 144.96,100.55 144.6,100.91 144.26,100.91 144.1,101.07 141.88,101.07 141.87,101.09 141.84,101.09
  BOTTOM w0.121: C7036.1 126.68,115.17 127.05,114.8 129.31,114.8 132.62,111.49 132.62,107.45 134.4,105.67 134.4,104.75 138.06,101.09 141.84,101.09
EXP_TXN10: length 14.4
  BOTTOM w0.076: 116.54,116.63 116.53,116.63 116.5,116.67 114.04,116.67 113.87,116.83 113.87,116.99 U0300.C20
  BOTTOM w0.121: 116.54,116.63 119.2,116.63 119.36,116.47 122.74,116.47 123.4,115.81 127.06,115.81 C7038.2
EXP_TXN10_C: length 27.1
  BOTTOM w0.102: U7000.BL38 144.45,101.8 144.06,101.41 143.35,101.41 143.23,101.53 141.7,101.53 141.69,101.52 141.66,101.52
  BOTTOM w0.121: 141.66,101.52 138.24,101.52 134.83,104.92 134.83,105.85 133.13,107.55 133.13,111.64 130.79,113.98 130.79,114.78 129.36,116.21 128.81,116.21 128.71,116.1 128.71,115.35 128.62,115.26 128.46,115.26 C7038.1
EXP_TXN11: length 10.7
  BOTTOM w0.076: 116.35,117.76 116.34,117.78 115.42,117.78 115.27,117.62 114.77,117.62 114.69,117.71 114.69,117.84 114.79,117.94 U0300.A21
  BOTTOM w0.121: C7040.2 123.93,117.38 119.72,117.38 119.33,117.76 116.35,117.76
EXP_TXN11_C: length 28.5
  BOTTOM w0.121: U7000.BM39 143.52,102.42 138.6,102.42 135.72,105.29 135.72,106.23 134.02,107.93 134.02,112.04 131.72,114.34 131.72,115.39 129.6,117.51 125.58,117.51 C7040.1
EXP_TXN12: length 15
  BOTTOM w0.076: 115.7,118.45 115.68,118.45 115.64,118.42 114.88,118.42 114.7,118.6 114.7,118.83 114.48,119.05 114.03,119.05 113.73,118.75
  BOTTOM w0.089: 113.73,118.75 U0300.C22
  BOTTOM w0.121: C7042.2 126.88,118.68 123.89,118.68 123.25,118.05 120.09,118.05 119.41,118.73 116.93,118.73 116.64,118.45 115.7,118.45
EXP_TXN12_C: length 27.6
  BOTTOM w0.102: U7000.BK39 144.95,102.65 144.62,102.98 144.26,102.98 144.04,103.21 143.42,103.21 143.34,103.13 142.69,103.13 142.68,103.15 142.65,103.15
  BOTTOM w0.121: 142.65,103.15 138.8,103.15 136.39,105.57 136.39,106.55 134.7,108.24 134.7,112.3 132.47,114.53 132.47,115.8 129.17,119.11 C7042.1
EXP_TXN13: length 11.5
  BOTTOM w0.076: U0300.A23 114.77,119.51 114.72,119.46 114.72,119.31 114.84,119.2 115.25,119.2 115.51,119.46 116.13,119.46 116.21,119.54 116.5,119.54 116.52,119.56
  BOTTOM w0.121: C7044.2 123.98,119.97 123.19,119.97 122.38,120.78 120.5,120.78 119.41,119.69 118.47,119.69 118.24,119.92 117,119.92 116.64,119.56 116.52,119.56
EXP_TXN13_C: length 31
  BOTTOM w0.102: 142.67,103.86 142.69,103.86 142.71,103.84 143.34,103.84 143.44,103.74 143.97,103.74 144.1,103.87 144.1,104.35 144.19,104.44 144.39,104.44 144.45,104.38 U7000.BL41
  BOTTOM w0.121: C7044.1 125.58,120.05 129.6,120.05 133.28,116.36 133.28,114.66 135.46,112.48 135.46,108.42 137.05,106.84 137.05,105.84 139.03,103.86 142.67,103.86
EXP_TXN14: length 15.4
  BOTTOM w0.076: 113.73,120.32 114.02,120.61 114.49,120.61 114.7,120.4 114.7,120.19 114.9,119.99 115.4,119.99 115.53,119.86 115.74,119.86 116.09,120.21 116.2,120.21 116.24,120.25 116.3,120.25
  BOTTOM w0.089: U0300.C24 113.73,120.32
  BOTTOM w0.121: 123.25,121.22 123.88,121.22 124.11,121.44 126.98,121.44 C7050.2 ; 123.25,121.22 v1(123.25,121.43) ; 123.25,121.22 122.88,121.22 122.65,121.44 119.9,121.44 119.06,120.61 116.74,120.61 116.39,120.25 116.3,120.25
EXP_TXN14_C: length 27
  BOTTOM w0.121: C7050.1 128.48,121.46 129.58,121.46 134.25,116.79 134.25,114.66 136.12,112.78 136.12,108.7 137.71,107.12 137.71,106.11 139.26,104.56 143.56,104.56 U7000.BM42
EXP_TXN15: length 12.7
  BOTTOM w0.076: U0300.A25 114.73,121.09 114.68,121.04 114.68,120.97 114.88,120.77 115.32,120.77 115.4,120.85 115.72,120.85 116.05,121.18 116.05,121.23 116.06,121.24
  BOTTOM w0.121: v1(119.31,122.33) 119.31,122.11 ; 119.31,122.11 123.57,122.11 124.19,122.74 124.72,122.74 C7052.2 ; 119.31,122.11 119.06,122.11 118.85,121.9 118.85,121.51 118.62,121.29 118.07,121.29 117.56,121.8 116.62,121.8 116.06,121.24
EXP_TXN15_C: length 31.2
  BOTTOM w0.121: C7052.1 126.12,122.82 129.44,122.82 134.96,117.3 134.96,114.92 136.79,113.09 136.79,108.98 138.37,107.39 138.37,106.39 139.43,105.32 144.07,105.32 144.31,105.09 144.68,105.09 145.02,104.75 U7000.BK42
EXP_TXP0: length 18.6
  BOTTOM w0.076: 116.13,108.59 116.08,108.63 116.06,108.63 116.04,108.66 115.52,108.66 115.37,108.81 114.18,108.81 114.17,108.83
  BOTTOM w0.089: U0300.C10 114.17,108.83
  BOTTOM w0.121: C7004.2 125.48,100.26 125.14,100.6 125.14,101.29 124.13,102.29 124.13,103 ; 124.13,103 124.13,104.15 122.26,106.02 121.7,106.02 121.21,106.51 121.21,107.41 120.24,108.38 119.34,108.38 119.14,108.59 116.13,108.59 ; 124.13,103 v1(123.91,103)
EXP_TXP0_C: length 21.1
  BOTTOM w0.102: U7000.BL27 144.45,93.91 144.4,93.86 144.16,93.86 144.08,93.94 144.08,94.49 143.91,94.66 143.39,94.66 143.31,94.58 142.9,94.58 142.88,94.56 142.86,94.56
  BOTTOM w0.121: v1(137.04,94.35) 137.04,94.56 ; 137.04,94.56 135.76,94.56 133.9,96.43 132.26,96.43 128.12,100.57 127.54,100.57 C7004.1 ; 137.04,94.56 142.86,94.56
EXP_TXP1: length 16.6
  BOTTOM w0.121: U0300.A11 115.22,109.86 116.25,109.86 116.44,109.67 120.22,109.67 125.06,104.83 125.06,104.1 ; C7015.2 125.89,102.98 125.8,102.89 125.8,102.75 125.91,102.65 125.91,102.38 125.85,102.32 125.63,102.32 125.06,102.89 125.06,104.1 ; 125.06,104.1 v1(125.28,104.1)
EXP_TXP1_C: length 21.7
  BOTTOM w0.076: 143.36,95.37 143.39,95.33 143.86,95.33 144.12,95.59 144.12,95.84 144.2,95.93 144.65,95.93 144.93,95.65 U7000.BK29
  BOTTOM w0.121: C7015.1 128.78,102.98 129.04,102.72 129.04,102.54 136.13,95.46 143.06,95.46 143.15,95.37 143.36,95.37
EXP_TXP2: length 17.8
  BOTTOM w0.076: U0300.C12 113.83,110.73 113.83,110.52 113.98,110.37 115.29,110.37 115.36,110.3 116.44,110.3 116.53,110.21 116.99,110.21
  BOTTOM w0.121: 116.99,110.21 120.29,110.21 124.29,106.2 125.3,106.2 ; 125.3,106.2 126.04,106.2 126.16,106.08 126.16,105.74 125.48,105.06 125.48,104.55 125.82,104.22 126,104.22 C7009.2 ; 125.3,106.2 v1(125.3,105.93)
EXP_TXP2_C: length 20.7
  BOTTOM w0.121: U7000.BM29 143.51,95.89 136.3,95.89 129.49,102.7 129.49,103.54 128.84,104.19 127.54,104.19 C7009.1
EXP_TXP3: length 12.8
  BOTTOM w0.076: 117.13,111.09 117.11,111.07 116.88,111.07 116.54,111.41 115.14,111.41 115.01,111.54 U0300.A13
  BOTTOM w0.121: C7020.2 124.96,107.8 124.9,107.74 124.9,107.2 124.84,107.15 124.64,107.15 120.68,111.11 117.15,111.11 117.13,111.09
EXP_TXP3_C: length 25.4
  BOTTOM w0.076: U7000.BL30 144.52,96.28 144.81,96.28 144.86,96.33 144.86,96.45 144.64,96.67 144.28,96.67
  BOTTOM w0.121: C7020.1 126.47,107.48 126.93,107.48 127.13,107.28 127.42,107.28 127.62,107.48 128.04,107.48 128.41,107.11 128.41,105.99 130.38,104.01 130.38,103.11 136.56,96.93 144.01,96.93 144.28,96.67
EXP_TXP4: length 15.5
  BOTTOM w0.076: U0300.C14 113.85,112.29 113.85,112.16 114.06,111.95 115.31,111.95 115.43,111.82 116.79,111.82 116.82,111.8
  BOTTOM w0.121: 116.82,111.8 117.32,111.8 117.51,111.61 120.84,111.61 124.19,108.26 126.99,108.26 C7022.2
EXP_TXP4_C: length 23
  BOTTOM w0.102: 142.7,97.36 143.21,97.36 143.39,97.18 143.92,97.18 144.11,97.36 144.55,97.36 144.94,97.75 U7000.BK32
  BOTTOM w0.121: C7022.1 128.53,107.93 128.85,107.61 128.85,106.15 130.87,104.13 130.87,103.28 136.79,97.36 142.7,97.36
EXP_TXP5: length 12.5
  BOTTOM w0.076: U0300.A15 115.01,113.08 115.09,113 115.96,113 116.23,112.73 116.47,112.73 116.5,112.76 116.5,112.78
  BOTTOM w0.121: 116.5,112.78 118.43,112.78 118.63,112.58 121.14,112.58 124.16,109.56 124.64,109.56 124.7,109.62 124.7,109.86 124.62,109.95 124.62,110.11 124.73,110.22 C7024.2
EXP_TXP5_C: length 26.3
  BOTTOM w0.089: U7000.BM32 143.75,97.86 144.07,98.18 144.07,98.56 143.87,98.77 143.23,98.77 142.75,98.28 142.55,98.28 142.52,98.31
  BOTTOM w0.121: C7024.1 126.86,110.22 127.05,110.03 128.87,110.03 129.75,109.15 129.75,106.52 131.76,104.5 131.76,103.65 137.1,98.31 142.52,98.31
EXP_TXP6: length 15.2
  BOTTOM w0.076: U0300.C16 113.86,113.85 113.86,113.67 114.02,113.52 115.34,113.52 115.58,113.28 115.89,113.28 115.91,113.26 115.92,113.26
  BOTTOM w0.121: 115.92,113.26 121.07,113.26 123.56,110.77 127.01,110.77 C7029.2
EXP_TXP6_C: length 25
  BOTTOM w0.089: U7000.BL33 144.33,98.57 144.33,98.59 143.94,98.97 142.96,98.97 142.78,98.79 142.45,98.79 142.42,98.76 142.4,98.76
  BOTTOM w0.121: 142.4,98.76 137.25,98.76 132.19,103.83 132.19,104.74 130.33,106.6 130.33,109.84 129.04,111.13 128.75,111.13 128.63,111.01 128.63,110.92 128.84,110.71 128.84,110.56 128.75,110.47 C7029.1
EXP_TXP7: length 11.3
  BOTTOM w0.076: U0300.A17 115.22,114.59 115.83,114.59 116.24,114.18 116.54,114.18 116.57,114.21
  BOTTOM w0.121: C7031.2 123.97,112.63 123.85,112.52 123.85,112.33 124.01,112.17 124.01,112.06 123.92,111.98 123.69,111.98 121.46,114.21 116.57,114.21
EXP_TXP7_C: length 28.5
  BOTTOM w0.089: 143.08,99.66 143.09,99.66 143.12,99.63 143.38,99.63 143.48,99.53 143.95,99.53 144.11,99.69 144.11,99.94 144.33,100.15 144.85,100.15 U7000.BK35
  BOTTOM w0.121: 143.08,99.66 137.62,99.66 133.08,104.2 133.08,105.11 131.25,106.95 131.25,110.5 129.19,112.55 126.48,112.55 126.4,112.63 C7031.1
EXP_TXP8: length 15
  BOTTOM w0.076: U0300.B18 114.06,115.58 114.01,115.53 114.01,115.25 114.18,115.09 114.3,115.09 114.48,115.27 114.64,115.27 114.82,115.1 115.28,115.1 115.48,114.9 116.15,114.9 116.16,114.89
  BOTTOM w0.121: 116.16,114.89 121.49,114.89 123.04,113.34 126.99,113.34 C7033.2
EXP_TXP8_C: length 24.1
  BOTTOM w0.121: C7033.1 128.46,113.29 129.52,113.29 131.67,111.14 131.67,107.13 133.51,105.29 133.51,104.37 137.78,100.1 143.5,100.1 U7000.BM35
EXP_TXP9: length 11.1
  BOTTOM w0.121: C7035.2 123.8,114.28 122.3,115.78 116.49,115.78 116.26,116.01 114.85,116.01 114.49,116.37 U0300.B19
EXP_TXP9_C: length 28.6
  BOTTOM w0.102: 141.84,100.85 141.87,100.85 141.88,100.87 143.95,100.87 144.27,100.55 U7000.BL36
  BOTTOM w0.121: C7035.1 125.73,114.06 125.97,114.06 126.07,114.16 126.07,114.75 126.25,114.94 126.58,114.94 126.68,114.84 126.95,114.57 129.21,114.57 132.38,111.39 132.38,107.35 134.17,105.57 134.17,104.65 137.96,100.85 141.84,100.85
EXP_TXP10: length 14.3
  BOTTOM w0.076: U0300.B20 114.15,117.15 114.04,117.04 114.04,116.9 114.11,116.83 116.51,116.83 116.54,116.86
  BOTTOM w0.121: 116.54,116.86 119.29,116.86 119.46,116.7 122.84,116.7 123.5,116.04 126.91,116.04 C7037.2
EXP_TXP10_C: length 27.1
  BOTTOM w0.102: 141.66,101.75 141.69,101.75 141.7,101.73 143.31,101.73 143.44,101.61 143.98,101.61 144.13,101.76 144.13,102.06 144.35,102.29 144.81,102.29 U7000.BK38
  BOTTOM w0.121: C7037.1 129.46,116.44 131.02,114.88 131.02,114.08 133.36,111.74 133.36,107.65 135.06,105.95 135.06,105.02 138.33,101.75 141.66,101.75
EXP_TXP11: length 10.7
  BOTTOM w0.076: 116.35,117.53 116.34,117.52 116.26,117.52 116.16,117.61 115.49,117.61 115.34,117.46 114.71,117.46 114.52,117.64 114.52,117.78 U0300.B21
  BOTTOM w0.121: 116.35,117.53 119.24,117.53 119.62,117.15 124.03,117.15 124.04,117.15 124.19,117.15 C7039.2
EXP_TXP11_C: length 28.8
  BOTTOM w0.121: C7039.1 125.58,117.27 126.32,117.27 ; 126.32,117.27 129.5,117.27 131.49,115.29 131.49,114.24 133.79,111.94 133.79,107.83 135.49,106.13 135.49,105.2 138.5,102.18 143.51,102.18 U7000.BM38 ; 126.32,117.27 v1(126.32,117.05)
EXP_TXP12: length 14.9
  BOTTOM w0.076: U0300.B22 114.14,118.73 113.99,118.58 113.99,118.36 114.1,118.24 114.32,118.24 114.5,118.42 114.64,118.42 114.82,118.25 115.64,118.25 115.68,118.22 115.7,118.22
  BOTTOM w0.121: C7041.2 127.08,118.45 123.98,118.45 123.35,117.81 119.99,117.81 119.31,118.5 117.02,118.5 116.74,118.22 115.7,118.22
EXP_TXP12_C: length 27.6
  BOTTOM w0.102: 142.65,102.91 142.68,102.91 142.69,102.93 143.42,102.93 143.5,103 143.95,103 144.18,102.78 144.18,102.77 144.3,102.65 U7000.BL39
  BOTTOM w0.121: 142.65,102.91 138.71,102.91 136.15,105.47 136.15,106.46 134.47,108.14 134.47,112.21 132.24,114.43 132.24,115.7 129.07,118.87 128.84,118.87 128.73,118.76 128.73,118.1 128.62,117.98 128.41,117.98 C7041.1
EXP_TXP13: length 11.7
  BOTTOM w0.076: U0300.B23 114.56,119.32 114.56,119.24 114.77,119.03 115.32,119.03 115.58,119.29 116.2,119.29 116.25,119.35 116.52,119.35
  BOTTOM w0.121: 117.33,119.69 117.1,119.69 116.76,119.35 116.52,119.35 ; 117.33,119.69 118.15,119.69 118.37,119.46 119.51,119.46 120.6,120.55 122.28,120.55 123.09,119.74 124.14,119.74 C7043.2 ; 117.33,119.69 v1(117.33,119.47)
EXP_TXP13_C: length 31
  BOTTOM w0.102: U7000.BK41 144.82,103.72 144.24,103.72 144.06,103.54 143.36,103.54 143.25,103.64 142.71,103.64 142.69,103.62 142.67,103.62
  BOTTOM w0.121: C7043.1 125.58,119.81 129.5,119.81 133.05,116.27 133.05,114.57 135.23,112.38 135.23,108.32 136.81,106.74 136.81,105.74 138.93,103.62 142.67,103.62
EXP_TXP14: length 15.4
  BOTTOM w0.076: 116.25,120.02 116.23,120.04 116.16,120.04 115.8,119.69 115.46,119.69 115.33,119.82 114.83,119.82 114.63,120.02 114.55,120.02 114.42,119.9 114.09,119.9 114.01,119.97 114.01,120.23 114.09,120.3 U0300.B24
  BOTTOM w0.121: C7049.2 126.99,121.21 124.21,121.21 123.98,120.98 122.78,120.98 122.55,121.21 120,121.21 119.16,120.37 118.95,120.37 ; 118.95,120.37 v1(118.95,120.15) ; 118.95,120.37 116.84,120.37 116.48,120.02 116.25,120.02
EXP_TXP14_C: length 27.1
  BOTTOM w0.121: C7049.1 128.52,121.23 129.48,121.23 134.02,116.69 134.02,114.56 135.89,112.69 135.89,108.6 137.47,107.02 137.47,106.02 139.16,104.32 143.47,104.32 U7000.BM41
EXP_TXP15: length 12.7
  BOTTOM w0.076: U0300.B25 114.5,120.95 114.5,120.91 114.81,120.61 115.39,120.61 115.46,120.68 115.78,120.68 116.16,121.06 116.21,121.06 116.23,121.07
  BOTTOM w0.121: 117,121.57 116.72,121.57 116.23,121.07 ; 117,121.57 117.46,121.57 117.97,121.06 118.72,121.06 119.08,121.42 119.08,121.8 119.16,121.88 123.66,121.88 124.29,122.5 124.68,122.5 C7051.2 ; 117,121.57 v1(117,121.35)
EXP_TXP15_C: length 31.1
  BOTTOM w0.121: C7051.1 126.16,121.88 126.39,121.88 126.51,122 126.51,122.5 126.59,122.58 129.35,122.58 134.72,117.21 134.72,114.82 136.55,112.99 136.55,108.88 138.13,107.3 138.13,106.29 139.34,105.09 143.97,105.09 144.09,104.98 144.09,104.81 144.15,104.75 U7000.BL42
EXT_SCI#: length 118.4
  TOP w0.102: v2(190.3,20.5) 190.3,21.11 189.3,22.12 v2(189.3,24.33) ; SR3017.1 150.76,38.83 150.88,38.71 150.88,37.94 151.79,37.03 v2(152.11,37.03)
  IN1 w0.102: v2(190.3,20.5) 190.3,19.78 189.52,18.99 167.1,18.99 165.87,20.23 152.83,20.23 v2(152.18,20.87) ; v2(189.3,24.33) 189.3,24.15 189.5,23.95 194.21,23.95 195.26,24.99 202.27,24.99 205.42,28.13 205.42,31.98 207.02,33.59 209.65,33.59 214.15,38.09 214.15,39.39 212.45,41.09 212.45,41.61 v2(212.45,41.61)
  BOTTOM w0.089: 222.33,48.11 222.33,48.25 222.61,48.53 U2000.M44
  BOTTOM w0.102: v2(152.18,20.87) 151.26,21.79 151.26,30.03 151.75,30.51 151.75,34.47 v1(151.49,34.73) 151.49,36.41 v2(152.11,37.03) ; R2210.2 212.45,41.22 212.45,41.61 v2(212.45,41.61) 211.94,41.61 211.54,42.02 211.54,43.19 211.72,43.36 212.22,43.36 212.4,43.54 212.4,44.05 214.74,46.38 219.54,46.38 220.3,47.15 221.37,47.15 222.33,48.11
EXT_SCI#_D: length 5.9
  TOP w0.102: v1(150.37,39.73) 150.05,39.41 150.05,38.1 150.15,37.99 SR3017.2 150.46,37.52 151.38,36.6 151.77,36.6 152.06,36.31 U3002.23
EXT_SMI#: length 132.4
  TOP w0.102: v2(189.49,20.5) 189.49,21.27 188.69,22.07 v2(188.69,24.33) ; v2(154.91,39.45) 154.83,39.38 SR3015.1 ; R2365.2 224.42,41.53 v2(224.26,41.69)
  IN1 w0.102: v2(188.69,24.33) 188.69,24.02 188.97,23.74 194.3,23.74 195.34,24.79 202.36,24.79 205.62,28.05 205.62,31.9 207.11,33.38 209.74,33.38 217.63,41.28 223.86,41.28 v2(224.26,41.69) 224.67,41.28 225.4,41.28 233.43,41.28 234.47,42.32 v2(234.58,42.32) ; v2(189.49,20.5) 189.49,20.15 188.74,19.4 175.94,19.4 175.32,20.02 172.94,20.02 172.32,19.4 167.27,19.4 165.38,21.29 162.88,21.29 162.65,21.52 154.11,21.52 v2(153.45,20.86)
  BOTTOM w0.102: v2(154.91,39.45) 157.24,37.12 157.24,30.16 156.29,29.22 153.37,29.22 152.52,28.37 v1(152.52,26.69) 152.52,25.85 154.01,24.37 154.01,22.01 153.45,21.45 v2(153.45,20.86) ; v2(234.58,42.32) 235.13,42.88 235.13,44.77 234.68,45.23 234.68,45.49 233.19,46.98 233.19,47.57 233.2,47.57 233.2,48.28 233.1,48.47 233.1,48.82 U2000.AN43
EXT_SMI#_EC: length 6
  TOP w0.102: v1(153.8,40.32) 154.41,39.71 154.41,38.11 154.49,38.03 SR3015.2 154.83,37.57 155.26,37.14 U3002.15
F_CS#_EC: length 5.9
  TOP w0.121: v1(167.27,20.1) 167.01,20.35 165.72,20.35 165.49,20.58 R3041.2 164.9,21.35 164.57,21.35 163.21,22.71 U3002.101
F_SCK_EC: length 3.8
  TOP w0.121: R3043.2 164.81,23.31 164.47,23.65 164.47,24.19 v1(164.19,24.47) 164.03,24.31 U3002.105
F_SDI_EC: length 6.7
  TOP w0.121: v1(168.18,21.7) 167.67,21.7 167.37,21.4 166.8,21.4 166.63,21.23 165.9,21.23 R3044.2 164.62,21.65 163.68,22.59 163.68,22.66 163.24,23.11 U3002.102
FAN0_PWM: length 223.2
  TOP w0.102: U3002.30 149.26,36.12 149.16,36.23 144.89,36.23 v1(143.9,35.24) 141.2,32.54 139.17,32.54 137.47,30.84 136.83,30.84 v2(135.21,32.46)
  IN1 w0.102: v2(62.84,112.19) 61.63,110.98 57.64,110.98 47.35,100.69 47.35,94.88 46.41,93.94 41.98,93.94 35.39,87.35 35.39,59.32 34.29,58.21 34.29,48.36 31.76,45.83 31.76,38.32 32.02,38.06 32.32,38.06 33.89,36.48 34.07,36.48 34.49,36.06 34.49,35.02 39.27,30.23 39.27,29.51 39.82,28.96 43.87,28.96 45.79,27.05 107.98,27.05 113.48,32.54 123.78,32.54 124.49,33.26 134.42,33.26 v2(135.21,32.46)
  BOTTOM w0.102: R5006.1 R5000.2 62.75,112.28 v2(62.84,112.19)
FAN0_TACH: length 268.9
  TOP w0.102: U3002.47 147.82,27.91 147.99,27.74 147.99,24.31 v2(148.24,24.06)
  IN3 w0.102: v2(39.96,106.99) 41.19,105.76 41.19,84.77 36.18,79.75 36.18,78.32 30.35,72.5 20.92,72.5 17.49,69.07 17.49,62.2 15.83,60.54 15.83,54.16 21.98,48.01 21.98,43.83 22.29,43.52 24.08,43.52 25.85,41.74 25.85,37.01 25.33,36.49 25.33,31.18 24.85,30.7 24.85,30.07 25.33,29.59 25.33,24.4 26.78,22.95 26.78,20.52 28.61,18.69 31.11,18.69 33.83,15.97 40.2,15.97 41.07,15.09 47.12,15.09 48.54,16.52 59.14,16.52 59.44,16.21 60.54,16.21 62.62,18.3 80.69,18.3 80.85,18.14 109.14,18.14 112.27,21.28 115.98,21.28 116.25,21.28 116.32,21.35 116.32,21.45 116.35,21.47 116.35,21.61 116.61,21.87 116.96,21.87 120.38,25.3 134.14,25.3 134.89,24.54 145.5,24.54 145.98,24.06 v2(148.24,24.06)
  BOTTOM w0.102: v2(39.96,106.99) 42.6,109.63 56.45,109.63 57.65,108.43 59.66,108.43 60.13,108.89 D5001.3 60.13,110.9 R5003.2 R5005.1
FAN1_PWM: length 203.5
  TOP w0.102: R5007.2 R5010.1 267.52,84.87 269.01,84.87 v1(270.39,86.25) 271.03,86.89 274.44,86.89 v2(275.16,87.61) ; v2(150.58,27.5) 150.6,27.52 150.6,28.12 148.71,30.01 148.3,30.01 148.07,30.25 148.07,30.66 148.06,30.66 148.06,31.68 148.86,32.48 U3002.31
  IN3 w0.102: v2(282.12,87.31) 282.3,87.13 282.3,86.49 281.8,86 281.8,81.85 282.73,80.92 282.73,76.59 280.49,74.34 280.49,70.78 279.34,69.63 279.34,68.13 277.79,66.58 275.99,66.58 274.51,65.1 274.51,63.54 270.96,59.99 270.96,59.25 266.19,54.47 262.12,54.47 261.67,54.92 255.81,54.92 254.47,53.59 254.47,46.89 255.15,46.21 255.15,43.7 253.77,42.31 251.69,42.31 249.94,40.57 241.59,40.57 240.89,39.87 239.24,39.87 238.39,39.02 235.43,39.02 233.52,37.11 216.54,37.11 213.03,33.6 206.03,33.6 203.96,31.53 199.5,31.53 196.15,28.19 187.15,28.19 186.61,28.73 185.54,28.73 185.53,28.75 168.39,28.75 167.67,28.04 158.9,28.04 158.35,28.58 151.66,28.58 v2(150.58,27.5)
  BOTTOM w0.102: v2(282.12,87.31) 281.74,87.31 280.9,86.47 279.51,86.47 278.36,87.61 v2(275.16,87.61)
FAN1_TACH: length 182.1
  TOP w0.102: R5009.1 R5008.2 263.22,85.83 262.69,85.31 D5003.3 261.36,85.31 260.79,85.88 259.87,85.88 259.54,86.21 257.38,86.21 256.3,85.14 256.3,84.08 256.23,84.01 v2(255.65,84.01) ; v2(148.57,20.96) 147.77,21.77 147.77,27.46 147.71,27.51 U3002.48
  IN2 w0.102: v2(148.57,20.96) 149.13,21.52 157.76,21.52 158.88,22.64 161.34,22.64 163.39,24.69 166.46,24.69 166.6,24.84 177,24.84 177.13,24.96 184.35,24.96 184.59,25.2 191.55,25.2 191.87,24.89 202.56,24.89 204.5,26.83 219.39,26.83 219.87,26.35 226.46,26.35 227.25,27.13 228.96,27.13 230.23,25.86 235.13,25.86 235.54,26.27 239.95,26.27 247.09,33.41 249.03,33.41 v2(249.59,33.97)
  BOTTOM w0.102: v2(255.65,84.01) 255.58,84.01 255.4,83.83 255.4,82.57 256.17,81.8 256.61,81.8 256.92,81.49 256.92,75.25 257.59,74.58 257.59,71.59 256.39,70.39 256.39,66.79 253.96,64.35 253.96,54.41 254.3,54.06 254.3,48.64 251.06,45.4 251.06,37.72 249.95,36.61 249.95,34.33 v2(249.59,33.97)
FAN2_PWM: length 6.3
  TOP w0.102: R5020.1 144.81,33.99 v1(145.17,33.99) 148.29,33.99 148.47,34.17 U3002.32
FAN2_TACH: length 97.8
  TOP w0.102: R5021.2 79.1,7.02 v2(79.1,6.71) 80.37,6.71 80.88,7.22 80.88,9.86 v1(80.7,10.04) 80.7,10.34 86.09,15.73 86.09,20.81 v2(85.83,21.06) ; v2(151.49,20.87) 152.01,20.35 153.83,20.35 154.06,20.12 U3002.79
  IN1 w0.102: v2(151.49,20.87) 150.84,20.23 147.75,20.23 146.61,19.08 143.84,19.08 143.1,18.34 134.31,18.34 134.07,18.58 134.07,22.15 130.99,25.22 118.19,25.22 113.57,20.61 86.29,20.61 v2(85.83,21.06)
  BOTTOM w0.102: v2(79.1,6.71) 78.84,6.45 CON5002.2
FAN_REVERSE: length 421.5
  TOP w0.102: v2(148.47,30.42) 148.47,30.42 148.47,31.66 149.66,32.85 U3002.29 ; R5016.1 258.64,92.75 v2(258.64,92.75)
  IN2 w0.102: v2(232.59,78.09) 233.11,78.6 238.55,78.6 241.61,81.67 241.61,82.47 242.99,83.85 243.73,83.85 246.55,86.67 251.03,86.67 253.33,88.97 253.62,88.97 254.07,89.42 256.33,89.42 258.64,91.72 v2(258.64,92.75)
  IN3 w0.102: v2(232.59,78.09) 232.34,78.34 217.26,78.34 215.25,76.33 215.25,73.79 213.27,71.81 205.66,71.81 200.95,67.09 200.95,65.97 202.02,64.9 202.02,64.16 198.13,60.27 198.13,48.45 194.35,44.68 190.79,44.68 187.78,41.67 170.09,41.67 169.56,41.14 154.52,41.14 148.44,47.21 142.55,47.21 142.03,46.69 135.03,46.69 v2(134.83,46.49) ; v2(148.47,30.42) 147.27,30.42 143.95,33.74 134.14,33.74 131.86,31.45 126.56,31.45 125.64,32.38 v2(125.51,32.38) 124.69,31.55 121.09,31.55 115.78,26.25 107.98,26.25 104.73,22.99 98.46,22.99 97.14,24.31 63,24.31 60.43,21.75 40.78,21.75 39.18,23.35 33.04,23.35 31.88,24.5 31.88,26.88 31.02,27.74 31.02,47.17 28.67,49.52 28.67,50.2 27.72,51.16 27.72,57.96 30.49,60.73 30.49,68.65 48.22,86.38 48.22,92.15 46.64,93.73 45.95,93.73 45.37,94.32 45.37,113.27 46.54,114.43 46.54,118.88 v2(45.83,119.59)
  BOTTOM w0.102: v2(134.83,46.49) 134.83,46.46 v1(133.84,45.47) 133.1,44.74 133.1,44.25 131.22,42.37 131.22,40.43 125.71,34.92 125.71,33.14 125.51,32.94 v2(125.51,32.38) ; R5015.1 43.72,119.82 44.33,119.21 45.45,119.21 v2(45.83,119.59)
FB_A: length 6.5
  TOP w0.254: R8080.2 R8049.2 ; R8049.2 58.25,182.53 58.28,182.56 v1(58.73,182.56) ; R8049.2 R80100.2 57.77,180.1 v2(57.18,179.51)
  BOTTOM w0.152: v2(57.18,179.51) 56.97,179.72 U8000.17
FB_B: length 8.3
  BOTTOM w0.102: R8037.2 62.26,185.64 62.63,186.01 63.89,186.01 64.67,186.8 v1(64.67,187.48)
  BOTTOM w0.203: R8015.2 62.05,185.04 62.26,185.24 R8037.2 R8023.2 61.49,185.44 60.75,184.7 60.55,184.7 59.99,184.14 U8000.5
FB_C: length 8
  TOP w0.254: R8099.1 R8079.1 R8047.1 v2(50.65,183.62)
  BOTTOM w0.152: U8000.30 53.04,183.34 52.73,183.66 52.12,183.66 51.43,182.96 50.95,182.96 50.65,183.25 v2(50.65,183.62)
  BOTTOM w0.254: v2(50.65,183.62) 50.65,183.67 50.22,184.11 49.49,184.11 v1(49.36,183.98)
FB_PLL_AVDD: length 51.7
  TOP w0.457: v5(156.79,104.36) 156.79,104.34 156.78,104.34 C7107.1
  TOP w0.508: v5(167.3,83.45) 167.65,83.8 167.7,83.8 167.75,83.85 C7106.1
  IN1 w0.35: v5(167.3,83.45) 167.34,83.45 167.91,84.02 170.43,84.02 171.56,85.15 171.56,86.47 172.01,86.92 v5(172.13,86.92) 171.48,87.57 171.48,101.08 172.04,101.64 v5(172.04,101.7) 172.1,101.76 172.1,101.87 170.15,103.82 157.38,103.82 156.84,104.36 v5(156.79,104.36)
  IN3 w0.4: v5(167.3,83.45) 166.79,83.96 158.1,83.96
  BOTTOM w0.25: U7000.L17 172.13,86.93 v5(172.13,86.92)
  BOTTOM w0.254: v5(167.3,83.45) 167.3,83.3 U7000.V11
  BOTTOM w0.3: U7000.L38 172.2,101.7 v5(172.04,101.7)
  BOTTOM w0.305: U7000.AN42 157.05,104.62 v5(156.79,104.36)
  vias: v1(152.61,57.39) v2(153.19,58.86) v2(153.19,58.25) v2(153.19,57.64)
FB_PLL_VDD:
  vias: v1(150.6,57.39)
FB_REFPLL_AVDD_GPU: length 73.3
  IN3 w0.35: v5(162.2,104.35) 162.25,104.35 162.77,103.82 170.94,103.82 171.54,103.23 171.54,95.96 172.06,95.44 172.06,95.41 v5(172.05,95.4)
  IN3 w0.4: v5(172.05,95.4) 171.46,94.81 171.46,85.38 170.54,84.46 152.53,84.46 151.77,83.7 151.77,83.24 151.26,82.73 151.26,75.11 152.1,74.28 152.1,61.05 v2(152.53,60.61)
  BOTTOM w0.3: v5(172.05,95.4) 172.2,95.4 U7000.L29 ; v5(162.2,104.35) 162.2,104.5 162.11,104.58 162.11,104.59 U7000.AF42
  vias: v1(153.52,59.85)
FBA_CLK0: length 34
  IN1 w0.114: v5(160.94,106.5) 161.22,106.78 161.43,106.78 161.66,107.01 161.66,108.8 161.51,108.94 161.51,110.5 160.8,111.21 160.8,116.35 159.39,117.76 159.39,131.59 159.67,131.87 160.12,131.87 v5(160.33,131.65)
  IN4 w0.114: v5(164.27,133.73) 161.56,133.73 161.25,133.41 161.25,132.34 160.82,131.91 160.59,131.91 v5(160.33,131.65)
  BOTTOM w0.122: v5(164.27,133.73) 164.11,133.89 163.95,134.05 U7600.K11
  BOTTOM w0.14: v5(160.94,106.5) 160.94,106.54 U7000.AG45
FBA_CLK0*: length 34.1
  IN1 w0.114: v5(160.95,107.2) 161.15,107 161.34,107 161.44,107.1 161.44,108.71 161.3,108.85 161.3,110.41 160.59,111.12 160.59,116.26 159.8,117.05 159.17,117.67 159.17,131.68 159.58,132.09 160.06,132.09 v5(160.33,132.35)
  IN4 w0.114: v5(164.27,134.38) 163.84,133.94 161.47,133.94 161.03,133.5 161.03,132.43 160.73,132.13 160.56,132.13 v5(160.33,132.35)
  BOTTOM w0.122: v5(164.27,134.38) U7600.K10
  BOTTOM w0.14: v5(160.95,107.2) 160.95,107.25 U7000.AG46
FBA_CLK1: length 35.4
  IN1 w0.114: v5(148.87,133.73) 148.58,133.73 148.48,133.63 148.48,133.48 148.63,133.33 149.03,133.33 149.23,133.13 151.68,133.13 151.85,132.96 152.03,132.78 152.03,132.44 152.18,132.29 152.61,132.29 152.81,132.09 v5(152.81,131.96)
  IN4 w0.114: v5(152.81,131.96) 152.81,132.09 152.92,132.19 153.21,132.19 153.41,131.99 153.41,120.56 158.52,115.46 158.52,112 159.24,111.27 159.24,107.16 159.13,107.06 158.99,107.06 v5(158.85,107.2)
  BOTTOM w0.122: U7601.K11 149.2,133.9 149.03,133.73 v5(148.87,133.73)
  BOTTOM w0.14: U7000.AK46 158.85,107.25 v5(158.85,107.2)
FBA_CLK1*: length 35.6
  IN1 w0.075: 149.21,133.46 149.2,133.47 149.2,134.06
  IN1 w0.114: v5(152.81,132.62) 152.7,132.51 152.27,132.51 152.24,132.53 152.24,132.87 151.77,133.35 149.32,133.35 149.21,133.46 ; 149.2,134.06 v5(148.87,134.38)
  IN4 w0.114: v5(158.84,106.51) 158.86,106.54 158.86,106.56 159.14,106.84 159.22,106.84 159.39,107.01 159.46,107.07 159.46,111.36 158.73,112.09 158.73,115.55 153.63,120.65 153.63,132.08 153.3,132.41 153.03,132.41 v5(152.81,132.62)
  BOTTOM w0.122: v5(148.87,134.38) 148.87,134.38 U7601.K10
  BOTTOM w0.14: v5(158.84,106.51) 158.84,106.54 U7000.AK45
FBA_CMD<0>: length 32.1
  BOTTOM w0.1: 171.75,134.49 171.26,134.98 170.62,134.98 170.57,135.03 168.82,135.03 U7600.H4
  BOTTOM w0.102: U7000.Y51 166.15,111.2 166.48,111.53 166.48,111.95 166.32,112.11 166.32,115.35 166.24,115.42
  BOTTOM w0.14: 166.24,115.42 166.2,115.47 166.2,116.52 167.22,117.54 167.72,117.54 167.92,117.34 168.52,117.34 173.49,122.31 173.49,132.75 171.75,134.49
FBA_CMD<1>: length 29
  TOP w0.14: R7113.1 171.8,133.66 v5(171.68,133.54)
  BOTTOM w0.1: U7600.K2 170.11,133.74 170.68,133.74 170.74,133.8 171.26,133.8 171.52,133.54 v5(171.68,133.54)
  BOTTOM w0.102: U7000.Y52 166.07,111.83 166.07,115.02 165.84,115.25 165.84,115.42
  BOTTOM w0.14: 165.84,115.42 165.84,116.59 167.06,117.81 168.25,117.81 172.78,122.34 172.78,132.72 171.96,133.54 v5(171.68,133.54)
FBA_CMD<2>: length 29.5
  BOTTOM w0.1: 171.34,132.86 171.11,133.09 168.84,133.09 U7600.M4
  BOTTOM w0.102: 165.55,115.42 165.55,115.01 165.8,114.76 165.8,110 U7000.Y49
  BOTTOM w0.14: 165.55,115.42 165.55,116.7 167.01,118.16 167.87,118.16 171.41,121.71 171.41,132.79
  BOTTOM w0.184: 171.41,132.79 171.34,132.86
FBA_CMD<3>: length 26.3
  BOTTOM w0.1: U7600.L5 167.67,133.4 167.54,133.27 167.54,131.73 167.15,131.34 167.15,127.69 167.41,127.43
  BOTTOM w0.102: 165.23,115.42 165.23,114.79 165.45,114.57 U7000.AA52
  BOTTOM w0.14: 165.23,115.42 165.23,116.78 166.88,118.42 167.39,118.42 170.15,121.18 170.15,125.72 168.44,127.43 167.41,127.43
FBA_CMD<4>: length 27.8
  BOTTOM w0.1: 168.07,127.01 167.49,127.01 166.95,127.56 166.95,131.47 167.32,131.83 167.32,133.59 167.46,133.73 168.17,133.73 U7600.L4
  BOTTOM w0.102: 168.59,126.5 168.07,127.01 ; 164.84,115.42 164.84,114.66 165.18,114.32 165.18,111.99 165.12,111.93 165.12,111.58 165.45,111.25 U7000.AA51
  BOTTOM w0.14: 164.84,115.42 164.84,116.72 167.05,118.93 167.05,119.27 169.6,121.83 169.6,125.48 168.59,126.5
FBA_CMD<5>: length 27.7
  BOTTOM w0.1: 167.62,126.5 166.75,127.37 166.75,131.57 167.11,131.94 167.11,133.74 167.42,134.05 167.85,134.05 U7600.K5
  BOTTOM w0.102: 164.52,115.42 164.52,114.44 164.9,114.06 164.9,111.45 165.1,111.25 165.1,110.85 165.45,110.5 U7000.AA50
  BOTTOM w0.14: 164.52,115.42 164.52,116.81 166.53,118.82 166.53,120.5 169.02,122.99 169.02,125.33 168.23,126.12 168,126.12 167.62,126.5
FBA_CMD<6>: length 28.4
  BOTTOM w0.1: 167.13,126.5 166.55,127.08 166.55,131.7 166.91,132.07 166.91,134.05 167.24,134.38 168.17,134.38 U7600.K4
  BOTTOM w0.102: U7000.AC50 164.4,110.7 164.4,111.2 164.65,111.45 164.65,113.81 164.16,114.3 164.16,115.42
  BOTTOM w0.14: 167.13,126.5 168.07,125.55 168.07,122.79 166.01,120.72 166.01,118.7 164.16,116.85 164.16,115.42
FBA_CMD<7>: length 27
  BOTTOM w0.1: U7600.J5 167.28,134.7 166.71,134.14 166.71,132.19 166.35,131.83 166.35,126.87 166.72,126.5
  BOTTOM w0.102: U7000.AC51 164.05,111.2 164.41,111.56 164.41,113.51 163.86,114.06 163.86,115.42
  BOTTOM w0.14: 163.86,115.42 163.86,116.92 165.49,118.55 165.49,121 167.51,123.02 167.51,125.71 166.72,126.5
FBA_CMD<8>: length 27.1
  BOTTOM w0.1: U7600.J4 168.19,135.01 167.07,135.01 166.51,134.44 166.51,132.3 166.15,131.93 166.15,126.68 166.22,126.61
  BOTTOM w0.102: U7000.AC52 164.05,113.37 163.55,113.87 163.55,115.42
  BOTTOM w0.14: 166.22,126.61 166.88,125.94 166.88,123.2 164.96,121.28 164.96,118.44 163.55,117.02 163.55,115.42
FBA_CMD<9>: length 28.9
  BOTTOM w0.1: 165.94,126.5 165.94,132.04 166.06,132.16 166.06,134.35 165.41,135.01 164.25,135.01 U7600.J11
  BOTTOM w0.102: 163.24,115.42 163.24,113.71 163.7,113.25 163.7,110 U7000.AC49
  BOTTOM w0.14: 163.24,115.42 163.24,117.13 164.44,118.34 164.44,121.56 166.16,123.28 166.16,126.05 165.94,126.27 165.94,126.5
FBA_CMD<10>: length 25.3
  BOTTOM w0.1: U7600.J10 164.65,134.75 165.26,134.75 165.86,134.15 165.86,132.28 165.74,132.16 165.74,126.6 165.64,126.5
  BOTTOM w0.102: U7000.AD52 163.35,113.15 162.96,113.54 162.96,115.42
  BOTTOM w0.14: 162.96,115.42 162.96,117.32 163.92,118.28 163.92,121.83 165.39,123.3 165.39,125.33 165.59,125.53 165.59,126.45 165.64,126.5
FBA_CMD<11>: length 24.5
  BOTTOM w0.1: U7600.L10 164.64,133.36 165.09,133.36 165.59,132.87 165.59,132.29 165.54,132.25 165.54,126.77 165.37,126.6
  BOTTOM w0.102: U7000.AD51 163.35,111.25 163.02,111.58 163.02,111.94 163.06,111.98 163.06,113.03 162.72,113.37 162.72,115.42
  BOTTOM w0.14: 165.37,126.6 165.23,126.47 165.23,125.89 164.83,125.49 164.83,123.54 163.4,122.11 163.4,118.25 162.72,117.57 162.72,115.42
FBA_CMD<12>: length 25.7
  BOTTOM w0.1: 165.28,126.88 165.28,132.28 165.38,132.38 165.38,132.78 165.09,133.08 164.27,133.08 U7600.L11
  BOTTOM w0.102: U7000.AD50 163.35,110.5 163,110.85 163,111.25 162.8,111.45 162.8,112.83 162.41,113.22 162.41,115.42
  BOTTOM w0.14: 165.28,126.88 164.17,125.76 164.17,123.68 162.76,122.27 162.76,118.13 162.41,117.78 162.41,115.42
FBA_CMD<13>: length 24.6
  BOTTOM w0.1: 164.92,127.05 164.92,132.21 164.7,132.44 164.27,132.44 163.95,132.75 U7600.M11
  BOTTOM w0.102: U7000.AF50 161.95,110.54 162.31,110.9 162.31,111.26 162.54,111.49 162.54,112.61 162.15,112.99 162.15,115.42
  BOTTOM w0.14: 164.92,127.05 163.49,125.62 R7100.1 163.49,123.8 162.24,122.54 162.24,118.3 162.15,118.21 162.15,115.42
FBA_CMD<14>: length 27.8
  BOTTOM w0.1: 161.52,133.65 161.61,133.74 162.98,133.74 U7600.K12
  BOTTOM w0.102: U7000.AF51 161.95,111.2 162.3,111.55 162.3,112.51 161.84,112.97 161.84,115.42
  BOTTOM w0.14: 161.84,115.42 161.84,117.66 161.6,117.9 161.6,124.06 159.01,126.65 159.01,132.39 159.99,133.37 161.24,133.37 161.52,133.65
FBA_CMD<15>: length 29.2
  BOTTOM w0.1: U7600.H11 163.63,135.03 161.8,135.03
  BOTTOM w0.102: U7000.AF52 161.95,112.46 161.46,112.95 161.46,115.4
  BOTTOM w0.14: 161.46,115.4 161.46,117.39 161.03,117.82 161.03,123.83 158.31,126.55 158.31,132.78 160.56,135.03 161.8,135.03
FBA_CMD<16>: length 40.4
  BOTTOM w0.1: U7601.M4 144.32,135.03 141.39,135.03
  BOTTOM w0.102: 156.55,114.33 156.55,112.1 156.5,112.05 156.5,111.45 156.7,111.25 156.7,110.7 U7000.AN50
  BOTTOM w0.14: 156.55,114.33 155.63,115.25 148.11,115.25 139.73,123.63 139.73,133.37 141.39,135.03
FBA_CMD<17>: length 37.7
  TOP w0.13: 141.36,133.95 v5(141.41,134)
  TOP w0.14: 141.36,133.95 141.04,133.64 R7112.1
  BOTTOM w0.1: U7601.K2 143.02,134.38 142.46,134.38 142.41,134.33 141.74,134.33 141.58,134.17 v5(141.41,134)
  BOTTOM w0.102: U7000.AN51 157.05,111.25 156.7,111.59 156.7,111.93 156.8,112.03 156.8,114.47 ; v5(141.41,134) 141.36,133.95
  BOTTOM w0.14: 141.36,133.95 140.37,132.96 140.37,123.73 148.33,115.77 155.5,115.77 156.8,114.47
FBA_CMD<18>: length 36.4
  BOTTOM w0.1: U7601.H4 144.33,133.07 144.33,133.52 144.14,133.71 142.55,133.71 142.32,133.48 141.72,133.48 141.41,133.17
  BOTTOM w0.102: U7000.AN52 157.05,114.59 ; 141.36,133.12 141.41,133.17
  BOTTOM w0.14: 157.05,114.59 155.35,116.29 148.7,116.29 140.89,124.1 140.89,132.65 141.36,133.12
FBA_CMD<19>: length 34.2
  BOTTOM w0.1: 144.46,126.54 145.96,128.04 145.96,132.74 145.3,133.4 U7601.J5
  BOTTOM w0.102: U7000.AM49 157.4,110 157.4,114.71
  BOTTOM w0.14: 144.46,126.54 143.62,125.7 143.62,122.81 149.62,116.81 155.3,116.81 157.4,114.71
FBA_CMD<20>: length 32.8
  BOTTOM w0.1: U7601.J4 144.97,133.73 145.43,133.73 146.16,133 146.16,127.86 144.8,126.5
  BOTTOM w0.102: U7000.AM52 157.75,114.87
  BOTTOM w0.14: 144.8,126.5 144.21,125.9 144.21,123.02 149.9,117.33 155.29,117.33 157.19,115.42 157.75,114.87
FBA_CMD<21>: length 32.9
  BOTTOM w0.1: U7601.K5 145.3,134.05 145.64,134.05 146.36,133.34 146.36,127.6 145.27,126.5
  BOTTOM w0.102: 158.08,114.96 158.08,111.53 157.75,111.2 U7000.AM51
  BOTTOM w0.14: 145.27,126.5 144.77,126.01 144.77,123.25 150.18,117.85 155.19,117.85 158.08,114.96
FBA_CMD<22>: length 34.9
  BOTTOM w0.1: 145.81,126.5 146.56,127.26 146.56,133.63 145.82,134.38 144.97,134.38 U7601.K4
  BOTTOM w0.102: 158.32,115.19 158.32,111.42 158.07,111.17 158.07,110.93 157.75,110.61 U7000.AM50
  BOTTOM w0.14: 145.81,126.5 145.34,126.03 145.34,123.49 149.03,119.79 154.36,119.79 155.61,118.55 155.61,117.9 158.08,115.42 158.32,115.19
FBA_CMD<23>: length 34.7
  BOTTOM w0.1: U7601.L5 145.3,134.7 145.94,134.7 146.76,133.88 146.76,126.92 146.34,126.5
  BOTTOM w0.102: U7000.AK50 159.15,110.57 158.8,110.92 158.8,111.25 158.56,111.49 158.56,115.35
  BOTTOM w0.14: 146.34,126.5 145.9,126.06 145.9,123.72 149.11,120.52 155.02,120.52 156.13,119.42 156.13,117.78 158.48,115.42 158.56,115.35
FBA_CMD<24>: length 34.8
  BOTTOM w0.1: U7601.L4 144.95,135.01 145.45,135.01 145.49,134.97 146.05,134.97 146.97,134.06 146.97,126.62 146.84,126.5
  BOTTOM w0.102: 158.81,115.42 158.8,115.42 158.8,111.6 159.15,111.25 U7000.AK51
  BOTTOM w0.14: 158.81,115.42 158.81,115.54 156.65,117.7 156.65,119.69 155.26,121.08 149.34,121.08 146.47,123.96 146.47,126.12 146.84,126.5
FBA_CMD<25>: length 33.7
  BOTTOM w0.1: U7601.L11 148.87,135.03 147.58,135.03 147.17,134.61 147.17,126.53
  BOTTOM w0.102: U7000.AK52 159.15,115.42 ; 147.17,126.5 147.17,126.53
  BOTTOM w0.14: 159.15,115.42 159.15,115.66 157.17,117.64 157.17,119.97 155.49,121.65 149.57,121.65 147.03,124.19 147.03,125.93 147.17,126.06 147.17,126.5
FBA_CMD<26>: length 34.6
  BOTTOM w0.1: 147.61,126.5 147.37,126.74 147.37,134.28 147.8,134.71 148.54,134.71 U7601.L10
  BOTTOM w0.102: 159.49,115.42 159.5,115.42 159.5,110 U7000.AJ49
  BOTTOM w0.14: 159.49,115.42 159.49,115.79 157.84,117.44 157.84,120.1 155.73,122.21 149.81,122.21 147.66,124.37 147.66,126.45 147.61,126.5
FBA_CMD<27>: length 31
  BOTTOM w0.1: 147.98,126.5 147.57,126.91 147.57,133.09 147.84,133.36 148.5,133.36 U7601.J10
  BOTTOM w0.102: U7000.AJ52 159.85,115.42
  BOTTOM w0.14: 159.85,115.42 159.85,115.86 159.23,116.48 158.43,117.28 158.43,120.31 155.96,122.78 150.04,122.78 148.27,124.56 148.27,126.22 147.98,126.5
FBA_CMD<28>: length 32.2
  BOTTOM w0.1: U7601.J11 148.87,133.08 147.99,133.08 147.77,132.86 147.77,127.4 148.09,127.08
  BOTTOM w0.102: U7000.AJ51 159.85,111.2 160.17,111.52 160.17,115.42
  BOTTOM w0.14: 148.09,127.08 148.83,126.34 148.83,124.79 150.28,123.35 156.19,123.35 158.95,120.59 158.95,117.34 160.17,116.11 160.17,115.42
FBA_CMD<29>: length 31.7
  BOTTOM w0.1: 148.87,132.43 148.44,132.43 148.05,132.04
  BOTTOM w0.102: 160.55,115.42 160.55,113.46 160.38,113.29 160.38,111.38 160.17,111.17 160.17,110.91 159.85,110.59 U7000.AJ50
  BOTTOM w0.14: 160.55,115.42 160.55,116.32 159.47,117.4 159.47,120.87 156.35,123.98 151.47,123.98 150.94,124.51 R7101.1 149.77,126.5 149.67,126.6 149.34,126.6 148.05,127.89 148.05,132.04 ; 148.87,132.43 U7601.H11
FBA_CMD<30>: length 30.9
  BOTTOM w0.1: 151.7,133.08 150.36,133.08 150.17,133.27 150.17,133.73 U7601.K12
  BOTTOM w0.102: 160.81,115.42 160.81,113.32 160.58,113.09 160.58,111.57 160.9,111.25 160.9,110.94 161.25,110.59 U7000.AG50
  BOTTOM w0.14: 160.81,115.42 160.81,116.63 159.99,117.45 159.99,121.67 154,127.66 154,132.55 152.86,133.69 152.3,133.69 151.7,133.08
FBA_CMD<31>: length 31.8
  BOTTOM w0.1: U7601.M11 149.52,135.03 151.54,135.03 151.92,135.41
  BOTTOM w0.102: U7000.AG51 161.25,111.25 160.8,111.7 160.8,112.92 161.13,113.25 161.13,115.36
  BOTTOM w0.14: 161.13,115.36 161.13,116.99 160.51,117.61 160.51,121.95 154.65,127.81 154.65,132.7 153.17,134.18 153.17,134.6 152.36,135.41 151.92,135.41
FBA_D<0>: length 19.7
  IN1 w0.127: v5(168.82,128.53) 168.61,128.32 168.61,127.18 168.84,126.96 168.84,122.33 167.86,121.35 167.86,115.88 168.13,115.62 168.13,114.17 167.83,113.87 v5(167.67,113.87)
  BOTTOM w0.102: v5(167.67,113.87) 168.16,113.87 168.59,113.44 168.59,111.54 168.25,111.2 U7000.U51
  BOTTOM w0.17: U7600.V4 v5(168.82,128.53)
FBA_D<1>: length 21.3
  IN1 w0.127: v5(170.07,127.32) 170.18,127.21 170.18,121.67 168.9,120.39 168.9,116.17 169.07,116.01 169.07,111.09 168.65,110.67 v5(168.65,110.05)
  BOTTOM w0.1: v5(170.07,127.32) 169.47,127.92 169.47,128.53 U7600.V3
  BOTTOM w0.102: U7000.U48 168.25,109.19 168.58,109.52 168.58,109.98 v5(168.65,110.05)
FBA_D<2>: length 21.4
  IN1 w0.075: 167.85,127.64 167.85,128.85 v5(168.18,129.18)
  IN1 w0.127: v5(167.72,114.49) 167.7,114.49 166.81,115.38 166.81,121.33 167.85,122.37 167.85,127.64
  BOTTOM w0.102: v5(167.72,114.49) 168.33,114.49 168.94,113.88 168.94,112.57 168.82,112.44 168.82,111.38 168.62,111.18 168.62,110.72 U7000.U50
  BOTTOM w0.17: U7600.U4 v5(168.18,129.18)
FBA_D<3>: length 21.9
  IN1 w0.075: v5(168.82,129.83) 169.15,129.51 169.15,128.97
  IN1 w0.127: 169.15,128.97 169.47,128.65 169.47,121.85 168.33,120.71 168.33,116.08 168.6,115.81 168.6,113.22 v5(167.95,112.58)
  BOTTOM w0.102: v5(167.95,112.58) 167.95,112 167.9,111.95 167.9,110 U7000.U49
  BOTTOM w0.17: U7600.U3 v5(168.82,129.83)
FBA_D<4>: length 27.5
  IN1 w0.075: v5(168.17,131.78) 168.5,132.1 170.3,132.1
  IN1 w0.127: 170.3,132.1 170.41,132.21 171.43,132.21 173.15,130.49 173.15,122.23 170.41,119.48 170.41,115.51 v5(169.99,115.1)
  BOTTOM w0.102: v5(169.99,115.1) 169.63,114.74 169.63,112.36 169.31,112.04 169.31,111.59 169.65,111.25 U7000.R51
  BOTTOM w0.17: U7600.P4 v5(168.17,131.78)
FBA_D<5>: length 24.5
  IN1 w0.075: 170.97,130.8 169.15,130.8 v5(168.82,131.13)
  IN1 w0.127: 170.97,130.8 171.34,130.43 171.34,121.75 169.45,119.85 v5(169.45,116.28)
  BOTTOM w0.102: 169.3,114.36 169.3,112.45 169.06,112.21 169.06,111.4 169.27,111.18 169.27,110.87 169.65,110.5 U7000.R50
  BOTTOM w0.17: v5(169.45,116.28) 169.3,116.14 169.3,114.36 ; U7600.P3 v5(168.82,131.13)
FBA_D<6>: length 32.5
  IN1 w0.127: v5(168.82,132.43) 169.45,133.06 171.95,133.06 173.91,131.1 173.91,122.17 171.18,119.44 171.18,118.02 170.85,117.69 170.85,115.31 170.48,114.94 170.48,111.31 170.14,110.97 170.14,108.21 169.83,107.9 v5(169.35,107.9)
  BOTTOM w0.17: U7600.N4 168.5,132.1 v5(168.82,132.43)
  BOTTOM w0.184: v5(169.35,107.9) 169.35,107.95 U7000.R47
FBA_D<7>: length 28.8
  IN1 w0.075: 170.99,131.45 170.99,131.45 169.8,131.45 v5(169.47,131.78)
  IN1 w0.102: 168.95,108.29 169.4,108.29 169.61,108.51
  IN1 w0.127: 169.61,108.51 169.73,108.63 169.73,110.14 169.55,110.33 169.55,115.8 169.94,116.19 169.94,119.68 172.44,122.18 172.44,130.14 171.12,131.45 170.99,131.45 ; 168.95,108.29 v5(168.55,107.89)
  BOTTOM w0.17: v5(169.47,131.78) U7600.N3
  BOTTOM w0.184: U7000.U46 168.55,107.85 v5(168.55,107.89)
FBA_D<8>: length 24.7
  IN4 w0.127: v5(167.22,107.18) 167.22,107.22 168.21,108.21 168.21,111.02 167.15,112.08 167.15,114.6 165.87,115.88 165.87,116.6 164.88,117.58 164.88,126.81 164.43,127.27 v5(164.35,127.27)
  BOTTOM w0.1: U7600.V11 163.62,128.53 163.62,128 v5(164.35,127.27)
  BOTTOM w0.184: U7000.V46 167.22,107.22 v5(167.22,107.18)
FBA_D<9>: length 25.2
  IN4 w0.127: v5(162.4,127.3) 162.09,126.99 162.09,117.72 163.63,116.18 163.63,115.03 164.45,114.21 164.45,111.5 165.51,110.44 165.51,108.21 165.65,108.07 165.65,107.35 v5(166.5,106.5)
  BOTTOM w0.1: U7600.V12 162.97,128.53 162.97,127.87 v5(162.4,127.3)
  BOTTOM w0.17: U7000.Y45 v5(166.5,106.5)
FBA_D<10>: length 22.7
  IN4 w0.127: v5(163.62,129.18) 163.62,117.51 164.78,116.36 164.78,115.36 165.78,114.36 165.78,111.72 166.26,111.24 166.26,108.9 v5(166.52,108.64)
  BOTTOM w0.17: U7600.U11 163.95,129.5 163.63,129.18 v5(163.62,129.18)
  BOTTOM w0.184: U7000.Y47 166.52,108.62 v5(166.52,108.64)
FBA_D<11>: length 24.6
  IN4 w0.127: v5(162.32,129.18) 162.83,128.67 162.83,125.77 163,125.61 163,117.47 164.24,116.23 164.24,115.17 165.16,114.25 165.16,111.56 165.89,110.84 165.89,108.49 166.43,107.95 166.43,107.93 166.45,107.9 v5(166.46,107.9)
  BOTTOM w0.1: U7600.U12 162.97,129.18 v5(162.32,129.18)
  BOTTOM w0.184: U7000.Y46 166.46,107.86 v5(166.46,107.9)
FBA_D<12>: length 25
  IN4 w0.127: v5(167.31,116.08) 166.9,116.49 166.9,118.18 166.11,118.97 166.11,130.62 164.54,132.19 164.04,132.19 v5(163.62,131.78)
  BOTTOM w0.102: U7000.V50 167.55,110.57 167.2,110.92 167.2,111.25 166.89,111.56 166.89,115.66 v5(167.31,116.08)
  BOTTOM w0.17: v5(163.62,131.78) 163.95,131.46 U7600.P11
FBA_D<13>: length 26.5
  IN4 w0.075: v5(162.97,131.13) 163.3,130.8 163.76,130.8 163.95,130.62 163.95,127.53
  IN4 w0.127: 163.95,127.53 163.95,127.07 164.27,126.75 164.27,117.53 165.35,116.45 165.35,115.62 166.36,114.61 166.36,111.87 167.67,110.57 167.67,108.37 167.23,107.93 v5(167.23,107.92)
  BOTTOM w0.17: v5(162.97,131.13) 163.3,131.45 U7600.P12
  BOTTOM w0.184: U7000.V47 167.23,107.93 v5(167.23,107.92)
FBA_D<14>: length 26.3
  IN4 w0.102: v5(167.7,113.03) 168.11,113.03 168.36,113.27 168.36,113.61 168.21,113.76
  IN4 w0.127: 168.21,113.76 168.21,115.65 167.96,115.9 167.96,118.34 166.72,119.58 166.72,131.57 165.21,133.08 v5(163.62,133.08)
  BOTTOM w0.1: U7600.N11 163.62,132.43 v5(163.62,133.08)
  BOTTOM w0.102: U7000.U52 168.32,111.82 168.32,112.78 168.07,113.03 v5(167.7,113.03)
FBA_D<15>: length 25.9
  IN4 w0.075: 164.53,131.45 163.22,131.45
  IN4 w0.127: v5(162.32,131.78) 162.9,131.78 163.22,131.45 ; 164.53,131.45 165.51,130.47 165.51,117.62 166.42,116.71 166.42,116.22 167.06,115.58 v5(167.64,115.58)
  BOTTOM w0.1: v5(162.32,131.78) 162.97,131.78 U7600.N12
  BOTTOM w0.102: v5(167.64,115.58) 167.3,115.24 167.3,112.6 167.14,112.44 167.14,111.66 167.55,111.25 U7000.V51
FBA_D<16>: length 45.3
  IN4 w0.127: v5(163.63,140.32) 163.2,140.75 161.21,140.75 161.12,140.66 159.69,140.66 155.85,136.83 155.85,136.13 154.92,135.2 154.92,120.13 159.4,115.64 159.4,112.55 160.12,111.84 160.12,110.95 159.77,110.61 159.77,106.74 159.7,106.67 159.7,106.3 v5(160.21,105.79)
  BOTTOM w0.1: v5(163.63,140.32) 163.63,139.57 U7600.B11
  BOTTOM w0.184: U7000.AJ44 v5(160.21,105.79)
FBA_D<17>: length 37.3
  IN4 w0.075: 161.95,138.6 162.53,138.6
  IN4 w0.127: v5(161.49,112.25) 161.55,112.31 161.55,112.96 160.72,113.8 160.72,115.66 156.48,119.89 156.48,134.59 160.12,138.23 160.75,138.23 161.03,138.51 161.86,138.51 161.95,138.6 ; v5(162.98,139.58) 162.98,139.05 162.53,138.6
  BOTTOM w0.102: v5(161.49,112.25) 161.59,112.16 161.59,109.29 U7000.AG48
  BOTTOM w0.17: v5(162.98,139.58) 163.17,139.38 163.17,139.38 U7600.B12
FBA_D<18>: length 42.1
  IN2 w0.127: v5(160.16,106.5) 160.16,106.51 159.77,106.9 159.77,115.32 156.44,118.65 156.44,136.4 159.85,139.8 160.62,139.8 160.78,139.96 163.24,139.96 v5(164.27,138.93)
  BOTTOM w0.17: v5(164.27,138.93) U7600.C11
  BOTTOM w0.184: v5(160.16,106.5) 160.16,106.54 U7000.AJ45
FBA_D<19>: length 37.3
  IN4 w0.127: v5(162.32,138.93) 161.96,139.3 161.96,139.41 161.55,139.82 161.24,139.82 160.83,139.41 160.83,139.37 160.49,139.03 160.26,139.03 156.01,134.79 156.01,119.7 160.19,115.52 160.19,112.81 160.89,112.11 v5(160.89,110.01)
  BOTTOM w0.1: U7600.C12 162.97,138.93 v5(162.32,138.93)
  BOTTOM w0.17: U7000.AG49 v5(160.89,110.01)
FBA_D<20>: length 38.5
  IN4 w0.075: 162.07,137.3 162.7,137.3
  IN4 w0.127: v5(163.62,136.98) 163.21,137.4 162.79,137.4 162.7,137.3 ; v5(162.25,107.9) 161.96,107.9 161.36,108.5 161.36,111.3 162.16,112.1 162.16,113.17 161.27,114.06 161.27,115.77 157.15,119.89 157.15,134.11 159.02,135.98 159.02,136.27 160.19,137.44 161.23,137.44 161.39,137.61 161.77,137.61 162.07,137.3
  BOTTOM w0.17: v5(163.62,136.98) 163.81,136.79 U7600.F11
  BOTTOM w0.184: v5(162.25,107.9) 162.25,107.85 U7000.AF46
FBA_D<21>: length 35.4
  IN4 w0.075: v5(162.97,136.33) 162.65,136.65 161.99,136.65
  IN4 w0.127: v5(162.3,108.55) 161.79,109.06 161.79,109.7 162.06,109.97 162.06,110.7 162.7,111.34 162.7,113.44 161.74,114.4 161.74,115.96 158.02,119.68 158.02,133.5 159.75,135.24 159.75,136.18 160.31,136.74 161.91,136.74 161.99,136.65
  BOTTOM w0.17: U7600.F12 163.3,136.65 v5(162.97,136.33)
  BOTTOM w0.184: v5(162.3,108.55) 162.25,108.55 U7000.AF47
FBA_D<22>: length 34.7
  IN4 w0.075: 162.04,136 163.95,136
  IN4 w0.127: 163.95,136 v5(164.27,136.33) ; 162.04,136 161.97,135.94 161.51,135.94 161.42,136.03 161.06,136.03 160.42,135.39 160.42,135.04 158.75,133.37 158.75,119.62 162.35,116.02 162.35,114.55 163.22,113.68 163.22,110.56 163.37,110.42 163.37,109.9 163.14,109.67 162.62,109.67 v5(162.24,109.3)
  BOTTOM w0.17: v5(164.27,136.33) U7600.G11 ; v5(162.24,109.3) 162.24,109.24 U7000.AF48
FBA_D<23>: length 33.8
  IN4 w0.127: v5(163.62,135.68) 163.13,135.19 161.54,135.19 160.69,134.34 160.69,133.69 160.44,133.44 159.96,133.44 159.55,133.04 159.55,126.15 160.97,124.74 160.97,118.07 162.88,116.15 162.88,114.81 163.7,113.99 163.7,111.6 163.94,111.36 163.94,108.84 163.05,107.95 163.05,107.9 v5(163.05,107.9)
  BOTTOM w0.17: v5(163.62,135.68) 163.62,135.68 163.3,136 U7600.G12
  BOTTOM w0.184: U7000.AD47 163.05,107.95 163.05,107.9 v5(163.05,107.9)
FBA_D<24>: length 37.4
  IN1 w0.127: v5(168.17,139.58) 167.82,139.23 167.11,139.23 166.95,139.38 166.03,139.38 165.34,138.69 165.34,135.77 165.28,135.48 164.99,135.19 164.46,135.02 161.46,135.02 161.21,134.77 161.21,126.93 162.14,126 162.14,113.72 162.42,113.44 162.42,111.45 163.04,110.83 163.04,110.1 v5(162.98,110.05)
  BOTTOM w0.17: U7000.AD49 162.98,110.02 v5(162.98,110.05) ; v5(168.17,139.58) U7600.B4
FBA_D<25>: length 41.4
  IN1 w0.127: v5(163.05,109.3) 162.69,109.67 162.25,109.67 162.1,109.83 162.1,110.83 161.89,111.03 161.89,112.95 161.48,113.36 161.48,116.43 160.74,117.18 160.74,139.32 161.36,139.95 164.43,139.95 164.55,140.06 168.33,140.06 168.43,139.96 169.09,139.96 v5(169.47,139.58)
  BOTTOM w0.17: v5(169.47,139.58) U7600.B3
  BOTTOM w0.184: U7000.AD48 163.05,109.25 v5(163.05,109.3)
FBA_D<26>: length 36.6
  IN1 w0.075: 163.23,129.23 163.3,129.3 163.3,131.51 163.23,131.58 ; v5(168.82,138.93) U7600.C4 167.89,138.6 167.8,138.69
  IN1 w0.127: 163.23,131.58 163.23,131.99 163.89,132.65 164.1,132.86 164.7,133.59 164.74,133.89 164.77,134.2 164.95,134.58 165.65,135.08 165.86,135.6 165.86,137.84 166.49,138.47 167.09,138.47 167.31,138.69 167.8,138.69 ; v5(164.37,107.91) 164.25,107.91 163.53,108.62 163.53,111.47 162.94,112.07 162.94,124.21 163.09,124.37 163.09,125.93 163.66,126.5 163.66,128.27 163.23,128.7 163.23,129.23
  BOTTOM w0.17: v5(168.82,138.93) U7600.C4
  BOTTOM w0.184: U7000.AC46 164.37,107.87 v5(164.37,107.91)
