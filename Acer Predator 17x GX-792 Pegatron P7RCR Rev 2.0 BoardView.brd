# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDI2_P_L: length 3.9
  TOP w0.108: U3401.17 303.8,147.54 303.43,147.17 302.62,147.17 v2(302.44,147.35)
  BOTTOM w0.108: v2(302.44,147.35) 302.55,147.25 303.68,147.25 L3401.1
LAN_MDI3_N: length 51.9
  TOP w0.108: U3300.21 277.52,102.45 277.19,102.78 277.19,103.36 277.11,103.44 277.11,104.1 v6(276.97,104.25) ; U3401.12 293.55,143.54 293.14,143.95 v2(292.87,143.95)
  IN4 w0.083: v2(292.87,143.95) 293.22,143.95 293.45,143.73 293.45,137.77 286.86,131.18 286.86,118.87 282.62,114.62 282.62,111.56 277.95,106.89 277.95,106.54 277.27,105.85 277.27,104.54 v6(276.97,104.25)
LAN_MDI3_N_C: length 8
  BOTTOM w0.108: v1(307.78,142.27) 307.78,142.49 ; 307.78,142.49 308.89,142.49 309.7,143.31 310.17,143.31 310.57,142.9 310.57,142.72 CON3400.8 ; 307.78,142.49 307.4,142.49 306.58,143.31 306.58,144.25 306.41,144.43 305.63,144.43 RN3400.2
LAN_MDI3_N_L: length 4
  TOP w0.108: v2(302.47,143.9) 302.57,143.8 303.59,143.8 303.84,143.54 U3401.13
  BOTTOM w0.108: v2(302.47,143.9) 303.03,144.46 303.66,144.46 RN3400.1
LAN_MDI3_P: length 51.9
  TOP w0.108: U3401.11 294.25,144.54 294.04,144.33 294.04,144.15 293.87,143.99 293.62,143.99 293.35,144.25 v2(293.35,144.51) ; U3300.20 277.75,102.73 277.55,102.93 277.55,103.51 277.48,103.59 277.48,104.22 v2(277.66,104.4)
  IN4 w0.083: v2(277.66,104.4) 277.66,104.59 277.58,104.67 277.58,105.72 278.26,106.41 278.26,106.76 282.93,111.43 282.93,114.5 287.17,118.74 287.17,131.05 293.76,137.64 293.76,143.86 293.35,144.26 v2(293.35,144.51)
LAN_MDI3_P_C: length 8
  BOTTOM w0.108: 306.95,143.9 306.95,143.46 307.55,142.86 308.74,142.86 309.55,143.67 310.32,143.67 310.64,143.35 CON3400.7 ; 306.95,143.9 v1(307.17,143.9) ; 306.95,143.9 306.95,144.4 306.56,144.79 305.67,144.79 RN3400.4
LAN_MDI3_P_L: length 3.9
  TOP w0.108: U3401.14 303.83,144.54 303.59,144.3 302.79,144.3 v2(302.46,144.64)
  BOTTOM w0.108: v2(302.46,144.64) 302.68,144.64 302.86,144.82 303.66,144.82 RN3400.3
LAN_RXN: length 107.3
  TOP w0.121: v2(272.1,97.08) 272.31,97.3 272.31,98.98 272.72,99.39 273.38,99.39 273.57,99.19 273.72,99.19 C3314.2
  IN4 w0.102: v2(219.67,61.32) 219.24,61.74 218.1,61.74 216.8,63.05 206.28,63.05 205.02,64.31 205.02,68.37 206.14,69.49 206.14,70.58 206.84,71.28 214.71,71.28 215.83,72.4 217.15,72.4 218.47,73.72 218.47,75.04 219.13,75.7 223.44,80 229.1,80 229.98,80.88 239.58,80.88 240.7,82 240.7,83.63 244.45,87.38 251.9,87.38 252.3,86.98 252.73,86.98 254.51,88.76 257.45,88.76 258.83,90.14 266.36,90.14 272.32,96.1 272.32,96.86 v2(272.1,97.08)
  BOTTOM w0.121: U2000.E20 219.67,61.03 v2(219.67,61.32)
LAN_RXN_C: length 2.9
  TOP w0.121: U3300.29 277.11,98.96 277.03,98.87 276.58,98.87 276.28,99.18 275.16,99.18 C3314.1
LAN_RXP: length 107.2
  TOP w0.121: C3313.2 273.62,98.96 273.47,98.96 273.28,99.15 272.81,99.15 272.55,98.89 272.55,97.29 v2(272.74,97.1)
  IN4 w0.102: v2(220.28,61.32) 219.87,61.73 219.56,61.73 219.33,61.96 218.19,61.96 216.89,63.27 206.37,63.27 205.23,64.4 205.23,68.28 206.36,69.41 206.36,70.49 206.93,71.06 214.8,71.06 215.92,72.18 217.24,72.18 218.69,73.63 218.69,74.95 223.53,79.79 229.19,79.79 230.07,80.66 239.67,80.66 240.91,81.91 240.91,83.54 244.54,87.17 251.81,87.17 252.21,86.77 252.82,86.77 254.6,88.55 257.54,88.55 258.92,89.92 266.45,89.92 272.54,96.01 272.54,96.9 v2(272.74,97.1)
  BOTTOM w0.121: U2000.G19 220.28,60.98 v2(220.28,61.32)
LAN_RXP_C: length 3
  TOP w0.121: U3300.30 277.09,98.56 277.02,98.64 276.49,98.64 276.18,98.94 275.22,98.94 C3313.1
LAN_TXN: length 116.7
  TOP w0.121: v2(273.33,97.54) 273.59,97.8 273.71,97.8 273.79,97.72 273.79,95.76 275.02,94.54 276.63,94.54 276.92,94.83 278.04,94.83 280.01,96.8 280.01,97.5 280.09,97.57 U3300.36
  IN4 w0.102: v2(273.33,97.54) 272.94,97.94 271.95,97.94 271.08,97.06 271.08,95.56 266.31,90.8 257.98,90.8 256.92,89.73 254.73,89.73 253.62,88.62 245.1,88.62 240.29,83.8 240.29,82.38 239.25,81.34 228.95,81.34 228.26,80.65 223.3,80.65 217.86,75.22 217.86,73.97 216.91,73.02 215.67,73.02 214.4,71.75 206.73,71.75 205.72,70.74 205.72,70.29 204.7,69.27 204.7,68.93 200.76,64.98 200.76,64.28 200.91,64.13 v2(201.19,64.13)
  BOTTOM w0.121: v1(201.75,60.23) 201.53,60.23 ; 201.53,60.23 201.53,63.48 201.19,63.82 v2(201.19,64.13) ; 201.53,60.23 201.53,57.33 203,55.86 206.38,55.86 207.13,56.6 207.69,56.6 C2013.1
LAN_TXP: length 116.8
  TOP w0.121: v2(273.33,98.15) 273.45,98.04 273.81,98.04 274.03,97.82 274.03,95.86 275.11,94.77 276.54,94.77 276.82,95.06 277.94,95.06 279.78,96.9 279.78,97.48 279.69,97.57 U3300.35
  IN4 w0.102: v2(273.33,98.15) 271.86,98.15 270.86,97.15 270.86,95.65 266.22,91.02 257.89,91.02 256.83,89.95 254.64,89.95 253.53,88.83 245.01,88.83 240.07,83.89 240.07,82.47 239.16,81.55 228.86,81.55 228.17,80.87 223.21,80.87 217.65,75.31 217.65,74.06 216.82,73.23 215.58,73.23 214.31,71.97 206.64,71.97 205.51,70.83 205.51,70.38 204.49,69.36 204.49,69.02 200.54,65.07 200.54,64.19 200.74,64 v2(200.74,63.7)
  BOTTOM w0.121: 201.3,62.31 201.3,57.24 202.91,55.63 206.48,55.63 207.22,56.37 207.83,56.37 C2012.1 ; 201.3,62.31 201.3,63.38 200.98,63.7 v2(200.74,63.7) ; 201.3,62.31 v1(201.08,62.31)
LCD_BKLTEN_EC: length 364
  TOP w0.102: v2(160.43,24.11) 159.72,24.82 159.72,28.89 160.34,29.51 U3002.118 ; R4593.2 92.13,187.99 91.96,188.17 D4503.2 91.29,188.83 89.9,190.23 85.83,190.23 85.32,190.74 v1(84.31,190.74) 84.22,190.74 v2(81.71,188.22)
  IN2 w0.102: v2(81.71,188.22) 81.27,187.79 77.85,187.79 73.58,183.53 72.3,183.53 66.87,178.1 66.87,171.29 66.68,171.09 66.68,166.95 64.69,164.95 58.19,164.95 57.38,164.14 57.38,153.58 56.33,152.53 56.33,148.59 56.06,148.32 56.06,135.7 58.43,133.34 58.43,126.34 55.83,123.74 55.83,113.44 53.73,111.34 48.39,111.34 39.45,102.4 39.45,82.84 40.04,82.26 40.04,77.98 30.13,68.07 30.13,64.96 28.55,63.38 26.29,63.38 20.07,57.17 20.07,49.54 23.37,46.24 23.37,44.58 26.3,41.66 26.3,24.95 28.35,22.89 38.61,22.89 39.02,23.3 60.49,23.3 62.58,25.38 116.9,25.38 119.23,23.04 151.52,23.04 151.72,23.25 153.13,23.25 153.34,23.45 158.18,23.45 158.44,23.71 160.03,23.71 v2(160.43,24.11)
LCD_BLEN: length 186.3
  TOP w0.102: D4502.1 94.63,188.23 94.49,188.09 R4518.2 94.49,186.67 v2(94.85,186.32)
  IN3 w0.102: v2(148.69,69.7) 148.59,69.81 142.13,69.81 141.61,70.32 141.61,73.18 140.82,73.97 140.3,73.97 138.35,75.93 136.66,75.93 135.29,77.3 133.83,77.3 130.8,80.34 130.8,82.17 130.08,82.88 130.08,87.65 127,90.73 127,116.41 127.31,116.72 127.31,123 127.82,123.51 127.82,124.03 127.4,124.46 127.16,124.46 122.71,128.9 122.71,130.45 122.24,130.92 122.24,133.84 120.14,135.94 118.44,135.94 117.74,136.63 117.13,136.63 116.64,137.12 116.64,144.54 117.71,145.6 122.86,145.6 123.13,145.87 123.52,145.87 126.65,149 v2(126.65,150.91)
  IN4 w0.102: v2(92.74,183.29) 92.74,181.21 93.78,180.17 93.78,178.19 95.1,176.87 95.1,166 95.84,165.27 95.84,162.21 96.6,161.45 98.68,161.45 99.04,161.81 100.31,161.81 101.79,160.33 105.86,160.33 107,159.19 112.97,159.19 119.83,152.33 120.77,152.33 121.55,151.54 123.22,151.54 123.55,151.87 125.2,151.87 125.76,151.31 126.4,151.31 126.65,151.06 v2(126.65,150.91)
  BOTTOM w0.102: U7408.3 149.94,70.31 149.33,69.7 v2(148.69,69.7) ; v2(94.85,186.32) 96.72,184.44 96.72,183.2 v1(97.31,182.61) 96.27,181.57 95.55,181.57 94.88,180.91 92.39,180.91 92.06,181.24 92.06,182.7 92.65,183.29 v2(92.74,183.29)
LCD_VCC_EN: length 155.6
  TOP w0.102: U7407.3 142.49,69.63 142.29,69.83 141.14,69.83 140.85,69.55 140.85,69.27 v2(140.37,68.79)
  IN1 w0.102: v2(104.27,179.69) 104.27,179.31 111.58,172 115.16,172 119.54,167.62 119.54,165.01 120.86,163.68 120.86,163.52 123.88,160.5 123.88,153.53 125.25,152.15 125.25,150.4 125.58,150.07 125.58,149.27 v2(124.34,148.03)
  IN3 w0.102: v2(140.37,68.79) 139.22,69.93 139.22,73.62 137.93,74.91 133.51,74.91 128.68,79.74 128.68,82.73 128.96,83 128.96,84.58 128.73,84.8 128.73,87.56 125.98,90.31 125.98,111.71 125.32,112.37 125.32,124.86 121.7,128.48 121.7,130.03 121.22,130.5 121.22,133.41 119.11,135.53 118.27,135.53 117.57,136.23 116.96,136.23 116.24,136.95 116.24,144.71 117.61,146.08 122.76,146.08 122.96,146.28 123.16,146.28 124.34,147.47 v2(124.34,148.03)
  BOTTOM w0.102: SR4506.1 v1(110.6,180.6) 110.6,179.69 109.71,178.8 105.16,178.8 v2(104.27,179.69)
LFRAME#_ESPI_CS0#: length 7.1
  BOTTOM w0.121: U2000.BE16 239.18,62.62 241.93,62.62 242.76,63.46 v1(244.71,63.46) 244.82,63.35 SR2206.2
LG_C: length 14.4
  IN3 w0.635: v4(89.52,155.18) 90.91,155.18 92.69,156.95 98.15,156.95 100.44,159.24 v4(102.24,159.24)
  vias: v1(88.53,155.07)
LGF_LED_ON: length 240.6
  TOP w0.102: SR3018.2 169.55,19.88 170.04,20.37 v2(170.04,20.66) ; v2(127.51,45.75) 127.51,43.47 129.85,41.13 v1(129.85,40.19) 129.85,34.03 125.11,29.3 125.11,28.57 123.86,27.31 123.35,27.31 122.69,27.97 121.4,27.97 119.54,26.12 v2(119.54,23.73)
  IN1 w0.102: v2(99.93,180.45) 106.99,173.39 106.99,164.77 106.72,164.5 106.72,162.6 109.68,159.65 119.76,159.65 121.11,158.29 121.11,153.69 122.69,152.12 122.69,151.55 122.19,151.04 122.19,149.49 125.95,145.73 125.95,135.07 124.7,133.81 124.7,132.04 125.08,131.66 125.08,125.54 125.51,125.11 125.51,123.4 126.99,121.91 126.99,65.98 127.62,65.36 127.62,51.26 127.51,51.16 v2(127.51,45.75)
  IN4 w0.102: v2(119.54,23.73) 119.54,23.4 120.1,22.84 140.82,22.84 143.94,19.72 169.55,19.72 170.04,20.21 v2(170.04,20.66)
  BOTTOM w0.102: Q4501.1 101.01,181.53 v2(99.93,180.45)
LGF_LED_ON#: length 23.6
  TOP w0.102: CON4500.36 104.75,189.39 103.07,191.07 101.32,191.07 100.15,189.9 99.24,189.9 98.69,189.34 98.69,180.45 99.17,179.97 100.08,179.97 v2(100.56,180.45)
  BOTTOM w0.102: v2(100.56,180.45) 101.2,181.08 101.83,181.08 101.96,180.96 Q4501.3 v1(101.96,178.8)
LID_SW#: length 320.3
  TOP w0.102: v2(95.43,186.9) 95.23,187.1 R4592.2 95.23,187.99 95.38,188.14 95.82,188.14 95.93,188.26 D4502.2 ; U3002.17 154.47,33.71 152.58,31.83 v2(152.58,30.32)
  IN2 w0.102: v2(152.58,30.32) 151.65,29.39 136.46,29.39 128.74,37.11 122.61,37.11 121.14,35.64 113.94,35.64 112.87,34.58 108.88,34.58 108.36,34.06 103.04,34.06 100.97,31.98 55.64,31.98 52.66,34.96 44.87,34.96 42.14,37.68 42.14,40.88 36.71,46.31 36.71,67.78 45.98,77.05 45.98,88.66 45.6,89.04 45.6,100.34 45.6,100.51 45.8,100.71 52.37,107.28 57.97,107.28 60.92,110.22 60.92,112.46 62.52,114.06 62.52,117.2 63.43,118.11 63.43,122.81 63.68,123.06 63.68,128.26 63.1,128.84 63.1,133.93 64.6,135.42 64.6,143.84 67.09,146.33 67.09,147.44 69.51,149.86 69.51,153.31 70.99,154.8 70.99,169.03 72.24,170.28 72.24,175.74 72.75,176.25 72.75,177.07 73.46,177.78 76.17,177.78 80.83,182.44 80.83,183.9 81.46,184.54 85.68,184.54 88.5,187.36 90.18,187.36 91.19,186.34 92.89,186.34 93.45,186.9 v2(95.43,186.9)
  BOTTOM w0.102: v1(152.06,29.79) v2(152.58,30.32) ; CON5602.25 93.75,185.42 94.37,186.04 94.37,186.57 94.7,186.9 v2(95.43,186.9)
LINE1_JD#: length 27.3
  TOP w0.254: R3624.2 v2(14.46,26.65) 14.65,26.84 14.66,26.84 v1(14.91,27.1)
  IN4 w0.254: v2(14.46,26.65) 13.85,27.26 13.85,28.2 14.43,28.79 14.43,31.38 12.43,33.38 11.54,33.38 10.52,34.4 10.52,37.52 9.71,38.34 9.71,41.99 10.42,42.7 12.93,42.7 14.84,44.61 v2(14.84,44.76)
  BOTTOM w0.254: v2(14.84,44.76) 14.81,44.79 14.74,44.79 14.33,45.2 CON6700.22
LINE1_L: length 19.4
  TOP w0.254: L6701.1 R6737.2 ; R6737.2 9.63,44 v2(9.63,44.43) ; R6737.2 8.46,42.83 v1(8.31,42.83) ; C3639.2 v2(15.6,31.99)
  IN2 w0.254: v2(15.6,31.99) 15.09,31.99 13.52,33.56 13.09,33.56 12.15,34.5 12.15,35.24 11.44,35.95 11.44,36.51 9.63,38.31 v2(9.63,44.43)
LINE1_R: length 20.9
  TOP w0.254: v2(15.6,31.35) 15.51,31.35 C3640.2 ; v2(9,44.43) 9,44.63 R6738.2 L6700.1
  IN2 w0.254: v2(15.6,31.35) 14.99,31.35 13.29,33.05 12.76,33.05 11.54,34.27 11.54,35.06 10.93,35.67 10.93,36.2 9,38.13 v2(9,44.43)
  BOTTOM w0.254: v1(15.3,29.95) 15.12,30.13 15.12,30.92 15.55,31.35 v2(15.6,31.35)
LINE1_VREFO_L: length 15.5
  TOP w0.203: U3600.31 8.54,33.02 v2(8.66,33.13)
  TOP w0.254: R6737.1 v2(7.73,43.8) 7.27,43.34 6.99,43.34 v1(6.41,42.76)
  IN2 w0.254: v2(8.66,33.13) 8.66,33.35 9.28,33.97 9.28,35.92 6.99,38.21 6.99,43.06 v2(7.73,43.8)
LINE1_VREFO_R: length 15.6
  TOP w0.203: v2(9.34,33.12) 9.29,33.12 8.94,32.77 U3600.30
  TOP w0.254: v1(7.27,44.28) 7.42,44.43 v2(8.36,44.43) 8.36,44.86 R6738.1
  IN2 w0.254: v2(9.34,33.12) 9.91,33.69 9.91,36.1 7.55,38.46 7.55,42.6 8.36,43.42 v2(8.36,44.43)
LP9+: length 13.4
  TOP w0.121: CON4500.32 106.75,189.05 106.7,189.1 106.7,189.53 106.37,189.85 106.37,190.34 106.1,190.61 v2(105.52,190.61)
  BOTTOM w0.121: v2(105.52,190.61) 105.75,190.37 106.13,190.37 106.37,190.13 106.37,189.16 105.46,188.25 105.46,187.73 U4501.3 105.46,187.24 105.46,186.14 106.19,185.42 106.19,183.83 105.92,183.57 105.09,183.57 105.01,183.5 105.01,183.15 L4500.3
LP9-: length 13.4
  TOP w0.121: CON4500.33 106.25,188.98 106.46,189.2 106.46,189.43 106.14,189.75 106.14,190.24 106,190.37 105.87,190.37 105.55,190.05 v2(105.21,190.05)
  BOTTOM w0.121: v2(105.21,190.05) 105.3,190.14 106.03,190.14 106.14,190.03 106.14,189.26 105.23,188.35 105.23,186.05 105.95,185.32 105.95,184.83 U4501.4 105.95,184.34 105.95,183.93 105.83,183.81 104.99,183.81 104.77,183.59 104.77,183.17 L4500.2
LPC_AD0: length 259.3
  TOP w0.121: v2(158.79,42.15) 158.78,42.15 158.34,42.59 157.34,42.59 157.05,42.3 157.05,41.29 SR3007.1 ; v2(237.47,30.44) 238.34,29.57 U6200.26 ; SR2202.1 243.91,60.18 248.68,60.18 v2(249.36,60.86)
  IN1 w0.083: v2(249.36,60.86) 248.35,59.86 248.35,58.44 248.53,58.27 248.53,48.68 248.93,48.27 248.93,44.78 245.1,40.95 244.54,40.95 243.91,40.31 243.91,39.47 243.56,39.11 243.37,39.11 243.22,38.96 243.22,38.73 241.67,37.18 240.28,37.18 236.52,33.42 236.52,31.39 v2(237.47,30.44) ; v2(119.85,20.61) 120.88,19.58 120.88,16.93 127.67,10.14 v2(141.71,10.14)
  IN4 w0.083: v2(119.85,20.61) 121.26,22.02 124.43,22.02 126.23,20.21 133.82,20.21 134.08,20.47 136.1,20.47 138.47,18.1 147.07,18.1 147.53,17.63 175.8,17.63 176.36,18.19 185.59,18.19 185.83,18.43 201.72,18.43 204.2,20.9 204.92,20.9 205.57,21.56 206.69,21.56 209.97,24.84 210.5,24.84 212.41,26.75 226.88,26.75 228.22,28.09 229.82,28.09 231.02,29.29 231.02,30.81 231.73,31.52 236.39,31.52 v2(237.47,30.44)
  BOTTOM w0.121: v2(158.79,42.15) 158.79,42.77 157.3,44.26 141.31,44.26 130.05,33 130.05,29.87 v1(129.85,29.68) 129.09,29.68 127.78,28.36 127.78,26.75 124.19,23.17 122.34,23.17 119.85,20.68 v2(119.85,20.61) ; CON4400.11 141.75,10.1 v2(141.71,10.14)
LPC_AD0_EC: length 7.2
  TOP w0.121: U3002.10 157.26,36.03 158.73,37.5 158.73,39.15 158.61,39.28 157.92,39.28 157.82,39.37 SR3007.2 157.57,39.69 157.18,40.09 v1(156.65,40.09)
LPC_AD1: length 250.4
  TOP w0.121: v2(157.52,42.15) 157.52,41.54 158.06,41 158.18,41 SR3006.1 ; v2(236.84,30.46) 236.84,30.44 236.39,29.99 U6200.23 ; v2(248.75,60.86) 248.52,60.63 SR2203.1
  IN1 w0.083: v2(236.84,30.46) 236.31,30.99 236.31,33.51 240.19,37.39 241.58,37.39 243.01,38.82 243.01,39.05 243.28,39.32 243.47,39.32 243.7,39.56 243.7,40.4 244.46,41.16 245.01,41.16 247.84,43.99 247.84,47.99 248.32,48.47 248.32,58.18 248.14,58.36 248.14,60.26 v2(248.75,60.86) ; v2(120.46,20.63) 121.09,20 121.09,17.13 127.67,10.55 141.94,10.55 v2(142.35,10.14)
  IN4 w0.083: v2(236.84,30.46) 235.99,31.31 231.81,31.31 231.25,30.74 231.25,29.2 229.84,27.79 228.23,27.79 226.96,26.52 212.48,26.52 210.59,24.63 210.06,24.63 206.78,21.35 205.66,21.35 205.01,20.7 204.28,20.7 201.8,18.22 185.91,18.22 185.68,17.98 176.57,17.98 176,17.42 147.43,17.42 146.96,17.89 138.36,17.89 135.99,20.26 134.17,20.26 133.54,19.63 126.43,19.63 124.26,21.81 121.63,21.81 v2(120.46,20.63)
  BOTTOM w0.121: v2(142.35,10.14) 142.75,9.74 CON4400.9 ; v2(157.52,42.15) 157.52,43.49 157.18,43.82 v1(153.02,43.82) 152.81,43.62 141.02,43.62 130.3,32.9 130.3,29.49 130.04,29.24 129.03,29.24 128.02,28.23 128.02,26.65 124.29,22.92 122.44,22.92 120.46,20.94 v2(120.46,20.63)
LPC_AD1_EC: length 7.9
  TOP w0.121: U3002.9 157.66,36.05 158.98,37.37 158.98,39.35 SR3006.2 158.93,39.69 159.06,39.82 159.06,40.83 158.37,41.51 v1(158.17,41.51)
LPC_AD2: length 259.7
  TOP w0.121: v2(158.15,42.15) 158.2,42.15 159.52,40.83 SR3005.1 ; v2(233,30.49) 233,30.28 233.46,29.83 233.99,29.83 234.01,29.81 234.03,29.81 234.13,29.71 234.13,29.69 234.44,29.38 U6200.20 ; v2(249.97,60.86) 249.53,61.3 248.37,61.3 248.15,61.08 245.61,61.08 244.56,62.13 SR2204.1
  IN1 w0.083: v2(142.98,10.14) 142.36,10.76 127.76,10.76 121.29,17.23 121.29,20.39 v2(121.07,20.62) ; v2(233,30.49) 233.56,29.93 237.65,29.93 237.87,30.15 237.87,30.7 236.79,31.78 236.79,33.4 240.37,36.97 242.5,36.97 243.53,38.01 246.42,38.01 247.17,38.76 247.17,39.14 246.99,39.31 246.99,42.54 249.14,44.69 249.14,48.36 248.74,48.76 248.74,58.08 249.33,58.68 249.33,60.22 v2(249.97,60.86)
  IN4 w0.083: v2(233,30.49) 232.6,30.88 232.1,30.88 231.71,30.49 231.71,28.88 230.11,27.29 229.34,27.29 227.9,25.85 227.23,25.85 227.1,25.97 217.36,25.97 216.04,24.65 211.21,24.65 210.76,24.21 210.23,24.21 209.71,23.69 209.71,23.35 206.64,20.28 204.46,20.28 201.98,17.8 186.09,17.8 185.86,17.56 176.94,17.56 176.36,16.99 145.64,16.99 145.43,16.78 137.62,16.78 136.67,17.72 125.97,17.72 124.86,18.83 124.86,20.45 124.11,21.21 123.2,21.21 123,21.01 121.46,21.01 v2(121.07,20.62)
  BOTTOM w0.121: v2(142.98,10.14) 143.75,9.37 CON4400.7 ; v2(121.07,20.62) 121.07,21.2 122.54,22.67 124.39,22.67 128.27,26.55 128.27,28.13 129.13,28.99 130.14,28.99 130.54,29.39 130.54,32.8 140.91,43.16 v1(148.14,43.16) 153.32,43.16 153.33,43.17 156.18,43.17 157.03,42.32 157.03,41.97 157.28,41.71 157.72,41.71 v2(158.15,42.15)
LPC_AD2_EC: length 6.2
  TOP w0.121: v1(159.77,38.77) 159.77,39.44 SR3005.2 159.26,39.44 159.26,37.04 158.06,35.84 U3002.8
LPC_AD3: length 265.4
  TOP w0.121: U6200.17 232.49,30.26 v2(232.26,30.49) ; SR3009.1 160.37,41.01 160.12,41.26 160.12,41.41 158.69,42.84 157.24,42.84 v2(156.57,42.17)
  IN1 w0.083: v2(232.26,30.49) 232.26,30.11 232.66,29.72 239.11,29.72 239.37,29.97 239.37,34.86 240.85,36.34 242.76,36.34 243.79,37.38 246.68,37.38 251.06,41.76 251.06,49.8 251.23,49.97 251.23,52.25 250.97,52.51 250.97,54.62 250.21,55.38 250.06,55.38 249.37,56.07 249.37,57.82 249.96,58.41 249.96,59.7 250.8,60.54 250.8,63.46 250.09,64.17 245.84,64.17 v2(244.23,62.56) ; v2(121.68,20.6) 121.5,20.43 121.5,17.32 127.84,10.98 143.92,10.98 v2(144.76,10.14)
  IN4 w0.083: v2(232.26,30.49) 232.26,29.14 230.16,27.03 229.47,27.03 228.02,25.58 227.19,25.58 227.01,25.76 217.53,25.76 216.21,24.44 211.29,24.44 210.85,24 210.32,24 209.92,23.6 209.92,23.2 206.76,20.05 204.52,20.05 202.06,17.59 186.17,17.59 185.94,17.36 177.12,17.36 176.54,16.78 145.81,16.78 145.6,16.57 137.53,16.57 136.59,17.51 125.12,17.51 124.65,17.98 124.65,20.37 124.02,21 123.28,21 122.89,20.6 v2(121.68,20.6)
  BOTTOM w0.121: v2(156.57,42.17) 155.82,42.92 153.56,42.92 153.35,42.7 v1(145.95,42.7) 140.8,42.7 130.79,32.69 130.79,29.29 130.24,28.74 129.24,28.74 128.52,28.02 128.52,26.45 124.5,22.42 122.65,22.42 121.68,21.45 v2(121.68,20.6) ; SR2205.1 244.13,62.67 v2(244.23,62.56) ; v2(144.76,10.14) 144.75,10.13 CON4400.5
LPC_AD3_EC: length 7.6
  TOP w0.121: U3002.7 158.47,35.86 159.75,37.14 159.75,37.87 160.37,38.49 SR3009.2 160.71,39.69 160.85,39.83 160.85,41.27 v1(160.66,41.46)
LPC_FRAME#: length 252.1
  TOP w0.121: SR3008.1 161.28,41.62 160.91,42 160.91,42.51 160.69,42.73 159.37,42.73 159.36,42.73 159.01,43.08 156.85,43.08 v2(155.94,42.17) ; U6200.22 235.74,29.52 236.1,29.88 v2(236.1,30.46)
  IN1 w0.083: v2(122.28,21.41) 122.28,20.57 121.71,20 121.71,17.6 128.12,11.2 144.34,11.2 v2(145.4,10.14) ; v2(236.1,30.46) 236.1,33.59 240.7,38.19 240.7,39.49 242.72,41.51 245.07,41.51 247.64,44.07 247.64,48.08 248.11,48.56 248.11,58.09 247.93,58.27 247.93,60.34 248.32,60.73 248.32,63.14 v2(247.68,63.77)
  IN4 w0.083: v2(122.28,21.41) 122.29,21.42 124.25,21.42 126.34,19.33 133.91,19.33 134.63,20.05 135.72,20.05 138.13,17.63 146.79,17.63 147.22,17.21 176.21,17.21 176.77,17.77 185.77,17.77 186,18.01 201.89,18.01 204.37,20.49 205.09,20.49 205.75,21.14 206.86,21.14 210.14,24.42 210.68,24.42 212.55,26.3 227.03,26.3 228.28,27.54 230.07,27.54 231.5,28.97 231.5,30.7 231.9,31.1 235.46,31.1 v2(236.1,30.46)
  BOTTOM w0.121: v2(155.94,42.17) 155.44,42.67 154.1,42.67 153.64,42.22 v1(150.15,42.22) 140.66,42.22 131.04,32.59 131.04,29.19 130.34,28.49 129.34,28.49 128.77,27.92 128.77,26.34 124.6,22.18 123.05,22.18 v2(122.28,21.41) ; v2(145.4,10.14) 145.4,9.74 145.75,9.38 CON4400.3 ; v2(247.68,63.77) 247.26,63.35 SR2206.1
LPC_FRAME#_EC: length 6
  TOP w0.121: SR3008.2 161.28,39.49 161.1,39.3 160.84,39.3 160.71,39.17 160.71,38.01 160.21,37.5 v1(160.21,36.99) 160.21,36.69 159.89,36.37 159.39,36.37 158.86,35.85 U3002.6
LPCPD#: length 45.7
  TOP w0.121: v2(238.94,30.4) 239,30.4 239.64,29.77 U6200.28
  IN1 w0.083: v2(238.94,30.4) 238.57,30.77 238.57,34.37 240.76,36.55 242.67,36.55 243.7,37.59 246.59,37.59 248.55,39.55 248.55,43.51 249.56,44.52 249.56,48.53 249.16,48.94 249.16,57.91 249.75,58.5 249.75,59.79 250.59,60.63 250.59,63.11 v2(250.2,63.51)
  BOTTOM w0.121: v2(250.2,63.51) 249.43,62.75 SR2209.1 ; v1(238.26,31.09) v2(238.94,30.4)
M2_SSD_PEDET: length 232.6
  TOP w0.102: v2(229.34,52.08) 228.81,51.55 228.81,49.53 228.34,49.06 228.34,47.18 228.02,46.86 228.02,44.2 R2105.2 227.87,43.18 227.87,41.72 228.07,41.51 228.07,40.65 R2110.1 228,39.91 228,39.05 v1(227.79,38.84) 227.04,38.84 v2(226.54,38.34) ; R5115.2 33.64,22.71 32.72,23.63 v2(32.72,24.24)
  IN3 w0.102: v2(32.72,24.24) 33.36,23.6 39.21,23.6 40.87,21.95 60.26,21.95 62.82,24.52 97.39,24.52 98.71,23.2 101,23.2 104.5,26.7 115.95,26.7 121.01,31.76 124.24,31.76 125.26,32.78 125.68,32.78 125.91,32.54 125.91,32.39 126.65,31.66 131.77,31.66 134.82,34.7 137.17,34.7 137.94,33.94 144.04,33.94 147.15,30.83 151.17,30.83 152.4,29.6 158.77,29.6 159.32,29.05 167.25,29.05 168.08,29.88 171.35,29.88 171.48,30.02 185.7,30.02 185.96,29.75 187.03,29.75 187.57,29.2 195.73,29.2 199.07,32.55 199.65,32.55 204.96,37.85 215.17,37.85 216.49,39.17 225.7,39.17 v2(226.54,38.34)
  BOTTOM w0.102: v2(229.34,52.08) 229.74,52.08 U2000.AG36 ; CON5102.69 32.16,21.95 32.72,22.51 v2(32.72,24.24)
M_CHA_ACT#: length 70.4
  TOP w0.229: v2(67.52,59.93) 67.02,60.42 67.02,60.86 67.4,61.23 67.54,61.23 68.44,62.14 69.08,62.14 70.87,63.93 CON1600.114
  IN1 w0.159: v3(86.78,100.97) 83.67,97.86 83.67,94.41 64.3,75.04 64.3,64.47 65.67,63.11 65.67,61.56 67.3,59.93 v2(67.52,59.93)
  BOTTOM w0.076: U0300.AU3 87.69,104.49 87.17,103.97 87.17,102.76 86.42,102 86.42,101.34 v3(86.78,100.97)
  BOTTOM w0.229: v2(67.52,59.93) 67.93,60.34 68.31,60.34 68.91,59.74 68.91,58.99 68.73,58.81 67.79,58.81 67.59,58.61 67.59,58.33 67.92,58.01 68.74,58.01 68.88,57.87 CON1601.114
M_CHA_ALERT#: length 66.5
  TOP w0.229: CON1600.116 71.37,63.6 69.58,61.81 69.2,61.81 68.84,61.45 68.84,60.89 69.15,60.59 v2(69.41,60.59)
  IN1 w0.159: v2(69.41,60.59) 69.18,60.82 69.08,60.82 67.92,61.97 67.92,63.4 66.2,65.11 66.2,74.4 85.48,93.67 85.48,97.35 88.02,99.89 v3(88.02,100.97)
  BOTTOM w0.076: U0300.AU5 88.07,105.6 88.07,103.03 87.94,102.9 87.94,101.33 88.02,101.25 v3(88.02,100.97)
  BOTTOM w0.229: v2(69.41,60.59) 70.03,59.96 70.03,59.16 69.38,58.5 CON1601.116
M_CHA_BA0: length 72.5
  TOP w0.229: v2(80.12,60.19) 80.11,60.19 79.64,60.67 79.64,60.95 79.77,61.09 80.19,61.09 80.32,61.22 80.32,61.64 80.19,61.77 79.79,61.77 79.64,61.92 79.64,62.25 79.81,62.43 80.59,62.43 80.8,62.64 80.8,63.42 81.02,63.64 81.8,63.64 81.87,63.71 CON1600.150
  IN1 w0.076: 95.02,99.63 95.02,99.89 95.17,100.04 95.17,104.98 95.12,105.02 v3(94.77,105.02)
  IN1 w0.159: v2(80.12,60.19) 80.26,60.19 80.53,60.47 80.53,62.69 80.56,62.71 80.56,64.79 80.34,65.01 80.34,69.16 79.66,69.84 79.66,71.19 79.83,71.36 80.26,71.36 80.34,71.44 80.34,71.87 80.67,72.2 80.67,72.43 81.02,72.79 81.25,72.79 81.35,72.69 81.57,72.69 81.79,72.91 81.79,73.14 81.7,73.24 81.7,73.46 81.92,73.69 82.14,73.69 82.24,73.59 82.47,73.59 82.69,73.81 82.69,74.04 82.59,74.13 82.59,74.36 82.82,74.58 83.04,74.58 83.14,74.48 83.37,74.48 83.59,74.71 83.59,74.93 83.49,75.03 83.49,75.26 83.72,75.48 83.94,75.48 84.04,75.38 84.26,75.38 84.49,75.61 84.49,75.83 84.39,75.93 84.39,76.16 84.61,76.38 84.84,76.38 84.94,76.28 85.16,76.28 85.39,76.51 85.39,76.73 85.29,76.83 85.29,77.05 95.89,87.65 95.89,91.14 96.48,91.73 96.48,96.17 95.02,97.63 95.02,99.63
  BOTTOM w0.076: v3(94.77,105.02) 94.77,105.53 U0300.AH5
  BOTTOM w0.229: v2(80.12,60.19) 80.46,60.19 80.65,60 80.65,59.42 80.24,59.01 78.24,59.01 78.16,58.94 78.16,58.63 79.08,57.72 79.62,57.72 79.88,57.47 CON1601.150
M_CHA_BA1: length 67.8
  TOP w0.229: v2(78.75,60.15) 78.75,59.31 80.62,57.44 CON1600.145
  IN1 w0.159: v3(94.63,100.32) 94.52,100.21 94.52,97.37 95.99,95.9 95.99,93.61 95.72,93.34 95.72,92.92 95.99,92.65 95.99,92.37 94.89,91.27 94.89,88.07 79.66,72.85 79.66,72.61 78.66,71.61 78.66,69.06 78.8,68.92 79.16,68.92 79.3,68.78 79.3,68.5 79.18,68.38 78.85,68.38 78.69,68.23 78.69,67.84 78.84,67.69 79.21,67.69 79.33,67.57 79.33,67.17 79.21,67.04 78.76,67.04 78.66,66.94 78.66,66.52 78.78,66.39 79.23,66.39 79.33,66.29 79.33,65.86 79.2,65.72 78.79,65.72 78.66,65.59 78.66,65.28 78.85,65.09 79.24,65.09 79.33,65 79.33,64.6 79.55,64.38 79.55,63.09 79.53,63.07 79.53,60.93 v2(78.75,60.15)
  BOTTOM w0.076: U0300.AH1 95.23,103.59 95.34,103.7 95.45,103.7 95.56,103.59 95.56,100.97 95.55,100.96 ; v3(94.63,100.32) 94.41,100.1 94.41,99.83 94.61,99.63 95.03,99.63
  BOTTOM w0.089: 95.55,100.96 95.55,100.15 95.03,99.63
  BOTTOM w0.229: CON1601.145 78.63,63.88 78.8,63.71 78.92,63.71 79.22,63.41 79.22,60.58 78.8,60.15 v2(78.75,60.15)
M_CHA_BG0: length 66.3
  TOP w0.229: v2(67.49,60.66) 67.64,60.66 68.13,60.17 68.13,59.73 69.02,58.84 70.13,58.84 71.12,57.84 CON1600.115
  IN1 w0.159: v2(67.49,60.66) 67.28,60.66 66.38,61.56 66.38,63.11 64.8,64.68 64.8,74.83 84.03,94.06 84.03,96.81 86.78,99.56 v3(86.78,100.36)
  BOTTOM w0.076: U0300.AU1 87.69,101.73
  BOTTOM w0.222: 87.69,101.73 87.38,101.43 87.38,100.57 87.18,100.36 v3(86.78,100.36)
  BOTTOM w0.229: v2(67.49,60.66) 67.72,60.88 68.26,60.88 68.49,61.11 68.49,61.47 68.26,61.7 67.64,61.7 67.49,61.85 67.49,62.3 69.13,63.93 CON1601.115
M_CHA_BG1: length 69.3
  TOP w0.229: v2(67.53,59.2) 66.95,59.2 66.82,59.07 66.82,58.63 66.94,58.51 69.62,58.51 70.62,57.51 CON1600.113
  IN1 w0.159: v2(67.53,59.2) 67.28,59.2 65.13,61.35 65.13,62.93 63.8,64.26 63.8,75.25 83.32,94.77 83.32,97.9 86.37,100.96 86.37,101.22 v3(86.78,101.63)
  BOTTOM w0.076: U0300.AU2 87.37,103.72 87.37,102.22 v3(86.78,101.63)
  BOTTOM w0.229: CON1601.113 68.63,63.93 67.02,62.33 67.02,59.71 v2(67.53,59.2)
M_CHA_CKE0: length 68.8
  TOP w0.184: CON1600.109 69.62,57.46 69.42,57.67 66.59,57.67 64.99,59.27 v2(63.81,59.27)
  IN1 w0.127: v2(63.81,59.27) 64.23,59.68 64.23,62.73 63.02,63.94 63.02,75.57 82.94,95.49 82.94,97.85 86.14,101.05 86.14,101.59 86.34,101.79 86.34,105.29 86.44,105.39 87.76,105.39 87.94,105.21 87.94,103.83 v3(88.84,102.93)
  BOTTOM w0.076: U0300.AT1 88.84,102.97 v3(88.84,102.93)
M_CHA_CKE1: length 66.8
  TOP w0.184: CON1600.110 69.87,63.78 69.07,62.97 67.84,62.97 67.15,62.28 v2(63.78,62.28)
  IN1 w0.127: v3(88.87,103.71) 88.17,104.42 88.17,105.29 87.85,105.61 86.35,105.61 85.81,105.06 85.81,102.79 85.68,102.66 85.29,102.66 85.14,102.51 85.14,102.26 85.25,102.14 85.7,102.14 85.81,102.03 85.81,101.15 82.61,97.95 82.61,95.77 62.59,75.75 62.59,63.47 v2(63.78,62.28)
  BOTTOM w0.076: v3(88.87,103.71) 88.74,103.71 U0300.AT2
M_CHA_CKE2: length 67.3
  IN1 w0.127: v3(88.89,104.37) 88.58,104.37 88.4,104.56 88.4,105.57 88.15,105.82 86.26,105.82 84.74,104.3 84.74,103.87 84.87,103.74 85.35,103.74 85.47,103.61 85.47,103.36 85.35,103.23 84.87,103.23 84.74,103.11 84.74,101.84 84.87,101.72 85.25,101.72 85.38,101.59 85.38,101.41 85.25,101.28 84.87,101.28 84.74,101.16 84.74,100.73 82.23,98.21 82.23,96 62.16,75.93 62.16,63.1 v2(63.81,61.45)
  BOTTOM w0.076: v3(88.89,104.37) 88.58,104.69 U0300.AT3
  BOTTOM w0.184: CON1601.109 67.63,63.91 67.12,63.41 65.77,63.41 v2(63.81,61.45)
M_CHA_CKE3: length 65.9
  IN1 w0.127: v2(63.81,60.79) 61.73,62.87 61.73,76.11 81.87,96.25 81.87,98.44 84.38,100.96 84.38,104.25 86.17,106.04 88.48,106.04 v3(88.85,105.67)
  BOTTOM w0.076: U0300.AT5 88.53,105.99 v3(88.85,105.67)
  BOTTOM w0.184: v2(63.81,60.79) 64.62,59.98 65.33,59.98 67.88,57.43 CON1601.110
M_CHA_CLK0: length 72.7
  TOP w0.108: v2(76.9,60.64) 76.11,59.84 76.11,59.35 75.78,59.02 75.78,58.06 76.15,57.69 76.31,57.69 76.62,57.38 CON1600.137
  IN1 w0.102: v2(91.87,96.31) 92.08,96.1 92.09,96.1 92.56,95.62 92.56,94.69 91.26,93.39 91.26,90.52 74.23,73.5 74.23,68.21 74.78,67.66 74.78,64.17 75.73,63.22 75.73,60.97 75.44,60.67 75.44,59.84 73.94,58.35 73.26,58.35 73.15,58.24 73.15,57.91 73.24,57.81 74.54,57.81 74.84,57.51 74.84,56.58 74.95,56.47 75.52,56.47 75.75,56.7 75.75,58.94 76.1,59.29 76.1,60.19 76.39,60.47 76.74,60.47 v2(76.9,60.64)
  BOTTOM w0.076: 95.69,100.01 95.69,100.02 95.74,100.06 95.74,100.08 95.74,100.08 95.74,102.49 96.31,103.07 96.31,103.53 96.19,103.65 96.06,103.65 95.97,103.56 U0300.AG1
  BOTTOM w0.108: 95.69,100.01 95.69,98.42 93.24,95.97 92.21,95.97 v2(91.87,96.31)
M_CHA_CLK0#: length 72.7
  TOP w0.108: v2(76.87,59.98) 76.55,59.98 76.33,59.75 76.33,59.26 76,58.93 76,58.16 76.24,57.92 76.4,57.92 76.69,57.63 76.87,57.63 77.12,57.38 CON1600.139
  IN1 w0.102: v2(91.86,95.62) 92.22,95.62 92.32,95.52 92.32,94.79 91.01,93.49 91.01,90.62 73.99,73.6 73.99,68.11 74.54,67.56 74.54,64.07 75.49,63.12 75.49,61.07 75.2,60.77 75.2,59.94 73.84,58.59 73.16,58.59 72.9,58.34 72.9,57.81 73.14,57.57 74.44,57.57 74.6,57.41 74.6,56.48 74.85,56.23 75.62,56.23 75.99,56.6 75.99,58.84 76.35,59.19 76.35,60.09 76.49,60.23 76.61,60.23 v2(76.87,59.98)
  BOTTOM w0.076: U0300.AG2 95.97,103.9 96.05,103.82 96.25,103.82 96.48,103.6 96.48,103 95.9,102.43 95.9,100.02 95.92,100.01
  BOTTOM w0.108: 95.92,100.01 95.92,98.33 93.33,95.75 91.99,95.75 v2(91.86,95.62)
M_CHA_CLK1: length 76.2
  TOP w0.108: CON1600.138 76.87,63.85 76.66,63.63 76.1,63.63 75.85,63.38 75.85,61.85 76.12,61.59 v2(76.89,61.59)
  IN1 w0.102: v2(91.88,97.62) 92.52,97.62 92.68,97.47 92.68,96.28 93.17,95.79 93.17,94.87 91.77,93.47 91.77,90.32 91.26,89.81 91.26,89.46 91.56,89.17 91.56,89.03 91.31,88.79 91.21,88.79 90.9,89.1 90.56,89.1 90.2,88.74 90.2,88.4 90.51,88.09 90.51,87.99 90.25,87.73 90.15,87.73 89.84,88.04 89.5,88.04 89.14,87.68 89.14,87.34 89.44,87.03 89.44,86.92 89.2,86.67 89.09,86.67 88.78,86.98 88.43,86.98 88.08,86.62 88.08,86.28 88.36,85.99 88.36,85.84 88.13,85.61 88.03,85.61 87.72,85.92 87.37,85.92 87.02,85.56 87.02,85.22 87.32,84.92 87.32,84.79 87.07,84.55 86.97,84.55 86.66,84.86 86.31,84.86 85.96,84.5 85.96,84.16 86.27,83.85 86.27,83.74 86.01,83.48 85.91,83.48 85.6,83.8 85.25,83.8 84.9,83.44 84.9,83.1 85.21,82.78 85.21,82.68 84.94,82.41 84.86,82.41 84.54,82.74 84.19,82.74 83.83,82.38 83.83,82.04 84.16,81.71 84.16,81.63 83.9,81.37 83.78,81.37 83.47,81.67 83.13,81.67 82.77,81.32 82.77,80.97 83.09,80.66 83.09,80.57 82.84,80.31 82.72,80.31 82.41,80.61 82.07,80.61 81.55,80.09 81.55,79.75 81.87,79.43 81.87,79.34 81.61,79.08 81.5,79.08 81.19,79.39 80.84,79.39 74.74,73.29 74.74,72.38 74.95,72.17 75.35,72.17 75.53,71.99 75.53,71.58 75.42,71.47 75,71.47 74.74,71.21 74.74,70.14 75.03,69.85 75.55,69.85 75.65,69.75 75.65,69.33 75.54,69.22 74.98,69.22 74.74,68.99 74.74,68.42 75.01,68.16 75.18,68.16 75.29,68.05 75.29,64.38 76.24,63.43 76.24,62.23 v2(76.89,61.59)
  BOTTOM w0.076: U0300.AK2 93.59,103.89 93.66,103.89 93.95,103.6 93.95,102.33 93.88,102.27
  BOTTOM w0.108: v2(91.88,97.62) 92.82,97.62 93.02,97.82 93.02,98.8 93.09,98.87 93.44,98.87 93.54,98.77 93.54,97.76 93.76,97.54 94.06,97.54 94.88,98.36 94.88,98.84 93.88,99.83 93.88,102.27
M_CHA_CLK1#: length 76.3
  TOP w0.108: CON1600.140 77.37,63.76 77.31,63.69 77.04,63.69 76.75,63.41 76.2,63.41 76.08,63.29 76.08,61.95 76.21,61.81 76.5,61.81 v2(76.89,62.2)
  IN1 w0.102: v2(91.89,98.24) 92.2,98.24 92.28,98.15 92.28,97.93 92.35,97.86 92.62,97.86 92.92,97.57 92.92,96.38 93.41,95.89 93.41,94.77 92.01,93.37 92.01,90.22 91.5,89.71 91.5,89.56 91.8,89.27 91.8,88.93 91.41,88.55 91.11,88.55 90.8,88.86 90.66,88.86 90.44,88.64 90.44,88.5 90.76,88.19 90.76,87.89 90.35,87.49 90.05,87.49 89.74,87.8 89.6,87.8 89.38,87.58 89.38,87.44 89.69,87.13 89.69,86.82 89.3,86.43 88.99,86.43 88.68,86.74 88.54,86.74 88.32,86.52 88.32,86.38 88.6,86.09 88.6,85.74 88.23,85.37 87.93,85.37 87.62,85.68 87.47,85.68 87.26,85.46 87.26,85.32 87.56,85.02 87.56,84.69 87.17,84.3 86.87,84.3 86.56,84.62 86.41,84.62 86.2,84.4 86.2,84.26 86.51,83.95 86.51,83.64 86.11,83.24 85.81,83.24 85.5,83.56 85.35,83.56 85.14,83.34 85.14,83.2 85.45,82.88 85.45,82.58 85.04,82.17 84.76,82.17 84.43,82.49 84.29,82.49 84.08,82.28 84.08,82.14 84.4,81.81 84.4,81.53 84,81.13 83.68,81.13 83.37,81.43 83.23,81.43 83.01,81.22 83.01,81.07 83.33,80.76 83.33,80.47 82.94,80.07 82.62,80.07 82.31,80.37 82.17,80.37 81.79,79.99 81.79,79.85 82.11,79.53 82.11,79.24 81.71,78.84 81.4,78.84 81.09,79.15 80.94,79.15 74.98,73.19 74.98,72.48 75.05,72.41 75.45,72.41 75.77,72.09 75.77,71.48 75.52,71.23 75.1,71.23 74.98,71.11 74.98,70.24 75.13,70.09 75.65,70.09 75.89,69.85 75.89,69.23 75.64,68.98 75.08,68.98 74.98,68.89 74.98,68.52 75.11,68.4 75.28,68.4 75.53,68.15 75.53,64.48 76.48,63.53 76.48,62.33 76.62,62.2 v2(76.89,62.2)
  BOTTOM w0.076: U0300.AK1 93.45,103.64 93.51,103.7 93.6,103.7 93.78,103.51 93.78,102.5 93.66,102.38
  BOTTOM w0.108: 93.66,102.38 93.66,99.74 94.65,98.75 94.65,98.45 93.97,97.77 93.85,97.77 93.76,97.86 93.76,98.86 93.53,99.09 93,99.09 92.8,98.9 92.8,97.91 92.73,97.85 92.33,97.85 92.25,97.92 92.25,98.18 92.19,98.24 v2(91.89,98.24)
M_CHA_CLK2: length 76.5
  IN1 w0.102: v3(91.86,101.42) 92.09,101.42 92.53,101.85 92.53,103.22 92.76,103.45 92.76,105.24 92.92,105.4 92.92,106.77 93.47,107.32 93.94,107.32 94.36,106.91 94.99,106.91 95.38,106.52 95.38,105.93 95.26,105.82 94.37,105.82 93.3,104.75 93.3,102.92 93.9,102.32 93.9,101.23 93.77,101.1 93.77,96.9 94.24,96.43 94.24,94.42 93.38,93.56 93.38,88.73 78.16,73.51 78.16,73.24 77.15,72.23 77.15,64.65 78.04,63.75 78.04,62.34 78.24,62.15 78.24,61.9 v2(78.75,61.38)
  BOTTOM w0.076: U0300.AL3 92.71,104.56 92.34,104.19 92.34,102.98 92.44,102.89 92.7,102.89 93,102.6 93,101 92.79,100.79 92.47,100.79 92.3,100.97 92.3,101.63 92.17,101.76 92.01,101.76 91.86,101.61 v3(91.86,101.42)
  BOTTOM w0.108: v2(78.75,61.38) 78.34,61.8 78.34,62.09 77.21,63.22 75.17,63.22 74.63,63.76 CON1601.137
M_CHA_CLK2#: length 76.6
  IN1 w0.102: v2(78.75,61.99) 78.53,61.99 78.48,62.05 78.48,62.25 78.29,62.44 78.29,63.85 77.39,64.75 77.39,72.13 78.4,73.14 78.4,73.41 93.62,88.63 93.62,93.46 94.48,94.32 94.48,96.53 94.01,97 94.01,101 94.14,101.13 94.14,102.42 93.54,103.02 93.54,104.65 94.47,105.58 95.36,105.58 95.62,105.83 95.62,106.62 95.09,107.15 94.46,107.15 94.04,107.56 93.37,107.56 92.68,106.87 92.68,105.5 92.52,105.34 92.52,103.55 92.28,103.32 92.28,101.95 92.14,101.81 91.95,101.81 91.86,101.9 v3(91.86,102.1)
  BOTTOM w0.076: U0300.AK3 93.31,104.69 92.98,105.01 92.59,105.01 92.37,104.79 92.37,104.45 92.18,104.26 92.18,102.91 92.37,102.72 92.64,102.72 92.83,102.53 92.83,101.07 92.72,100.96 92.54,100.96 92.46,101.04 92.46,101.7 92.24,101.92 92.04,101.92 v3(91.86,102.1)
  BOTTOM w0.108: v2(78.75,61.99) 77.31,63.44 75.26,63.44 75.13,63.57 CON1601.139
M_CHA_CLK3: length 75.2
  IN1 w0.102: v2(91.88,99.48) 92.26,99.86 92.26,100.21 92.59,100.54 92.59,101.3 93.16,101.88 93.35,101.88 93.42,101.81 93.42,101.38 93.21,101.18 93.21,99.33 93.14,99.26 92.67,99.26 92.39,98.98 92.39,98.45 92.62,98.22 93.18,98.22 93.31,98.08 93.31,96.63 93.73,96.22 93.73,94.69 92.61,93.58 92.61,89.03 81.55,77.97 81.41,77.97 81.14,78.24 80.79,78.24 80.43,77.88 80.43,77.54 80.71,77.26 80.71,77.12 80.49,76.91 80.35,76.91 80.07,77.18 79.73,77.18 79.37,76.82 79.37,76.48 79.64,76.2 79.64,76.06 79.43,75.84 79.29,75.84 79.01,76.12 78.67,76.12 78.31,75.76 78.31,75.41 78.58,75.14 78.58,75 78.28,74.7 78.09,74.7 77.89,74.89 77.49,74.89 77.08,74.48 77.08,74.15 77.22,74 77.22,73.86 76.86,73.5 76.71,73.5 76.5,73.7 76.22,73.7 75.79,73.28 75.79,72.86 76.4,72.26 76.4,71.3 76.04,70.94 76.04,70.42 76.4,70.06 76.4,68.93 76.04,68.57 76.04,66.19 76.4,65.83 76.4,65.58 76.04,65.22 76.04,64.69 77.3,63.44 77.3,62.01 77.49,61.82 77.49,59.9 77.88,59.51 78.48,59.51 78.68,59.31 78.68,58.74 78.51,58.57 78.25,58.57 77.82,59 77.26,59 77.2,59.06 77.2,59.32 77.15,59.37 v2(76.84,59.37)
  BOTTOM w0.076: U0300.AL2 92.71,103.83 93.13,103.42 93.13,103.01 93.41,102.73 93.41,99.99 93.11,99.68 93.11,99.63
  BOTTOM w0.108: CON1601.138 74.88,58.57 75.15,58.85 75.61,58.85 76.13,59.37 v2(76.84,59.37) ; v2(91.88,99.48) 92.96,99.48 93.11,99.63
M_CHA_CLK3#: length 75.2
  IN1 w0.102: v3(91.88,100.17) 92.35,100.64 92.35,101.4 93.06,102.12 93.45,102.12 93.66,101.91 93.66,101.28 93.45,101.08 93.45,99.23 93.24,99.02 92.77,99.02 92.63,98.88 92.63,98.55 92.72,98.46 93.28,98.46 93.55,98.18 93.55,96.73 93.97,96.32 93.97,94.59 92.86,93.48 92.86,88.93 81.65,77.72 81.31,77.72 81.04,78 80.89,78 80.68,77.78 80.68,77.64 80.95,77.36 80.95,77.02 80.59,76.66 80.25,76.66 79.97,76.94 79.83,76.94 79.61,76.72 79.61,76.58 79.89,76.3 79.89,75.96 79.53,75.6 79.19,75.6 78.91,75.87 78.77,75.87 78.55,75.66 78.55,75.51 78.83,75.24 78.83,74.9 78.38,74.45 77.99,74.45 77.79,74.65 77.59,74.65 77.32,74.38 77.32,74.25 77.46,74.1 77.46,73.76 76.96,73.26 76.61,73.26 76.4,73.46 76.32,73.46 76.03,73.18 76.03,72.96 76.64,72.36 76.64,71.2 76.28,70.84 76.28,70.52 76.64,70.16 76.64,68.83 76.28,68.47 76.28,66.29 76.64,65.93 76.64,65.48 76.28,65.12 76.28,64.79 77.54,63.54 77.54,62.11 77.73,61.92 77.73,60 77.98,59.75 78.58,59.75 78.92,59.41 78.92,58.64 78.61,58.33 78.15,58.33 77.72,58.76 v2(76.84,58.76)
  BOTTOM w0.076: U0300.AL1 92.87,103.39 92.97,103.28 92.97,102.94 93.25,102.66 93.25,100.06 92.97,99.78 92.95,99.78
  BOTTOM w0.108: 92.95,99.78 92.87,99.7 92.38,99.7 92.31,99.78 92.31,100.36 92.18,100.49 92.01,100.49 91.88,100.36 v3(91.88,100.17) ; v2(76.84,58.76) 76.45,59.14 76.22,59.14 75.7,58.63 75.25,58.63 75.1,58.48 75.1,57.81 75.24,57.67 75.32,57.67 75.38,57.61 CON1601.140
M_CHA_CS#0: length 72.7
  TOP w0.184: v2(80.8,57.94) 81.34,57.94 81.62,57.66 CON1600.149
  IN1 w0.076: v3(98.9,105.65) 98.25,105.01 98.25,103.92 97.89,103.56 97.89,100.43 97.97,100.34 97.97,100.06 98.41,99.63
  IN1 w0.127: 98.41,99.63 99.58,98.46 99.85,98.46 102.46,95.85 102.46,92.12 101.42,91.08 101.42,84.18 89.69,72.46 89.69,71.93 86.49,68.73 86.49,66.06 86.04,65.61 86.04,61.39 86.38,61.05 86.38,59.68 87.25,58.81 87.25,58.61 88.32,57.53 88.32,56.31 87.78,55.76 85.5,55.76 85.37,55.63 83.95,55.63 83.51,56.08 83.51,58.29 83.26,58.54 82.79,58.54 82.18,57.93 80.82,57.93 v2(80.8,57.94)
  BOTTOM w0.076: U0300.AD5 98.64,105.82 98.73,105.82 v3(98.9,105.65)
M_CHA_CS#1: length 75.8
  TOP w0.184: v2(83.06,59.16) 83.48,59.58 84.54,59.58 84.83,59.28 84.83,58.84 84.57,58.57 84.01,58.57 83.62,58.19 CON1600.157
  IN1 w0.076: 97.23,99.69 97.23,99.76 96.83,100.16 v3(96.83,100.28)
  IN1 w0.127: v2(83.06,59.16) 83.51,59.16 83.65,59.3 83.65,60.21 84.27,60.83 84.27,69.55 99.69,84.97 99.69,91.44 100.06,91.81 100.06,92 99.89,92.16 98.81,92.16 98.72,92.25 98.72,92.59 98.81,92.68 100.68,92.68 101.15,93.15 101.15,93.52 100.92,93.75 100.72,93.75 100.19,93.22 98.85,93.22 98.74,93.32 98.72,93.32 98.72,93.69 98.84,93.8 100.06,93.8 101.16,94.9 101.16,95.09 100.95,95.3 100.71,95.3 99.74,94.33 98.86,94.33 98.72,94.46 98.72,94.75 98.84,94.86 99.47,94.86 100.43,95.82 100.43,96.02 100.21,96.24 100,96.24 99.08,95.33 98.88,95.33 98.72,95.48 98.72,95.82 99.59,96.68 99.59,96.97 97.23,99.32 97.23,99.69
  BOTTOM w0.076: 97.09,100.28 98.43,101.63 98.43,102.88 98.13,103.19 98.13,103.25 98.11,103.27 98.11,103.67 U0300.AE2
  BOTTOM w0.089: 97.09,100.28 v3(96.83,100.28)
M_CHA_CS#2: length 78.9
  IN1 w0.127: v2(83.25,60.65) 83.49,60.65 83.84,61.01 83.84,69.73 99.26,85.15 99.26,91.63 99.17,91.73 98.51,91.73 98.35,91.89 98.35,96.08 99.13,96.86 99.13,97 98.88,97.25 98.74,97.25 98.33,96.83 98.15,96.83 97.87,97.11 97.87,97.23 98.36,97.71 98.36,97.84 98.16,98.04 98.03,98.04 97.56,97.57 97.46,97.57 97.24,97.79 97.24,97.97 97.69,98.42 97.69,98.56 97.5,98.75 97.33,98.75 v2(96.84,98.25)
  BOTTOM w0.076: U0300.AD2 98.83,103.69 98.83,100.42 98.84,100.41
  BOTTOM w0.089: 98.84,100.41 98.94,100.31
  BOTTOM w0.178: 98.94,100.31 98.94,99.63
  BOTTOM w0.184: CON1601.149 79.63,63.81 80.07,63.36 80.07,61.35 80.27,61.14 82.76,61.14 v2(83.25,60.65) ; v2(96.84,98.25) 96.65,98.07 96.65,96.15 96.85,95.96 98.79,95.96 98.94,96.1 98.94,97.24 99.12,97.42 103.34,97.42 103.52,97.61 103.52,97.98 103.34,98.16 99.12,98.16 98.94,98.34 98.94,99.63
M_CHA_CS#3: length 77.4
  IN1 w0.127: v3(98.93,106.31) 98.93,106.6 99.03,106.7 100.12,106.7 100.26,106.56 100.26,106.2 100.44,106.03 100.87,106.03 101.05,106.2 101.05,106.58 101.17,106.7 101.73,106.7 101.86,106.84 101.86,107.07 101.7,107.23 101.7,107.45 101.59,107.55 101.39,107.55 101.3,107.46 101.3,107.34 101.19,107.23 99.82,107.23 99.58,107.46 99.58,108.43 99.44,108.57 98.8,108.57 98.68,108.45 98.68,107.27 98.58,107.17 97.84,107.17 97.75,107.08 97.75,106.64 97.68,106.56 96.99,106.56 96.91,106.48 96.91,106.13 97.03,106 97.83,106 97.96,105.87 97.96,105.16 97.83,105.03 97.45,105.03 97.33,104.9 97.33,104.65 97.45,104.52 97.83,104.52 97.96,104.39 97.96,103.96 97.77,103.77 97.14,103.77 97.01,103.64 97.01,103.39 97.14,103.26 97.54,103.26 97.61,103.19 97.61,100.29 97.78,100.12 97.78,99.95 102.05,95.68 102.05,92.37 100.99,91.3 100.99,84.36 89.26,72.64 89.26,72.11 86.06,68.91 86.06,66.24 85.57,65.75 v2(85.57,61.2)
  BOTTOM w0.076: U0300.AE5 97.91,105.99 98.23,106.31 98.93,106.31 v3(98.93,106.31)
  BOTTOM w0.184: CON1601.157 81.63,63.83 84.26,61.2 v2(85.57,61.2)
M_CHA_DQ0: length 79.6
  TOP w0.165: CON1600.8 44.37,63.96 42.33,61.91 v2(40.83,61.91)
  IN1 w0.114: v2(40.83,61.91) 39.86,61.91 39.18,62.59 39.18,70.23 39.29,70.34 39.48,70.34 39.59,70.46 39.59,70.69 39.48,70.8 39.29,70.8 39.18,70.91 39.18,71.14 39.29,71.26 39.48,71.26 39.59,71.37 39.59,71.6 39.48,71.71 39.29,71.71 39.18,71.83 39.18,72.06 39.29,72.17 39.48,72.17 39.59,72.29 39.59,72.51 39.48,72.63 39.29,72.63 39.18,72.74 39.18,72.97 39.29,73.09 39.48,73.09 39.59,73.2 39.59,73.43 39.48,73.54 39.29,73.54 39.18,73.66 39.18,73.89 39.29,74 39.48,74 39.59,74.11 39.59,74.34 39.48,74.46 39.29,74.46 39.18,74.57 39.18,74.8 39.29,74.91 39.48,74.91 39.59,75.03 39.59,75.26 39.48,75.37 39.29,75.37 39.18,75.49 39.18,75.71 39.29,75.83 39.48,75.83 39.59,75.94 39.59,76.17 39.48,76.29 39.29,76.29 39.18,76.4 39.18,76.83 65.22,102.87 65.22,103.91 67.35,106.04 70.73,106.04 71.33,106.64 73,106.64 v3(73.11,106.53)
  BOTTOM w0.076: v3(73.11,106.53) 73.23,106.65 73.93,106.65 74.07,106.51 74.6,106.51 74.67,106.58 U0300.BR6
  BOTTOM w0.165: v2(40.83,61.91) 42.13,61.91 42.25,62.03 42.25,62.27 42.14,62.39 41.69,62.39 41.53,62.55 41.53,62.83 41.66,62.97 42,62.97 42.13,63.1 CON1601.7
M_CHA_DQ1: length 77.7
  TOP w0.165: CON1600.7 44.12,57.49 43.39,58.22 v2(42.14,58.22)
  IN1 w0.114: v3(71.06,104.41) 70.82,104.64 68.56,104.64 40.62,76.7 40.62,69.24 41.67,68.19 41.67,67.72 41.55,67.6 40.84,67.6 40.72,67.49 40.72,67.26 40.84,67.15 41.55,67.15 41.67,67.03 41.67,66.8 41.55,66.69 40.84,66.69 40.72,66.58 40.72,66.35 40.84,66.23 41.55,66.23 41.67,66.12 41.67,62.69 43.05,61.31 43.05,59.99 42.31,59.25 41.85,59.25 41.61,59 41.61,58.56 41.94,58.22 v2(42.14,58.22)
  BOTTOM w0.076: U0300.BT6 74.29,107.07 72.9,107.07 71.86,106.04 71.86,105.79 71.74,105.66 71.74,105.44 71.96,105.21 71.96,104.78 71.59,104.41 v3(71.06,104.41)
  BOTTOM w0.165: v2(42.14,58.22) 41.99,58.38 41.59,58.38 41.5,58.3 41.5,58.01 41.8,57.72 42.26,57.72 42.38,57.6 CON1601.8
M_CHA_DQ2: length 76.8
  TOP w0.165: v2(45.7,58.16) 45.92,58.38 46.08,58.38 46.62,57.84 CON1600.17
  IN1 w0.114: v3(73.26,104.02) 73.26,103.47 72.07,102.27 69.46,102.27 44.86,77.67 44.86,63.1 45.13,62.84 45.13,59.56 45.35,59.34 45.75,59.34 46.18,58.92 46.18,55.57 45.42,54.81 44.63,54.81 44.11,55.33 44.11,56.57 v2(45.7,58.16)
  BOTTOM w0.076: v3(73.26,104.02) 73.26,104.47 73.59,104.79 73.75,104.79 74.01,105.05 74.86,105.05 74.9,105.09 75.46,105.09 U0300.BP3
  BOTTOM w0.165: v2(45.7,58.16) 45.08,58.16 44.38,57.46 CON1601.16
M_CHA_DQ3: length 79.1
  TOP w0.165: v2(44.33,61.91) 45.43,61.91 47.37,63.85 CON1600.20
  IN1 w0.114: v3(72.76,103.55) 72.74,103.53 69.26,103.53 42.95,77.22 42.95,76.44 43.22,76.18 43.73,76.18 43.83,76.08 43.83,75.74 43.72,75.62 43.41,75.62 42.95,75.16 42.95,74.39 42.86,74.3 42.01,74.3 41.9,74.19 41.9,73.96 42.02,73.84 42.82,73.84 42.95,73.7 42.95,73.48 42.84,73.36 42.02,73.36 41.9,73.25 41.9,73.02 42.02,72.9 42.84,72.9 42.95,72.79 42.95,72.56 42.84,72.45 42,72.45 41.9,72.35 41.9,72.13 42.04,71.99 42.84,71.99 42.95,71.88 42.95,70.48 43.08,70.35 43.71,70.35 43.82,70.24 43.82,69.09 43.64,68.91 43.06,68.91 42.95,68.8 42.95,67.67 43.09,67.53 43.69,67.53 43.82,67.4 43.82,66.11 43.69,65.97 43.08,65.97 42.95,65.85 42.95,63.25 43.07,63.13 43.28,63.13 43.36,63.21 43.56,63.21 43.68,63.09 43.68,62.83 43.59,62.74 43.59,62.64 v2(44.33,61.91)
  BOTTOM w0.076: U0300.BR3 74.86,104.6 74.81,104.6 74.52,104.3 74.14,104.3 73.39,103.55 v3(72.76,103.55)
  BOTTOM w0.165: v2(44.33,61.91) 44.71,61.53 45.19,61.53 45.39,61.73 45.39,62.56 45.63,62.79 45.83,62.79 45.95,62.91 45.95,63.37 45.63,63.7 CON1601.21
M_CHA_DQ4: length 77.9
  TOP w0.165: CON1600.3 43.12,57.47 42.83,57.77 41.31,57.77 v2(40.93,58.15)
  IN1 w0.114: v3(71.43,104.83) 71.28,104.99 68.42,104.99 40.28,76.84 40.28,66.31 41.33,65.26 41.33,62.55 42.71,61.16 42.71,60.14 42.16,59.59 41.17,59.59 40.93,59.34 v2(40.93,58.15)
  BOTTOM w0.076: v3(71.43,104.83) 71.43,106.03 71.86,106.46 72.05,106.46 72.83,107.24 74.05,107.24 74.13,107.33 74.5,107.33 74.74,107.08 75.77,107.08 76.04,106.81 76.04,106.31 U0300.BN5
  BOTTOM w0.165: v2(40.93,58.15) 40.93,58.38 40.82,58.48 40.56,58.48 40.43,58.35 40.43,57.91 40.63,57.71 41.25,57.71 41.38,57.58 CON1601.4
M_CHA_DQ5: length 79.1
  TOP w0.165: v2(39.93,63.08) 40.22,63.36 42.92,63.36 43.38,63.82 43.38,64.8 CON1600.4
  IN1 w0.114: v2(39.93,63.08) 39.52,63.49 39.52,63.71 39.63,63.82 40.87,63.82 40.98,63.94 40.98,64.17 40.87,64.28 39.63,64.28 39.52,64.4 39.52,64.69 39.61,64.78 40.49,64.78 40.56,64.85 40.56,65.14 40.44,65.25 39.67,65.25 39.52,65.41 39.52,65.79 39.63,65.9 39.72,65.9 39.84,66.01 39.84,66.24 39.72,66.36 39.63,66.36 39.52,66.47 39.52,66.81 39.63,66.93 39.82,66.93 39.93,67.04 39.93,67.27 39.82,67.39 39.63,67.39 39.52,67.5 39.52,67.73 39.63,67.84 39.82,67.84 39.93,67.96 39.93,68.19 39.82,68.3 39.63,68.3 39.52,68.41 39.52,68.64 39.63,68.76 39.82,68.76 39.93,68.87 39.93,69.1 39.82,69.21 39.63,69.21 39.52,69.33 39.52,69.56 39.63,69.67 39.82,69.67 39.93,69.79 39.93,76.98 68.64,105.7 71.61,105.7 71.99,106.08 v3(72.66,106.08)
  BOTTOM w0.076: U0300.BP6 75.4,106.68 75.18,106.9 74.75,106.9 74.53,106.67 74.14,106.67 73.91,106.91 72.97,106.91 72.66,106.6 v3(72.66,106.08)
  BOTTOM w0.165: v2(39.93,63.08) 39.59,63.42 39.2,63.42 39.13,63.5 39.13,64.08 39.25,64.2 39.8,64.2 40.27,63.74 40.88,63.74 41.13,63.98 CON1601.3
M_CHA_DQ6: length 77.5
  TOP w0.165: v2(45.7,58.8) 46.22,58.8 46.67,58.35 46.78,58.35 47.62,57.5 CON1600.21
  IN1 w0.114: v3(71.93,102.69) 69.4,102.69 44.52,77.81 44.52,73.22 44.02,72.73 44.02,72.38 44.52,71.88 44.52,62.96 44.79,62.69 44.79,58.58 42.33,56.13 42.33,56 42.5,55.84 42.74,55.84 v2(45.7,58.8)
  BOTTOM w0.076: U0300.BP2 75.33,103.81 75.33,103.17 74.57,102.42 72.2,102.42 v3(71.93,102.69)
  BOTTOM w0.165: v2(45.7,58.8) 46.08,58.8 46.29,58.59 46.29,57.89 46.09,57.69 45.53,57.69 45.38,57.54 CON1601.20
M_CHA_DQ7: length 78
  TOP w0.165: v2(44.33,62.57) 45.45,62.57 46.37,63.49 CON1600.16
  IN1 w0.114: v2(44.33,62.57) 44.18,62.72 44.18,63.86 44.06,63.97 43.43,63.97 43.3,64.11 43.3,64.34 43.39,64.43 44.06,64.43 44.18,64.54 44.18,64.95 44.06,65.06 43.44,65.06 43.33,65.17 43.33,65.4 43.44,65.52 44.06,65.52 44.18,65.63 44.18,67.88 44.06,68 43.43,68 43.32,68.11 43.32,68.34 43.43,68.45 44.06,68.45 44.18,68.57 44.18,70.77 44.08,70.86 43.43,70.86 43.31,70.98 43.31,71.21 43.43,71.32 44.11,71.32 44.18,71.38 44.18,71.74 43.99,71.93 43.46,71.93 43.29,72.1 43.29,73.14 43.45,73.3 44.06,73.3 44.18,73.41 44.18,73.71 44.06,73.82 43.41,73.82 43.29,73.94 43.29,74.17 43.41,74.28 44.06,74.28 44.18,74.4 44.18,74.7 44.09,74.78 43.52,74.78 43.4,74.9 43.4,75.12 43.52,75.24 44.06,75.24 44.18,75.36 44.18,76.5 44.04,76.64 43.41,76.64 43.29,76.75 43.29,76.98 43.41,77.09 44.08,77.09 44.18,77.19 44.18,77.96 69.36,103.14 v3(72.35,103.14)
  BOTTOM w0.076: v3(72.35,103.14) 72.9,103.14 73.03,103.26 73.42,103.26 73.66,103.03 74.11,103.03 74.73,103.65 74.73,103.8 74.73,103.86 74.73,104.21 74.75,104.24 74.94,104.43 75.31,104.43 75.41,104.53 76.16,104.53 U0300.BN3
  BOTTOM w0.165: v2(44.33,62.57) 44.53,62.37 44.79,62.37 44.98,62.55 44.98,62.83 44.69,63.12 44.49,63.12 44.35,63.26 44.35,63.49 44.63,63.76 CON1601.17
M_CHA_DQ8: length 74.7
  TOP w0.165: v2(46.62,61.96) 48.37,63.72 CON1600.24
  IN1 w0.114: v3(78.02,105.66) 77.35,104.99 76.22,104.99 73.54,102.31 72.89,102.31 72.19,101.61 70.34,101.61 46.39,77.65 46.39,77.37 46.71,77.04 46.71,74.37 46.6,74.25 46.07,74.25 45.95,74.14 45.95,73.91 46.07,73.79 46.6,73.79 46.71,73.68 46.71,73.48 46.6,73.36 46.07,73.36 45.95,73.25 45.95,73.02 46.07,72.91 46.6,72.91 46.71,72.79 46.71,72.56 46.6,72.45 46.07,72.45 45.95,72.34 45.95,72.11 46.07,71.99 46.6,71.99 46.71,71.88 46.71,71.65 46.6,71.54 46.07,71.54 45.95,71.42 45.95,71.19 46.07,71.08 46.6,71.08 46.71,70.96 46.71,70.74 46.6,70.62 46.07,70.62 45.95,70.51 45.95,70.28 46.07,70.16 46.55,70.16 46.66,70.05 46.66,69.82 46.55,69.71 46.07,69.71 45.95,69.59 45.95,68.56 46.13,68.39 46.59,68.39 46.71,68.27 46.71,66.22 46.03,65.53 46.03,64.1 46.62,63.51 v2(46.62,61.96)
  BOTTOM w0.076: v3(78.02,105.66) 77.95,105.66 U0300.BL4
  BOTTOM w0.165: CON1601.25 46.63,63.8 47.23,63.19 47.23,62.07 47.12,61.96 v2(46.62,61.96)
M_CHA_DQ9: length 75.9
  TOP w0.165: CON1600.28 49.37,63.98 49.14,63.74 48.95,63.74 47.11,61.9 47.11,61.77 v2(46.64,61.3)
  IN1 w0.114: v2(46.64,61.3) 46.51,61.17 46.11,61.17 45.88,61.4 45.88,63.77 45.61,64.03 45.61,65.83 46.37,66.59 46.37,67.67 45.61,68.42 45.61,74.59 45.72,74.7 46.25,74.7 46.37,74.81 46.37,75.04 46.25,75.16 45.74,75.16 45.61,75.28 45.61,75.51 45.72,75.61 46.25,75.61 46.37,75.73 46.37,75.96 46.25,76.07 45.74,76.07 45.61,76.19 45.61,76.46 45.69,76.53 46.3,76.53 46.37,76.6 46.37,76.9 46.29,76.98 45.74,76.98 45.61,77.11 45.61,77.36 70.11,101.86 72.04,101.86 72.69,102.51 73.45,102.51 77.26,106.32 v3(78.01,106.32)
  BOTTOM w0.076: v3(78.01,106.32) 77.96,106.32 U0300.BL5
  BOTTOM w0.165: CON1601.29 47.62,63.35 47.76,63.22 47.76,61.24 47.6,61.08 46.86,61.08 v2(46.64,61.3)
