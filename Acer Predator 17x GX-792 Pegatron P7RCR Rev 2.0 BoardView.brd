# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BVREF_CA_RC: length 2
  TOP w0.305: R0511.1 C0502.2 v1(63.15,101.91)
C_CC1: length 49.2
  TOP w0.102: U1201.L9 296.79,59.7 297.03,59.94 297.28,59.94 297.3,59.96 ; v2(303.23,56.6) 303.95,56.6 304.28,56.93 305.21,56.93 v1(305.44,57.16)
  TOP w0.254: 297.3,59.96 300.2,59.96 301.44,58.72 301.83,58.72 302.01,58.54 302.01,57.82 C1223.1 v2(303.23,56.6)
  TOP w0.279: CON1201.A5 315.13,32.3 v2(314.86,32.04)
  IN2 w0.508: v2(310.19,31.91) 310.94,31.16 313.99,31.16 v2(314.86,32.04)
  IN4 w0.508: v2(310.19,31.91) 309.14,32.96 309.14,38.72 306.4,41.46 306.4,52.2 303.23,55.37 v2(303.23,56.6)
  BOTTOM w0.102: U1208.1 U1208.10 309.77,32.33 v2(310.19,31.91)
C_CC2: length 54.8
  TOP w0.102: v1(309.1,38.01) 309.91,37.19 309.96,37.19 v2(310.28,36.88) ; 297.08,60.56 296.71,60.2 U1201.L10
  TOP w0.254: 297.08,60.56 300.56,60.56 v2(301.33,59.8) 301.71,59.42 C1224.1
  IN2 w0.254: 319.9,38.37 320.33,38.37 321.24,37.47 321.24,34.59 320.49,33.85 CON1201.B5
  IN2 w0.508: 319.9,38.37 311.01,38.37 310.28,37.64 v2(310.28,36.88)
  IN4 w0.508: v2(310.28,36.88) 309.77,37.39 309.77,39 307.01,41.75 307.01,52.81 306.3,53.52 306.3,55.96 304.88,57.38 304.88,58.63 304.18,59.33 304.18,59.71 303.66,60.23 301.76,60.23 v2(301.33,59.8)
  BOTTOM w0.102: U1207.10 U1207.1 309.7,37.46 v2(310.28,36.88)
C_USB_BN: length 25.3
  TOP w0.076: U1201.L7 296.55,58.76 296.74,58.76 296.79,58.71
  TOP w0.121: v2(299.95,58.22) 299.46,58.71 296.79,58.71
  BOTTOM w0.121: 306.25,46.41 306.25,55.87 304.28,57.84 301.72,57.84 300.93,58.62 300.38,58.62 300.31,58.55 300.31,58.3 300.23,58.22 v2(299.95,58.22) ; 306.25,46.41 v1(306.03,46.41) ; 306.25,46.41 306.25,45.99 307.18,45.05 307.18,43.86 307.07,43.75 306.74,43.75 306.62,43.63 RN1201.4
C_USB_BN_CON: length 20.7
  BOTTOM w0.121: RN1201.3 306.62,40.72 305.64,39.74 305.64,36.64 306.56,35.72 308,35.72 308.27,35.46 U1207.6 U1207.5 309.85,35.46 arc(309.92,35.44) 309.99,35.4 311.93,35.4 arc(312.19,35.35) 312.41,35.2 314.43,33.18 arc(314.79,32.94) 315.2,32.86 318.83,32.86 arc(319.18,32.81) CON1201.B7
C_USB_BP: length 25.4
  TOP w0.076: U1201.K7 296.24,58.95 296.84,58.95
  TOP w0.121: v2(299.95,58.86) 299.65,58.86 299.56,58.95 296.84,58.95
  BOTTOM w0.121: RN1201.2 307.42,44.43 ; 307.42,44.43 v1(307.64,44.43) ; 307.42,44.43 307.42,45.15 306.48,46.08 306.48,55.96 304.37,58.07 301.82,58.07 301.03,58.86 v2(299.95,58.86)
C_USB_BP_CON: length 21
  BOTTOM w0.121: 305.87,37.55 305.87,36.74 306.65,35.96 U1207.7 U1207.4 309.57,35.96 arc(309.86,35.9) 310.1,35.74 arc(310.21,35.66) 310.35,35.63 311.93,35.63 arc(312.28,35.56) 312.58,35.36 314.6,33.34 arc(314.88,33.16) 315.2,33.09 319,33.09 arc(319.28,33.18) 319.47,33.4 CON1201.B6 ; 305.87,37.55 v1(306.09,37.55) ; 305.87,37.55 305.87,39.64 306.92,40.69 307.21,40.69 307.42,40.9 RN1201.1
C_USB_TN: length 26.7
  TOP w0.121: v2(299.32,57.59) 299,57.27 298.83,57.27 297.9,58.2 U1201.L6
  BOTTOM w0.121: 305.33,49.84 305.33,44.67 305.94,44.06 305.94,41.04 304.6,39.7 304.6,39.11 RN1202.2 ; 305.33,49.84 v1(305.55,49.84) ; 305.33,49.84 305.33,52.26 302.72,54.87 301.66,54.87 300.96,55.57 300.96,56.55 300.18,57.34 299.57,57.34 v2(299.32,57.59)
C_USB_TN_CON: length 16.8
  TOP w0.121: v2(313.42,33.38) 313.46,33.36 arc(313.78,33.23) 314.13,33.18 317.59,33.18 317.71,33.3 CON1201.A7
  BOTTOM w0.121: RN1202.1 304.85,37.04 304.4,36.58 304.4,36.36 306.69,34.07 307.95,34.07 308.21,34.33 U1208.5 U1208.6 309.88,34.33 310.34,33.86 312.05,33.86 312.8,33.11 313.14,33.11 v2(313.42,33.38)
C_USB_TN_CON_CHG: length 10.9
  TOP w0.121: v1(294.36,70.87) 294.14,70.87 ; 294.14,70.87 294.14,71.33 294.19,71.38 294.75,71.38 294.8,71.43 294.8,71.58 294.49,71.89 U1202.11 ; 294.14,70.87 294.14,70.49 296.02,68.61 296.93,68.61 297.64,67.9 299.17,67.9 299.54,68.28 299.54,68.85 R1221.2
C_USB_TP: length 26.8
  TOP w0.076: U1201.K6 296.23,57.95 296.79,57.95
  TOP w0.121: v2(299.32,56.95) 299.24,57.03 298.74,57.03 297.8,57.96 296.8,57.96 296.79,57.95
  BOTTOM w0.121: v2(299.32,56.95) 299.47,57.1 300.08,57.1 300.73,56.46 300.73,55.48 301.57,54.64 302.63,54.64 305.1,52.16 305.1,47.76 ; RN1202.4 304.37,39.17 304.37,39.8 305.7,41.13 305.7,43.97 305.1,44.57 305.1,47.76 ; v1(304.88,47.76) 305.1,47.76
C_USB_TP_CON: length 16.8
  TOP w0.121: v2(313.42,32.75) 313.53,32.81 arc(313.78,32.91) 314.05,32.95 314.13,32.95 314.18,32.95 arc(314.19,32.95) 314.19,32.95 317.63,32.95 317.78,32.8 CON1201.A6
  BOTTOM w0.121: RN1202.3 304.05,36.85 304.16,36.74 304.16,36.26 306.59,33.83 U1208.4 U1208.7 310,33.83 310.2,33.63 311.95,33.63 312.7,32.87 313.29,32.87 v2(313.42,32.75)
C_USB_TP_CON_CHG: length 11
  TOP w0.121: 299.78,68.59 299.78,68.92 R1217.2 ; 299.78,68.59 299.78,68.18 299.26,67.67 297.55,67.67 296.83,68.38 295.92,68.38 293.91,70.39 293.91,71.43 293.99,71.51 U1202.10 ; 299.78,68.59 v1(300,68.59)
CA_DET: length 46.6
  TOP w0.102: v2(284.77,107.14) 284.28,107.63 284.16,107.63 v1(283.65,108.13) 283.65,109.63 283.24,110.04 R4609.1 283.24,114.88 283.47,115.11 284.78,115.11 285.1,115.42 Q7206.2
  IN2 w0.102: v2(284.77,107.14) 284.82,107.09 292.39,107.09 292.84,106.64 297.72,106.64 299.32,108.24 299.32,108.95 306.97,116.59 306.97,117.2 309.76,119.99 309.76,121.67 CON4601.13
CATERR#: length 1.2
  TOP w0.102: T0745.1 76.95,125.18 76.94,125.19 v3(76.67,125.19)
  BOTTOM w0.102: U0300.BM30 76.67,125.12 v3(76.67,125.19)
CFG_RCOMP: length 6.3
  BOTTOM w0.254: U0300.BT25 70.9,120.86 v1(69.86,121.9) 69.4,121.44 R0742.1
CGH_SRN: length 8.5
  TOP w0.203: SR8805.2 281.16,27.29 280.52,26.65 278.31,26.65 276.87,28.1 v1(276.87,28.33) 276.57,28.63 U8800.19
CGH_SRP: length 8.3
  TOP w0.203: SR8804.2 281.29,28.56 v1(280.85,28.12) 279.74,27.01 278.39,27.01 277.4,28 277.4,28.53 276.97,28.96 U8800.20
CHA_DIMM0_EVENT#: length 54.7
  TOP w0.102: CON1600.134 75.87,67.21 76.29,67.63 v2(76.74,67.63) ; v1(117.94,73.31) v2(117.94,71.42)
  IN3 w0.102: v2(117.94,71.42) 112.96,76.4 85.51,76.4 v2(76.74,67.63)
  BOTTOM w0.102: v2(76.74,67.63) 76.7,67.63 C1619.1 R1600.2
CHA_DIMM1_EVENT#: length 68.4
  TOP w0.102: v2(118.55,71.65) 118.56,71.66 v1(118.56,75.17)
  IN3 w0.102: v2(118.55,71.65) 113.59,76.6 80.79,76.6 v2(76.99,72.8) 77.4,72.4 77.4,69.63 75.87,68.1 75.87,59.69 v2(75.7,59.52)
  BOTTOM w0.102: v2(76.99,72.8) 76.99,72.6 C1620.1 R1601.2 ; v2(75.7,59.52) 75.44,59.52 73.88,57.95 CON1601.134
CHB_DIMM0_EVENT#: length 63.7
  TOP w0.102: v2(79.79,42.76) 79.77,42.74 74.4,42.74 v2(74.15,42.98) ; v2(117.91,52.46) 118.17,52.71 v1(118.17,53.32)
  IN3 w0.102: v2(74.15,42.98) 74.15,43.29 75.09,44.23 75.09,50.15 74.5,50.73 74.5,52.15 75.04,52.69 106.86,52.69 107.47,52.08 115.63,52.08 116.01,52.46 v2(117.91,52.46)
  BOTTOM w0.102: v2(74.15,42.98) 74.15,43.19 73.88,43.46 CON1701.134 ; R1700.2 C1718.1 79.69,42.65 v2(79.79,42.76)
CHB_DIMM1_EVENT#: length 60.5
  TOP w0.102: v1(118.4,47.99) v2(115.55,47.99) ; CON1700.134 75.87,51.9 76.71,51.06 76.71,50.14 76.48,49.9 75.74,49.9 75.29,49.45 75.29,47.99 v2(75.88,47.4)
  IN3 w0.102: v2(75.88,47.4) 80.16,47.4 80.47,47.09 80.47,45.8 80.87,45.4 87.83,45.4 88.65,46.22 88.65,51.72 89.01,52.08 106.44,52.08 108.37,50.15 110.5,50.15 111.33,49.31 113.72,49.31 115.04,47.99 v2(115.55,47.99)
  BOTTOM w0.102: C1719.1 R1701.2 115.22,47.66 v2(115.55,47.99)
CHG_ACN: length 364.2
  TOP w0.203: U8800.1 277.37,34.58 277.57,34.78 278.64,34.78 278.64,34.79 279.39,35.54 279.41,35.54 279.41,37.32 279.59,37.5 C8809.2 279.94,38.13 C8807.2 v2(279.73,38.97)
  TOP w0.229: v2(19.3,76.93) 19.97,77.6 19.97,79.53 20.19,79.75 20.19,81.4 20.43,81.64 21.32,81.64 21.79,81.17 JP8802.2
  IN1 w0.203: v2(279.73,38.97) 279.73,39.13 279.26,39.6 278.79,39.6 278.22,40.16 276.97,40.16 276.04,39.24 276.04,36.94 276.18,36.81 276.18,34.7 275.71,34.24 275.71,33.23 274.25,31.77 274.25,30.94 271.98,28.67 262.85,28.67 260.24,31.27 255.5,31.27 254.39,30.17 248.62,30.17 243.02,24.57 212.38,24.57 210.9,23.1 209,23.1 206.94,21.04 206.94,20.47 206.43,19.96 206.43,18.47 204.93,16.96 159.94,16.96 159.14,16.16 150.22,16.16 147.16,13.1 133.29,13.1 128.73,17.66 125.35,17.66 124.67,18.35 124.67,20.61 123.1,22.18 120.88,22.18 120.17,22.89 117.87,22.89 115.08,20.11 115.08,19.16 114.42,18.5 67.17,18.5 65.17,20.49 60.95,20.49 59.65,19.18 55.23,19.18 54.95,19.46 41.7,19.46 39.97,21.19 34.45,21.19 33.58,22.05 30.99,22.05 30,23.04 29.33,23.04 27.4,24.98 27.4,30.65 27.69,30.94 28.63,30.94 29.22,31.53 29.22,36.21 27.88,37.55 27.88,39.75 26.28,41.35 26.28,43.93 15.6,54.61 15.6,59.16 12.43,62.34 12.43,75.46 13.95,76.98 16.96,76.98 17.56,76.38 18.75,76.38 v2(19.3,76.93)
  BOTTOM w0.102: v1(279.73,38.34) v2(279.73,38.97)
CHG_ACP: length 363.9
  TOP w0.203: U8800.2 276.97,34.78 277.35,35.16 278.58,35.16 279.11,35.68 279.11,37.24 278.84,37.5 C8808.2 278.54,38.01 C8807.1 279.11,38.58 v2(279.11,38.97)
  TOP w0.229: v2(18.89,77.4) 19.06,77.4 v1(19.46,77.81) 19.46,79.53 19.86,79.93 19.86,81.58 20.31,82.04 JP8801.2
  IN1 w0.203: v2(18.89,77.4) 18.71,77.22 18.71,76.96 18.45,76.69 17.68,76.69 17.09,77.29 13.82,77.29 12.12,75.58 12.12,62.21 15.3,59.04 15.3,54.48 25.97,43.81 25.97,41.23 27.58,39.62 27.58,37.42 28.91,36.09 28.91,31.66 28.5,31.25 27.56,31.25 27.09,30.78 27.09,24.85 29.28,22.66 29.95,22.66 30.87,21.75 33.46,21.75 34.32,20.89 39.84,20.89 41.57,19.16 54.77,19.16 55.05,18.88 59.77,18.88 61.08,20.19 65.05,20.19 67.04,18.19 114.55,18.19 115.39,19.03 115.39,19.98 117.99,22.59 120.05,22.59 120.76,21.88 122.97,21.88 124.36,20.48 124.36,18.22 125.23,17.36 128.61,17.36 133.17,12.8 147.29,12.8 150.35,15.86 159.26,15.86 160.05,16.64 205.04,16.64 206.74,18.34 206.74,19.83 207.24,20.34 207.24,20.91 209.12,22.79 211.05,22.79 212.53,24.26 243.15,24.26 248.75,29.86 254.58,29.86 255.68,30.97 260.12,30.97 262.72,28.37 272.11,28.37 274.55,30.82 274.55,31.64 276.02,33.1 276.02,34.11 276.48,34.58 276.48,36.94 276.35,37.07 276.35,39.12 277.09,39.86 278.1,39.86 278.66,39.3 278.79,39.3 v2(279.11,38.97)
CHG_BST: length 2.9
  TOP w0.229: SR8803.2 280.16,31.99 279.98,31.81 v1(279.61,31.81) 279.43,31.99 279.21,31.99 278.76,32.44 U8800.25
CHG_BST_R: length 4.3
  TOP w0.508: C8817.2 281.96,32.89 SR8803.1 282.81,31.99 282.82,32 D8800.3 284.55,32 v1(284.87,32.32)
CHG_GPIO12_AC_BATT#_Q: length 3.7
  TOP w0.102: v1(263.53,32.82) SR8810.1 264.99,33.78 265.52,33.25 Q8807.3
CHG_HG: length 13.7
  TOP w0.229: v4(279.51,32.62) 279.29,32.84 U8800.26
  IN2 w0.762: v4(279.51,32.62) 281.92,30.21 281.92,27.67 280.9,26.65 280.9,25.23 v4(281.77,24.37)
  BOTTOM w0.508: T8800.1 282.42,25.24 282.42,25.01 v4(281.77,24.37)
CHG_ILIM: length 5.3
  TOP w0.102: U8800.21 277.37,28.92 C8824.1 R8813.2 ; R8813.2 279.15,28.02 v1(279.15,27.49) ; R8813.2 R8811.1
CHG_LDO: length 32.6
  TOP w0.229: U8800.24 278.65,32.04 279.94,30.75 C8821.1
  TOP w0.381: v2(272.78,36.61) 273.11,36.28 R8806.2
  TOP w0.508: v2(276,41.18) 277.2,39.99 280.68,39.99 280.98,39.68 281.37,39.68 282.49,38.55 282.49,38.17 v1(285.91,34.75) 285.91,30.51 285.45,30.06 D8800.2 D8800.1 282.55,30.75 C8821.1
  IN2 w0.508: v2(272.78,36.61) 274.96,38.79 274.96,39.78 276,40.82 v2(276,41.18)
CHG_LED_RED: length 308.2
  TOP w0.102: U3002.25 151.26,33.55 149.74,32.03 v2(149.74,30.41) ; v2(89.19,186.87) 88.91,187.15 R5602.1
  IN2 w0.102: v2(89.19,186.87) 88.78,186.87 86.16,184.26 85.53,184.26 83.54,182.27 81.41,182.27 74.89,175.74 74.89,171.51 73.15,169.77 73.15,162.03 71.4,160.28 71.4,154.63 69.91,153.15 69.91,149.69 68.56,148.33 68.56,145 65.61,142.05 65.61,135.03 66.27,134.37 66.27,128.44 68.03,126.69 68.03,120.54 67.99,120.5 67.99,120.17 68.03,120.13 68.03,117.24 65.33,114.54 65.33,113.48 58.72,106.87 53.11,106.87 46.62,100.38 46.62,99.54 46.62,76.63 37.53,67.55 37.53,46.06 42.58,41.02 42.58,37.84 45.06,35.36 52.83,35.36 55.81,32.39 100.8,32.39 102.87,34.46 108.19,34.46 108.71,34.98 112.7,34.98 113.77,36.05 120.97,36.05 123.71,38.79 127.72,38.79 136.72,29.79 149.12,29.79 v2(149.74,30.41)
  BOTTOM w0.102: CON5602.22 92.25,186 92.08,186.16 89.9,186.16 v2(89.19,186.87) ; v1(149.74,29.55) v2(149.74,30.41)
CHG_LED_RED_LED: length 10.2
  TOP w0.114: LQ801.1 243.22,188.79 242.89,189.12 LC801.1 242.06,189.12 241.81,189.36 241.81,189.7 241.51,190 v1(241.51,190) 241.31,190 240.58,189.27 236.99,189.27 236.45,189.81 CON1.4
CHG_LED_YELLOW: length 311.3
  TOP w0.102: R5601.1 89.8,187 v2(89.92,186.87) ; U3002.28 150.06,32.84 149.1,31.88 v2(149.1,30.41)
  IN2 w0.102: v2(89.92,186.87) 89.21,186.16 88.91,186.16 87.17,184.43 87,184.43 84.43,181.86 81.58,181.86 75.29,175.57 75.29,171.34 74.5,170.55 74.5,159.2 74.17,158.87 74.17,152.3 72.8,150.92 72.8,144.94 70.96,143.11 67.25,143.11 66.02,141.88 66.02,135.23 66.68,134.57 66.68,128.61 68.43,126.85 68.43,122.6 69.62,121.41 69.62,118.26 65.73,114.38 65.73,113.31 58.89,106.47 53.28,106.47 47.02,100.21 47.02,99.71 47.02,92.08 47.38,91.73 47.91,91.73 48.29,91.35 48.29,77.63 37.73,67.08 37.73,46.15 42.78,41.1 42.78,37.93 45.14,35.57 52.91,35.57 55.89,32.59 100.71,32.59 102.79,34.67 108.11,34.67 108.63,35.19 112.62,35.19 113.68,36.25 120.88,36.25 123.63,39 127.8,39 136.8,30 148.69,30 v2(149.1,30.41)
  BOTTOM w0.102: v2(89.92,186.87) 90.33,186.47 92.13,186.47 92.75,185.85 CON5602.23 ; v1(148.85,31.07) 148.85,30.66 v2(149.1,30.41)
CHG_LED_YELLOW_LED: length 9.7
  TOP w0.114: CON1.3 235.95,190.49 235.31,189.85 232.34,189.85 231.5,189.01 v1(231.5,188.88) 231.5,187.36 LC802.1 LQ802.1
CHG_LG: length 14.1
  TOP w0.229: v4(279.15,30.69) 279.15,30.94 278.46,31.64 U8800.23
  IN2 w0.762: v4(279.15,30.69) 279.15,28.33 278.77,27.95 278.77,20.4 v4(279.38,19.79)
  BOTTOM w0.508: v4(279.15,30.69) 279.15,30.74 T8801.1
CHG_LX: length 13.8
  TOP w0.229: C8817.1 280.6,32.87 280.19,32.87 279.83,33.24 U8800.27
  TOP w0.432: v4(280,33.81) 280.09,33.81 280.78,33.13 C8817.1
  IN2 w0.762: v4(281.92,25.97) 283.06,27.11 283.06,30.75 v4(280,33.81)
  vias: v1(280.98,25.18)
CHG_PROCHOT#: length 7.5
  TOP w0.102: U8800.10 273.92,32.84 273,31.92 273,31.52 272.83,31.35 272.07,31.35 R8837.2 270.9,32.52 Q8806.1 270.17,34.13 v1(270.49,34.45)
CHG_PROCHOT#_Q: length 8.4
  TOP w0.121: Q8807.6 266.82,29.96 266.46,29.6 264.34,29.6 v1(263.91,30.03) 261.95,31.98 261.95,33.09 SR8811.1
CHG_RC: length 0.7
  BOTTOM w0.254: v1(279.33,20.61) v2(280.07,20.61)
CHG_SRN_R: length 23.4
  TOP w0.102: v2(287.13,27.57) 287.33,27.37 v1(287.33,26.7)
  TOP w0.203: SR8805.1 283.7,27.29 283.75,27.24 C8826.2 284.66,27.75 286.32,27.75 C8823.2 v2(287.13,27.57)
  TOP w0.229: v2(299.36,23.76) 300.16,23.76 300.26,23.86 JP8805.2
  IN2 w0.254: v2(299.36,23.76) 299.22,23.76 298.28,24.7 298.28,28.46 297.72,29.01 288.6,29.01 287.16,27.57 v2(287.13,27.57)
CHG_SRP_R: length 23.2
  TOP w0.102: v1(286.87,29.39) 286.87,28.81 C8823.1
  TOP w0.203: SR8804.1 283.75,28.56 283.83,28.64 C8825.2 284.7,28.09 286.15,28.09 C8823.1 286.87,28.43 v2(287.1,28.2)
  TOP w0.229: v2(299.36,24.42) 299.17,24.42 298.89,24.14 JP8804.2
  IN2 w0.254: v2(287.1,28.2) 288.27,29.37 297.87,29.37 298.63,28.61 298.63,24.85 299.07,24.42 v2(299.36,24.42)
CHG_VCC: length 335.7
  TOP w0.229: C8816.2 279.8,34.4 279.69,34.4 278.93,33.64 U8800.28
  TOP w0.508: R8812.2 8.4,61.87 v2(8.97,62.44) ; C8816.2 279.58,35.08 v2(279.1,34.6)
  IN2 w0.508: v2(228.05,21.44) 228.05,21.3 228.41,20.94 229.6,20.94 230.11,20.43 234.88,20.43 235.67,21.22 239.48,21.22 240.22,21.95 241.74,21.95 248.7,28.91 254.19,28.91 255.25,29.98 260.76,29.98 262.79,27.95 268.65,27.95 275.3,34.6 v2(279.1,34.6) ; v2(8.97,62.44) 9.18,62.64 12.43,62.64 16.44,58.63 16.44,56.7 17.33,55.81 17.33,49.38 20.96,45.75 20.96,36.79 22.05,35.69 22.05,30.11 22.74,29.42 22.74,18.58 25.27,16.05 37.06,16.05 39.72,18.7 49.39,18.7 49.69,19.01 59.67,19.01 63.15,22.49 88.98,22.49 97.24,14.23 99.32,14.23 99.65,14.56 108.14,14.56 108.37,14.33 124.11,14.33 125.3,13.15 147.56,13.15 149.75,15.34 159.66,15.34 159.91,15.08 162.91,15.08 163.13,14.87 164.87,14.87 166.77,16.77 194.24,16.77 v2(195.46,15.55)
  IN4 w0.508: v2(228.05,21.44) 227.72,21.11 213.64,21.11 212.86,20.33 211.39,20.33 206.62,15.55 v2(195.46,15.55)
  BOTTOM w0.508: v1(278.72,33.84) 278.72,34.22 v2(279.1,34.6)
CHG_VCC_R: length 2.9
  TOP w0.102: D8801.3 4.91,60.99 v1(5.42,60.48)
  TOP w0.508: R8812.1 5.66,61.87 5.42,61.63 D8801.3
CK_24M_85OHM_BCK: length 8.1
  BOTTOM w0.121: U2000.G1 220.28,69.8 220.28,70.15 219.75,70.68 219.45,70.68 218.21,71.92 214.77,71.92 214.59,71.75 213.65,71.75 SR2504.2
CK_24M_85OHM_BCK#: length 8.1
  BOTTOM w0.121: SR2506.2 213.86,71.51 214.69,71.51 214.86,71.69 218.11,71.69 219.36,70.44 219.66,70.44 220.04,70.05 220.04,69.81 220,69.77 U2000.F1
CK_24M_BCK: length 188.1
  IN4 w0.102: v3(112.74,125.42) 112.92,125.24 112.92,125 113.34,124.58 114.12,124.58 115.17,125.64 115.98,125.64 116.67,126.32 117.89,126.32 119.13,125.08 123.14,125.08 124.42,123.81 124.42,121.69 125.01,121.09 125.01,110.28 130.29,105 130.29,91.36 130.6,91.05 130.6,90.52 130.96,90.17 130.96,88.39 131.16,88.19 131.16,68.78 133.38,66.55 133.38,62.95 134.65,61.68 134.65,58.88 143.27,50.26 146.5,50.26 152.6,44.17 169.94,44.17 170.46,43.64 186.95,43.64 189.84,46.54 189.84,50.12 191.12,51.39 191.12,60.32 200.95,70.16 203.97,70.16 204.2,69.93 v2(204.2,69.77)
  BOTTOM w0.121: v2(204.2,69.77) 204.2,69.93 203.99,70.14 203.99,70.54 204.73,71.28 210.46,71.28 211.12,71.94 SR2504.1 ; v3(112.74,125.42) 112.74,125.49 U0300.E31
CK_24M_BCK#: length 188.3
  IN4 w0.102: v2(204.63,70.2) 204.26,70.2 204.08,70.38 200.86,70.38 190.9,60.41 190.9,51.48 189.63,50.21 189.63,46.63 186.86,43.86 170.55,43.86 170.03,44.38 152.68,44.38 146.59,50.48 143.36,50.48 134.87,58.97 134.87,61.77 133.6,63.04 133.6,66.64 131.38,68.87 131.38,88.28 131.17,88.48 131.17,90.26 130.82,90.61 130.82,91.14 130.5,91.45 130.5,105.09 125.23,110.37 125.23,121.18 124.63,121.78 124.63,123.9 123.23,125.29 119.22,125.29 117.98,126.54 116.58,126.54 115.89,125.85 115.08,125.85 114.03,124.8 113.43,124.8 113.14,125.09 113.14,125.17 v3(113.39,125.42)
  BOTTOM w0.121: SR2506.1 212.11,71.1 212.03,71.18 212.03,71.35 212.12,71.43 212.12,71.59 212,71.7 211.21,71.7 210.55,71.04 205.77,71.04 ; U0300.D31 113.39,125.49 v3(113.39,125.42) ; 205.77,71.04 204.83,71.04 204.23,70.45 204.23,70.23 204.26,70.2 v2(204.63,70.2) ; 205.77,71.04 v1(205.77,70.83)
CK_100M_85OHM_BCK: length 9.7
  BOTTOM w0.121: SR2501.2 213.79,73.11 213.97,73.11 214.58,72.5 218.34,72.5 220.57,70.27 220.57,69.53 220.52,69.47 220.52,69.32 220.47,69.26 U2000.G2
CK_100M_85OHM_BCK#: length 9.7
  BOTTOM w0.121: U2000.H2 220.81,69.68 220.81,70.36 218.44,72.73 214.68,72.73 214.07,73.35 213.72,73.35 SR2502.2
CK_100M_85OHM_CPUXDP: length 7.2
  BOTTOM w0.121: SR2508.2 218.4,74.34 218.59,74.34 222.1,70.83 222.1,69.59 U2000.L2
CK_100M_85OHM_CPUXDP#: length 7
  BOTTOM w0.121: SR2509.2 218.55,74.65 218.61,74.65 222.33,70.93 222.33,69.87 U2000.L1
CK_100M_85OHM_PCIE: length 8.9
  BOTTOM w0.121: U2000.J2 221.28,69.45 221.03,69.7 221.03,70.85 218.65,73.24 216.44,73.24 216.08,73.6 216.08,74 215.98,74.1 SR2511.2
CK_100M_85OHM_PCIE#: length 8.9
  BOTTOM w0.121: SR2512.2 215.86,74.65 215.86,74.56 216.31,74.1 216.31,73.69 216.54,73.47 218.75,73.47 221.27,70.95 221.27,69.87 U2000.J1
CK_100M_BCK: length 187.5
  IN4 w0.102: v3(116.26,125.23) 116.86,125.83 117.65,125.83 118.89,124.58 122.93,124.58 123.92,123.59 123.92,121.27 124.53,120.66 124.53,109.95 129.81,104.67 129.81,91.11 130.08,90.84 130.08,90.36 130.47,89.97 130.47,88.5 130.28,88.31 130.28,83.06 130.68,82.67 130.68,68.58 132.89,66.36 132.89,62.42 134.03,61.28 134.03,58.82 143.49,49.36 146.69,49.36 152.37,43.68 169,43.68 169,43.68 169.71,43.68 170.23,43.16 187.15,43.16 190.33,46.34 190.33,49.92 191.64,51.23 191.64,59.51 192.88,60.75 192.88,61.41 201.03,69.55 202.55,69.55 203.34,68.76 v2(203.49,68.76)
  BOTTOM w0.121: SR2501.1 212.32,73.08 211.45,73.08 210.15,71.78 204.52,71.78 203.49,70.75 203.49,69.48 203.29,69.28 203.29,68.96 v2(203.49,68.76) ; U0300.B31 116.26,125.81 116.44,125.63 116.44,125.41 v3(116.26,125.23)
CK_100M_BCK#: length 187.4
  IN4 w0.102: v2(203.05,68.34) 203.05,68.74 202.46,69.34 201.12,69.34 193.1,61.32 193.1,60.66 191.85,59.42 191.85,51.14 190.54,49.83 190.54,46.25 187.24,42.95 170.14,42.95 169.62,43.47 168.92,43.47 168.91,43.47 152.28,43.47 146.6,49.14 143.4,49.14 133.81,58.73 133.81,61.19 132.68,62.33 132.68,66.27 130.46,68.49 130.46,82.58 130.07,82.98 130.07,88.4 130.26,88.59 130.26,89.88 129.86,90.27 129.86,90.75 129.59,91.02 129.59,104.58 124.31,109.86 124.31,120.57 123.7,121.18 123.7,123.5 122.84,124.37 118.8,124.37 117.56,125.61 116.95,125.61 116.88,125.54 v3(116.88,125.25)
  BOTTOM w0.121: v2(203.05,68.34) 203.05,68.34 203.05,69.37 203.26,69.58 203.26,70.85 204.42,72.02 210.05,72.02 211.35,73.31 212.32,73.31 SR2502.1 ; v3(116.88,125.25) 116.67,125.46 116.67,125.73 116.36,126.05 115.22,126.05 U0300.A32
CK_100M_CPUXDP: length 280.6
  IN4 w0.102: v2(216.74,74.51) 216.32,74.92 215.69,74.92 214.6,76.02 213.4,76.02 210.66,73.27 206.02,73.27 205.03,72.28 201.06,72.28 188.25,59.47 188.25,47.48 185.85,45.08 171,45.08 170.52,45.56 153.21,45.56 146.54,52.23 144.2,52.23 136.44,59.99 136.44,65.17 135.12,66.49 135.12,66.86 132.56,69.43 132.56,88.77 132.35,88.97 132.35,91.38 131.69,92.05 131.69,105.77 127.33,110.13 127.33,121.78 126.51,122.6 126.51,124.38 120.62,130.27 118.69,130.27 118.29,129.88 116.82,129.88 116.1,130.6 115.18,130.6 113.52,132.26 113.52,138.45 110.29,141.68 71.79,141.68 70.95,142.53 70.11,142.53 67.32,145.32 66.05,145.32 62.71,148.66 60.24,148.66 v2(59.85,148.27)
  BOTTOM w0.121: XDP4400.40 54.15,136.95 53.88,136.68 52.52,136.68 51.87,137.33 51.87,139.45 ; v1(52.09,139.45) 51.87,139.45 ; 51.87,139.45 51.87,143.06 51.09,143.84 51.09,146.9 51.72,147.52 52.55,147.52 53.04,148.02 58.29,148.02 58.91,148.64 59.47,148.64 59.84,148.27 v2(59.85,148.27) ; v2(216.74,74.51) 217.12,74.12 SR2508.1
CK_100M_CPUXDP#: length 280.6
  IN4 w0.102: v2(216.74,75.14) 215.78,75.14 214.69,76.23 213.31,76.23 210.57,73.49 205.93,73.49 204.94,72.5 200.97,72.5 188.03,59.56 188.03,47.57 185.76,45.3 171.09,45.3 170.61,45.78 153.3,45.78 146.63,52.45 144.29,52.45 136.66,60.08 136.66,65.26 135.34,66.58 135.34,66.95 132.77,69.51 132.77,88.86 132.57,89.06 132.57,91.47 131.9,92.14 131.9,105.86 127.54,110.22 127.54,121.87 126.73,122.69 126.73,124.47 120.71,130.49 118.6,130.49 118.21,130.09 116.91,130.09 116.19,130.82 115.27,130.82 113.73,132.35 113.73,138.54 110.38,141.9 71.88,141.9 71.04,142.74 70.2,142.74 67.41,145.54 66.14,145.54 62.8,148.88 v2(59.82,148.88)
  BOTTOM w0.121: 51.64,137.7 51.64,142.96 50.86,143.74 50.86,147 51.62,147.76 52.45,147.76 52.95,148.25 58.19,148.25 58.81,148.88 v2(59.82,148.88) ; 51.64,137.7 v1(51.42,137.7) ; 51.64,137.7 51.64,137.23 52.42,136.45 XDP4400.42 ; v2(216.74,75.14) 216.87,75.01 SR2509.1
CK_100M_LAN: length 71.8
  TOP w0.121: U3300.33 278.89,97.64 278.72,97.47 278.72,96.76 277.81,95.84 276.77,95.84 276.56,95.63 276.21,95.63 ; 276.21,95.63 275.85,95.63 275.42,96.07 v2(275.19,96.3) ; 276.21,95.63 v1(276.21,95.41)
  IN4 w0.102: v2(275.19,96.3) 275.19,96.3 275.64,96.75 275.64,96.96 275.51,97.1 274.57,97.1 273.88,96.41 273.88,96.08 266.55,88.75 259.33,88.75 258.09,87.52 254.75,87.52 253.17,85.94 250.09,85.94 249.9,86.14 244.68,86.14 241.74,83.2 241.74,81.46 240.11,79.84 239.31,79.84 239.31,79.84 238.92,79.84 230.64,79.84 229.76,78.96 224.07,78.96 222.24,77.13 222.24,76.09 v2(222.43,75.9)
  BOTTOM w0.121: SR2517.2 222.71,75.62 v2(222.43,75.9)
CK_100M_LAN#: length 71.2
  TOP w0.121: v2(275.86,96.28) 275.86,95.96 275.95,95.87 276.46,95.87 276.67,96.08 277.71,96.08 278.21,96.58 ; 278.21,96.58 278.49,96.86 U3300.32 ; 278.21,96.58 v1(278.06,96.73)
  IN4 w0.102: v2(221.82,75.9) 222.03,76.11 222.03,77.22 223.98,79.18 229.67,79.18 230.55,80.05 239.22,80.05 240.02,80.06 241.52,81.55 241.52,83.29 244.59,86.35 249.99,86.35 250.18,86.16 253.08,86.16 254.66,87.73 258,87.73 259.24,88.97 266.47,88.97 273.66,96.16 273.66,96.5 274.48,97.31 275.6,97.31 275.86,97.05 v2(275.86,96.28)
  BOTTOM w0.121: SR2518.2 v2(221.82,75.9)
CK_100M_LAN#_R: length 6.7
  BOTTOM w0.102: U2000.P3 223.3,69.02 223.3,69.45 223.17,69.67 223.17,70.2 223.26,70.29
  BOTTOM w0.121: 223.26,70.29 223.26,71.79 222.15,72.9 222.15,73.49 ; v1(221.93,73.49) 222.15,73.49 ; 222.15,73.49 222.15,74.11 SR2518.1
CK_100M_LAN_R: length 5.9
  BOTTOM w0.102: 223.42,70.12 223.39,70.09 223.39,69.71 223.51,69.48 223.51,69.25 U2000.P2
  BOTTOM w0.121: SR2517.1 222.39,74.11 222.39,72.99 223.49,71.89 223.49,70.19 223.42,70.12
CK_100M_PCIE: length 190.1
  IN4 w0.102: v2(213.9,74.35) 213.71,74.54 213.23,74.54 211.26,72.57 206.31,72.57 205.09,71.36 201.16,71.36 190.42,60.61 190.42,51.68 189.15,50.41 189.15,47.39 186.14,44.38 170.72,44.38 170.23,44.86 152.91,44.86 146.25,51.53 143.88,51.53 135.41,60 135.41,62.21 134.36,63.27 134.36,66.63 131.86,69.14 131.86,88.48 131.65,88.68 131.65,91.09 130.99,91.76 130.99,105.32 126.59,109.72 126.59,121.3 125.28,122.61 125.28,124.31 120.83,128.76 116.95,128.76 115.94,129.76 114.78,129.76 113.29,128.27 113.29,128.04 113.34,128 v3(113.66,128)
  BOTTOM w0.121: SR2511.1 214.28,74.5 214.05,74.5 v2(213.9,74.35) ; U0300.D35 113.2,128 v3(113.66,128)
CK_100M_PCIE#: length 190.1
  IN4 w0.102: v2(213.9,74.99) 213.67,74.76 213.14,74.76 211.17,72.79 206.22,72.79 205,71.58 201.07,71.58 190.2,60.7 190.2,51.77 188.93,50.5 188.93,47.48 186.05,44.6 170.8,44.6 170.32,45.08 153,45.08 146.34,51.75 143.97,51.75 135.63,60.09 135.63,62.3 134.58,63.36 134.58,66.72 132.07,69.23 132.07,88.57 131.87,88.77 131.87,91.18 131.2,91.85 131.2,105.41 126.81,109.81 126.81,121.39 125.5,122.7 125.5,124.4 120.92,128.98 117.04,128.98 116.03,129.98 114.69,129.98 113.21,128.5 v3(112.87,128.5)
  BOTTOM w0.121: U0300.C36 113.59,128.5 v3(112.87,128.5) ; v2(213.9,74.99) 214.15,74.73 214.42,74.73 SR2512.1
CK_100M_PE0: length 89.1
  TOP w0.121: v1(225.96,73.95) 225.74,73.95 ; 225.74,73.95 225.74,72.8 225.85,72.69 225.85,72.27 SR2510.2 ; 225.74,73.95 225.74,75.09 226.53,75.88 229.06,75.88 230.62,77.43 234.13,77.43 v2(234.63,77.92)
  IN4 w0.102: v2(299.07,93.72) 299.48,93.3 299.48,92.86 298.94,92.31 281.87,92.31 279.47,89.91 274.62,89.91 273.63,88.93 267.75,88.93 266.97,88.15 260.88,88.15 258.64,85.9 255.16,85.9 253.64,84.38 252.07,84.38 250.21,82.52 250.21,82.26 249.33,81.38 242.49,81.38 240.47,79.36 239.81,79.36 238.86,79.36 238.51,79.01 237.11,79.01 236.78,79.01 235.93,78.16 235.93,77.8 235.63,77.5 234.74,77.5 234.63,77.62 v2(234.63,77.92)
  BOTTOM w0.121: v2(299.07,93.72) 299.51,93.27 299.51,92.59 299.25,92.33 CON5300.47
CK_100M_PE0#: length 89.1
  TOP w0.121: v1(228.02,76.33) 228.02,76.11 ; 228.02,76.11 226.43,76.11 225.51,75.19 225.51,72.7 225.61,72.59 225.61,72.08 SR2503.2 ; 228.02,76.11 228.97,76.11 230.52,77.67 233.76,77.67 v2(234.02,77.92)
  IN4 w0.102: v2(299.7,93.72) 299.7,92.77 299.02,92.09 281.96,92.09 279.56,89.69 274.71,89.69 273.72,88.71 267.84,88.71 267.06,87.93 260.97,87.93 258.73,85.68 255.25,85.68 253.73,84.16 252.16,84.16 250.43,82.44 250.43,82.17 249.42,81.16 242.58,81.16 240.56,79.14 239.9,79.14 239.9,79.14 238.95,79.14 238.6,78.79 236.87,78.79 236.15,78.07 236.15,77.71 235.72,77.29 234.65,77.29 v2(234.02,77.92)
  BOTTOM w0.121: CON5300.49 299.75,93.67 v2(299.7,93.72)
CK_100M_PE0#_R: length 7.7
  TOP w0.121: v1(224.85,68.61) 224.85,68.39 ; 224.85,68.39 224.42,68.39 224.06,68.03 224.06,66.35 223.99,66.28 223.76,66.28 v2(223.53,66.52) ; 224.85,68.39 225.13,68.39 225.76,69.01 225.76,70.64 SR2503.1
  BOTTOM w0.121: U2000.N7 223.03,66.87 223.03,66.6 223.11,66.52 v2(223.53,66.52)
CK_100M_PE0_R: length 7.8
  TOP w0.121: 225.99,70.09 225.99,68.92 225.23,68.16 224.52,68.16 224.29,67.93 224.29,66.25 224.09,66.05 223.82,66.05 v2(223.56,65.78) ; 225.99,70.09 225.99,70.73 SR2510.1 ; 225.99,70.09 v1(226.21,70.09)
  BOTTOM w0.121: v2(223.56,65.78) 223.52,65.78 U2000.N8
CK_100M_PE1: length 96.6
  TOP w0.121: v2(236.68,77.27) 236.68,77.28 236.51,77.45 236.33,77.45 235.2,78.58 230.37,78.58 228.6,76.81 225.99,76.81 224.8,75.63 224.8,73.98 224.21,73.39 224.21,72.88 ; v1(224.43,72.88) 224.21,72.88 ; 224.21,72.88 224.21,72.16 SR2505.2
  IN4 w0.102: v2(301.75,94.07) 301.06,93.39 301.06,92.79 299.78,91.51 288.31,91.51 286.28,89.48 280.49,89.48 280.06,89.05 275.16,89.05 274.24,88.13 269.44,88.13 268.34,87.03 260.9,87.03 257.42,83.56 253.71,83.56 249.96,79.8 242.18,79.8 241,78.62 239.29,78.62 238.9,78.22 237.24,78.22 236.94,77.92 236.94,77.53 v2(236.68,77.27)
  BOTTOM w0.121: v2(301.75,94.07) 301.99,93.82 305.19,93.82 305.64,93.38 305.64,92.42 305.75,92.31 CON5300.73
CK_100M_PE1#: length 96.7
  TOP w0.121: v1(224.35,75.22) 224.57,75.22 ; 224.57,75.22 224.57,75.72 225.89,77.05 228.5,77.05 230.27,78.81 235.3,78.81 236.42,77.69 236.9,77.69 v2(237.29,77.3) ; 224.57,75.22 224.57,74.08 223.98,73.49 223.98,72.15 SR2507.2
  IN4 w0.102: v2(237.29,77.3) 237.16,77.44 237.16,77.83 237.33,78.01 238.98,78.01 239.38,78.4 241.09,78.4 242.27,79.59 250.05,79.59 253.8,83.34 257.51,83.34 260.98,86.82 268.43,86.82 269.53,87.92 274.33,87.92 275.25,88.84 280.15,88.84 280.58,89.26 286.37,89.26 288.4,91.29 299.87,91.29 301.28,92.7 301.28,93.3 301.41,93.44 v2(301.76,93.44)
  BOTTOM w0.121: v2(301.76,93.44) 301.91,93.59 305.09,93.59 305.4,93.28 305.4,92.43 305.25,92.27 CON5300.71
CK_100M_PE1#_R: length 6.3
  TOP w0.121: 223.98,70.11 223.98,70.71 SR2507.1 ; 223.98,70.11 223.98,69.62 223.75,69.4 223.3,69.4 222.15,68.25 222.15,67.32 v2(222.61,66.86) ; 223.98,70.11 v1(223.76,70.11)
  BOTTOM w0.121: U2000.L7 222.35,67.12 v2(222.61,66.86)
CK_100M_PE1_R: length 6.3
  TOP w0.121: 222.89,68.66 223.39,69.16 223.85,69.16 224.21,69.53 224.21,70.71 SR2505.1 ; 222.89,68.66 v1(223.04,68.51) ; 222.89,68.66 222.38,68.16 222.38,67.69 v2(222.61,67.47)
  BOTTOM w0.121: v2(222.61,67.47) 221.96,67.47 221.87,67.56 221.87,67.74 222.01,67.88 U2000.L5
CK_100M_PE8: length 223.8
  TOP w0.133: v1(217.38,64.08) 217.38,64.29 ; 217.38,64.29 211.83,64.29 206.95,59.4 206.95,57.03 206.29,56.37 205.69,56.37 205.37,56.05 205.37,55.6 v2(205.77,55.2) ; 217.38,64.29 218.16,64.29 218.31,64.44 219.9,64.44 SR2513.2
  IN3 w0.114: v2(41.89,26.09) 41.78,26.21 41.78,26.56 41.85,26.64 42.1,26.64 44.87,23.87 58.37,23.87 61.54,27.05 97.76,27.05 104.38,33.66 119.11,33.66 122.09,36.64 123.47,36.64 123.74,36.37 131,36.37 133.96,39.34 143.82,39.34 148.87,34.3 162.54,34.3 163,34.75 192.9,34.75 194.94,36.79 195.46,36.79 197.42,38.75 198.29,38.75 206.55,47.01 206.55,48.76 207.54,49.75 207.54,53.24 205.77,55 v2(205.77,55.2)
  BOTTOM w0.133: CON5102.55 31.75,25.45 31.85,25.56 32.24,25.56 32.8,25 35.5,25 36.73,23.78 40.36,23.78 41.71,25.13 41.71,25.92 v2(41.89,26.09)
CK_100M_PE8#: length 223.9
  TOP w0.133: v2(205.09,55.2) 205.09,56.17 205.57,56.66 206.17,56.66 206.66,57.14 206.66,59.52 211.71,64.57 218.04,64.57 218.19,64.73 219.13,64.73 ; 219.13,64.73 219.83,64.73 SR2514.2 ; 219.13,64.73 v1(219.13,64.94)
  IN3 w0.114: v2(205.09,55.2) 207.19,53.09 207.19,49.89 206.2,48.9 206.2,47.15 198.15,39.09 197.28,39.09 195.32,37.14 194.8,37.14 192.76,35.1 162.86,35.1 162.4,34.64 149.01,34.64 143.97,39.68 133.82,39.68 130.85,36.71 123.88,36.71 123.61,36.98 121.95,36.98 118.97,34.01 104.24,34.01 97.62,27.39 61.4,27.39 58.22,24.21 45.02,24.21 42.25,26.98 41.71,26.98 41.43,26.71 41.43,26.25 v2(41.28,26.09)
  BOTTOM w0.133: CON5102.53 31.73,25.95 31.84,25.84 32.36,25.84 32.92,25.29 35.62,25.29 36.85,24.06 40.24,24.06 41.43,25.25 41.43,25.95 v2(41.28,26.09)
CK_100M_PE8#_R: length 6.4
  TOP w0.133: 222.36,64.7 221.36,64.7 SR2514.1 ; 222.36,64.7 223.75,64.7 224.42,65.36 224.85,65.36 225.2,65.72 225.67,65.72 v2(225.86,65.91) ; 222.36,64.7 v1(222.36,64.91)
  BOTTOM w0.133: v2(225.86,65.91) 226.16,65.61 U2000.W10
CK_100M_PE8_R: length 6.4
  TOP w0.133: SR2513.1 221.24,64.42 223.87,64.42 224.01,64.55 ; 224.01,64.55 224.53,65.08 224.97,65.08 225.32,65.43 225.73,65.43 v2(225.86,65.3) ; 224.01,64.55 v1(224.16,64.4)
  BOTTOM w0.133: U2000.W11 226.19,65.08 226.08,65.08 v2(225.86,65.3)
CL_CLK: length 125.4
  TOP w0.121: v2(300.84,101) 300.46,101.38 R5312.2
  IN4 w0.083: v2(236.02,68.76) 236.35,69.09 237.42,69.09 238.64,67.88 238.64,66.23 244.29,60.58 245.42,60.58 245.5,60.5 245.69,60.3 247.67,60.3 248.27,59.7 249.04,59.7 250.01,58.74 250.85,58.74 251,58.59 259.94,58.59 263.03,55.5 265.61,55.5 267.53,57.42 273.28,57.42 274.34,58.48 276.2,58.48 278.61,60.89 285.17,60.89 285.98,60.08 287.78,60.08 288.88,61.18 288.88,62.24 289.59,62.95 292.54,62.95 293.91,64.32 298.49,64.32 300.38,66.21 300.38,68.04 302.49,70.14 304.08,70.14 306.3,72.37 306.3,76.82 307.05,77.57 307.05,80.36 308.03,81.33 308.03,82.75 306.94,83.83 306.94,85.94 306.73,86.15 304.93,86.15 303.9,87.19 303.9,100.86 302.8,101.96 301.81,101.96 v2(300.84,101)
  BOTTOM w0.121: v2(300.84,101) 301.68,101.84 v1(301.99,101.84) ; v2(236.02,68.76) 236.02,68.83 235.73,69.12 235.72,69.12 U2000.AV2
CL_CLK_R: length 3.5
  TOP w0.121: v1(298.2,101.43) 298.63,101 v2(298.71,101) 298.91,101 R5312.1
  BOTTOM w0.121: v2(298.71,101) 298,100.29 CON5300.42
CL_DATA: length 126.3
  TOP w0.121: v1(235.39,68.38) 235.73,68.38 v2(236.02,68.09) ; R5311.2 300.46,102.22 v2(300.84,101.84)
  IN4 w0.083: v2(300.84,101.84) 301.53,102.52 303.03,102.52 304.36,101.19 304.36,87.38 305.13,86.62 306.92,86.62 307.53,86.01 307.53,83.9 308.49,82.94 308.49,81.06 307.52,80.08 307.52,77.37 306.82,76.67 306.82,72.22 304.27,69.68 302.68,69.68 300.84,67.84 300.84,66.01 298.67,63.84 294.09,63.84 291.83,61.58 291.83,60.98 291.64,60.8 289.15,60.8 287.97,59.62 285.79,59.62 284.98,60.43 278.81,60.43 276.4,58.02 274.97,58.02 273.13,56.18 267.32,56.18 266.07,54.93 262.4,54.93 260.94,56.39 257.3,56.39 255.9,57.79 251.14,57.79 250.66,58.27 249.82,58.27 248.85,59.24 248.08,59.24 247.48,59.84 245.5,59.84 245.22,60.11 244.05,60.11 238.14,66.02 238.14,67.72 237.23,68.63 236.56,68.63 v2(236.02,68.09)
  BOTTOM w0.121: U2000.AV3 235.55,68.6 235.79,68.36 235.79,68.32 v2(236.02,68.09)
CL_DATA_R: length 4.4
  TOP w0.121: R5311.1 298.58,102.22 v2(298.48,102.12)
  BOTTOM w0.121: v2(298.48,102.12) 298.08,102.12 v1(297.8,101.84) 297.5,101.54 CON5300.40
CL_RST#: length 125.3
  TOP w0.121: R5310.2 301.99,103.08 v2(302.49,103.08) ; v1(237.01,67.6) 237.01,68.09 v2(236.87,68.23)
  IN4 w0.083: v2(302.49,103.08) 303.23,103.08 304.57,101.74 304.57,87.47 305.21,86.83 307.01,86.83 307.74,86.1 307.74,83.99 308.7,83.02 308.7,80.97 307.72,79.99 307.72,77.29 307.03,76.59 307.03,71.82 304.43,69.22 302.52,69.22 301.05,67.76 301.05,65.93 298.68,63.56 294.12,63.56 292.08,61.52 292.08,60.94 291.73,60.59 289.24,60.59 288.06,59.41 285.7,59.41 284.89,60.22 278.89,60.22 276.48,57.81 275.21,57.81 273.34,55.94 267.38,55.94 266.16,54.72 262.31,54.72 260.85,56.18 257.21,56.18 255.81,57.58 251.01,57.58 250.54,58.06 248.76,58.06 248.22,58.6 244.45,58.6 237.65,65.39 237.65,66.5 236.87,67.28 v2(236.87,68.23)
  BOTTOM w0.121: U2000.AW2 236.87,68.53 v2(236.87,68.23)
CL_RST#_R: length 10.4
  TOP w0.121: v2(298.48,102.83) 300.06,104.4 R5310.1 SR5302.2
  BOTTOM w0.121: CON5300.38 297,101.55 297.16,101.71 297.16,102.98 v1(297.8,103.61) 298.48,102.93 v2(298.48,102.83)
CLK_KBCPCI_DEBUG: length 196
  IN1 w0.083: v2(123.53,20.6) 122.18,19.25 122.18,17.79 128.25,11.72 144.55,11.72 146.03,10.24 v2(146.03,10.14) ; v2(247.68,62.92) 247.85,62.75 247.85,60.97 246.5,59.62 246.5,54.7 246.45,54.64 246.45,53.51 246.85,53.11 246.85,50.11 247.38,49.59 247.38,48.8 246.94,48.37 246.94,44.36 244.89,42.31 242.54,42.31 239.66,39.43 239.66,38.13 234.99,33.47 234.99,30.65 v2(234.78,30.44)
  IN4 w0.083: v2(234.78,30.44) 234.25,29.9 233.68,29.9 230.89,27.11 230.89,26.42 228.45,23.98 211.49,23.98 210.7,23.2 210.57,23.2 208.51,21.14 208.51,19.79 205.84,17.12 186.37,17.12 186.13,16.89 179.5,16.89 178.92,16.31 146.01,16.31 145.8,16.11 137.22,16.11 136.28,17.05 124.92,17.05 124.19,17.78 124.19,19.94 v2(123.53,20.6)
  BOTTOM w0.121: v2(247.68,62.92) 247.27,62.51 246.86,62.51 246.77,62.42 R2227.1 ; CON4400.1 146.75,9.42 v2(146.03,10.14) v1(146.84,10.14)
CLK_KBCPCI_PCH: length 204.5
  TOP w0.121: U3002.13 156.06,35.97 155.89,36.15 155.89,37.27 156.57,37.95 C3022.1 156.15,38.43 156.15,41.31 v2(155.29,42.17) ; C2203.1 247.01,62.42 R2265.1 246.29,62.22 v2(246.29,61.81)
  IN1 w0.083: v2(246.29,61.81) 246.29,60.72 245.25,59.68 245.25,57.99 245.52,57.72 245.52,53.13 245.93,52.72 245.93,48.27 246.01,48.19 246.01,46.05 245.33,45.37 244.86,45.37 242.93,43.44 241.18,43.44 240.36,42.61 240.36,41.44 238.13,39.21 237.45,39.21 236.84,38.61 236.84,36.63 233.89,33.68 v2(233.89,32.75)
  IN4 w0.083: v2(233.89,32.75) 233.89,32.67 233.62,32.4 231.3,32.4 231.03,32.13 229.49,30.59 229.49,30.21 229.49,29.79 228.67,28.97 227.85,28.97 226.68,27.79 212.21,27.79 210.83,26.41 208.86,26.41 208.63,26.18 208.63,24.88 206.74,23 205.67,23 204.46,21.79 203.83,21.79 201.35,19.31 185.46,19.31 185.23,19.08 175.6,19.08 175.33,18.81 175.29,18.81 175.24,18.85 166.46,18.85 166.07,19.25 146.4,19.25 146.16,19 138.9,19 136.02,21.88 127.74,21.88 v2(126.47,20.61)
  BOTTOM w0.121: v2(155.29,42.17) 154.83,41.71 v1(152.25,41.71) 141.07,41.71 133.84,34.48 133.84,33.71 131.54,31.41 131.54,28.98 130.55,27.99 129.64,27.99 129.27,27.62 129.27,26.14 126.47,23.34 v2(126.47,20.61)
CLKOUT_LPC0_ESPI_CLK: length 8.9
  TOP w0.121: v2(244.89,62.57) 244.89,62.57 245.48,62.57 R2265.2
  BOTTOM w0.102: 240.6,61.88 239.05,61.88 238.69,62.09 238.34,62.09 U2000.BC17
  BOTTOM w0.121: 240.6,61.88 v1(241.65,61.88) 242.24,61.88 242.51,62.15 244.47,62.15 v2(244.89,62.57) 245.03,62.42 R2265.2
CLKOUT_LPC1_CLK: length 45.9
  TOP w0.121: U6200.21 235.09,29.44 234.63,29.9 234.63,29.92 234.24,30.31 234.22,30.31 234.12,30.41 v2(234.12,30.46) ; R2264.1 244.36,63.02 v1(244.61,63.27) 244.68,63.35 C2202.1 246.06,62.92 v2(247.07,62.92)
  IN1 w0.083: v2(247.07,62.92) 246.92,62.77 246.92,60.69 245.71,59.48 245.71,58.67 245.98,58.4 245.98,53.32 246.39,52.91 246.39,48.56 246.47,48.48 246.47,45.85 245.42,44.81 244.95,44.81 243.12,42.98 241.38,42.98 240.82,42.42 240.82,41.25 238.32,38.75 237.64,38.75 237.3,38.41 237.3,36.43 234.35,33.48 234.35,30.7 v2(234.12,30.46)
CLKOUT_LPC1_CLK_R: length 10.2
  TOP w0.121: v2(234.97,61.24) 235.42,60.79 240.6,60.79 241.41,61.6 241.41,62.36 v1(241.8,62.76) 242.53,62.76 R2264.2
  BOTTOM w0.121: U2000.AV19 235.47,60.73 v2(234.97,61.24)
CLKREQ0_WLAN#: length 91.7
  TOP w0.121: v2(300.25,93.44) 300.7,92.99 300.7,92.91 R5306.1
  IN2 w0.083: v2(288.16,92.84) 288.64,93.33 290.41,93.33 290.91,93.83 297.85,93.83 298.46,93.22 300.03,93.22 v2(300.25,93.44)
  IN3 w0.083: v2(253.19,62.41) 257.36,66.58 257.36,72.03 257.56,72.23 257.56,74.84 260.71,77.99 260.71,81.77 260.97,82.02 260.97,83.32 262,84.36 272.55,84.36 274.04,85.85 277.4,85.85 278.64,87.09 278.64,87.89 283.58,92.83 288.14,92.83 v2(288.16,92.84)
  BOTTOM w0.121: v2(300.25,93.44) 300.75,92.94 CON5300.53 ; U2000.BC24 238.31,58.29 239.85,58.29 240.69,59.14 241.19,59.14 241.36,58.97 245.51,58.97 R2425.1 246.53,58.44 247.64,58.44 248.55,59.34 R2421.2 250.22,59.34 251.01,58.55 252.13,58.55 252.61,59.04 v1(252.61,61.35) 252.61,61.83 v2(253.19,62.41)
CLKREQ1_WIGI#: length 117.6
  TOP w0.121: R2410.2 242.21,58.07 v2(242.16,58.01) 242.16,57.42 241.38,56.65 240.11,56.65 239.38,57.38 v1(238,57.38) 237.96,57.43 237.75,57.43 237.41,57.76 237.41,57.9 237.15,58.15 236.15,58.15 v2(235.72,57.73) ; v2(305.16,95.94) 305.29,96.07 R5305.1
  IN4 w0.083: v2(242.16,58.01) 243.78,58.01 244.07,57.72 248.27,57.72 248.73,57.25 250.51,57.25 250.77,56.99 255.56,56.99 256.96,55.59 260.61,55.59 262.07,54.13 272.36,54.13 275.45,57.22 276.73,57.22 279.14,59.63 283.95,59.63 284.94,58.63 288.12,58.63 288.83,59.34 291.37,59.34 292.36,60.33 296.29,60.33 303.32,67.35 303.32,67.58 303.55,67.82 303.85,67.82 308.78,72.74 308.78,79.63 309.75,80.6 309.75,84.92 307.25,87.42 305.46,87.42 305.17,87.7 305.17,94.17 305.51,94.51 305.51,95.6 v2(305.16,95.94)
  BOTTOM w0.121: CON5300.68 304.5,96.61 v2(305.16,95.94) ; U2000.AW24 236.26,58.17 236.17,58.17 v2(235.72,57.73)
CLKREQ#: length 8.3
  TOP w0.121: SR3302.2 289.16,96.89 287.56,98.49 v1(287.33,98.49) 285.62,98.49 285.27,98.84 284.41,98.84 283.49,99.76 U3300.4
CLKREQ#_MSATA: length 240.4
  TOP w0.121: v2(37.44,27.64) 37.44,25.73 36.54,24.82 35.19,24.82 34.98,25.03 R2490.1 34.98,25.35 34.64,25.69 SR5103.1 34.21,26.11 34.04,25.94 v1(34.04,24.98)
  IN1 w0.083: v2(241.38,53.36) 241.24,53.36 240.52,52.63 240.52,48.66 238.23,46.37 237.27,46.37 236.5,45.6 233.35,45.6 232.85,45.1 222.22,45.1 221.64,45.69 211.66,45.69 208.75,42.77 208.75,41.85 208.05,41.15 208.05,38.64 205.22,35.81 204.51,35.81 196.73,28.03 191.04,28.03 190.38,27.37 188.86,27.37 188.2,28.03 169.94,28.03 169.27,27.37 168.21,27.37 167.54,28.03 166.08,28.03 165.21,27.16 161.02,27.16 160.24,27.95 158.62,27.95 157.99,27.32 155.24,27.32 154.58,27.98 143.41,27.98 142.91,27.98 141.02,29.87 130.17,29.87 129.21,30.83 126.03,30.83 125.91,30.72 124.41,30.72 123.81,30.12 119.01,30.12 115.74,26.84 112.8,26.84 111.61,25.65 71.05,25.65 69.47,24.08 45.13,24.08 41.56,27.64 v2(37.44,27.64)
  BOTTOM w0.089: 239.24,54.11 238.92,54.11 238.52,54.51 U2000.BD32
  BOTTOM w0.121: R2430.2 243.23,53.58 242.17,53.58 241.95,53.36 v2(241.38,53.36) 241.31,53.36 241.16,53.51 240.84,53.51 240.7,53.65 239.7,53.65 239.24,54.11
CMSRC: length 3.4
  TOP w0.229: R8804.1 277.53,36.76 277.55,36.74 v1(277.55,36.35) 277.55,35.85 276.57,34.86 U8800.3
COEX1_1.8V: length 6.1
  BOTTOM w0.102: T5309.1 301.16,102.78 300.03,102.78 299.55,102.3 299.55,100.46 299.5,100.41 CON5300.48
COEX2_1.8V: length 4.9
  BOTTOM w0.102: T5308.1 299.35,102.75 299.35,100.54 299,100.2 CON5300.46
COEX3_1.8V: length 6.9
  BOTTOM w0.102: T5306.1 300.21,104.45 299.14,103.39 299.14,100.68 298.5,100.03 CON5300.44
COMP_A: length 6.5
  BOTTOM w0.203: R8096.2 61.45,177.96 61.4,178.01 C8032.2 61.07,178.67 59.69,178.67 59.44,178.92 58.48,178.92 58.3,179.1 v1(57.87,179.1) 57.64,179.33 57.64,179.76 57.37,180.03 U8000.16
COMP_B: length 9.9
  BOTTOM w0.102: R8030.2 61.37,188.28 61.79,187.85 62.76,187.85 64.57,189.67 v1(64.57,190.3)
  BOTTOM w0.203: U8000.4 59.96,184.54 61.03,185.62 61.03,186.77 61.28,187.02 C8015.2 R8030.2
COMP_C: length 8.1
  BOTTOM w0.102: v1(46.56,183.67) 46.97,183.27 48.48,183.27 48.93,182.82 C8005.1
  BOTTOM w0.203: U8000.29 53.03,182.94 52.68,183.3 52.18,183.3 51.23,182.35 50.43,182.35 50,182.78 R8093.1 C8005.1
CORE_PLLVDD:
  vias: v1(139.83,78.47)
CORE_PLLVDD_GPU: length 71.2
  TOP w0.254: C7212.1 161.98,83.65 v5(162.19,83.45)
  TOP w0.457: v5(168.5,104.35) 168.69,104.16 C7213.1
  IN4 w0.35: 151.76,83.62 151.76,82.73 150.53,81.49 145.11,81.49 144.26,82.35 140.69,82.35 138.83,80.49 v2(135.3,80.49) ; 151.76,84.39 151.76,91.82 v3(151.19,92.4) ; v5(168.5,104.35) 168.55,104.35 169.1,103.8 170.2,103.8 171.47,102.52 171.47,85.37 170.1,84 162.8,84 162.25,83.45 v5(162.19,83.45) 162.15,83.45 161.6,84 152.36,84
  BOTTOM w0.254: v5(162.19,83.45) 162.19,83.29 U7000.AF11 ; U7000.BB24 151,92.4 v3(151.19,92.4)
  BOTTOM w0.305: U7000.U42 168.5,104.5 v5(168.5,104.35)
  vias: v1(136.1,80.65)
CPU_PECI: length 396.6
  TOP w0.121: v2(227.51,73.06) 227.51,73.87 R0746.2
  IN2 w0.083: v2(120.28,125.76) 124.06,125.76 125.51,124.31 125.51,122.82 126.78,121.55 126.78,98.23 126.07,97.52 126.07,76.97 129.52,73.52 129.52,71.91 130.13,71.3 130.13,54.41 136.73,47.81 136.73,42.04 v2(136.33,41.64)
  IN3 w0.083: v2(136.33,41.64) 136.47,41.49 143.73,41.49 149.91,35.32 162.22,35.32 162.61,35.7 192.51,35.7 194.55,37.74 195.07,37.74 205.18,47.86 205.18,53.12 203.88,54.42 203.88,55.69 204.13,55.94 205.85,55.94 208.2,58.28 209.92,58.28 210.97,59.34 210.97,60.02 211.54,60.58 211.54,61.69 214.51,64.66 217.47,64.66 218.66,65.86 218.66,66.91 219.83,68.08 220.2,68.08 223.24,71.12 224.16,71.12 225.44,72.4 226.85,72.4 v2(227.51,73.06) 227.51,69.93 226.8,69.22 223.22,69.22 221.9,67.9 221.9,66.28 221.01,65.39 219.03,65.39 217.66,64.02 214.74,64.02 214.63,64.01 212.13,61.51 212.13,60.39 211.54,59.8 211.54,59.11 208.29,55.85 208.29,48.89 207.15,47.76 207.15,46.76 198.54,38.14 197.67,38.14 195.71,36.18 195.7,36.19 195.19,36.19 193.15,34.15 164.37,34.15 163.66,33.43 v2(163.66,32.67)
  IN4 w0.083: v2(65.54,133.99) 65.54,136.6 67.34,138.4 72.66,138.4 72.79,138.27 88.33,138.27 89.35,139.29 106.54,139.29 108.54,137.29 111.46,137.29 112.87,135.88 112.87,130.02 112.5,129.64 112.5,126.96 112.88,126.58 115.75,126.58 116.36,127.18 118.85,127.18 v2(120.28,125.76)
  BOTTOM w0.076: 73.32,126.87 73.36,126.83 74.13,126.83 U0300.BT34
  BOTTOM w0.121: v2(163.66,32.67) 162.66,31.67 162.66,27.88 161.86,27.08 160.92,27.08 160.57,26.73 159.32,26.73 158.96,27.08 R0733.2 ; 73.32,126.87 73.15,127.04 73.15,127.66 73.25,127.76 73.25,129.5 70.06,132.7 v1(67.82,132.7) 66.83,132.7 v2(65.54,133.99)
CPU_PM_DOWN: length 7.9
  BOTTOM w0.076: U0300.BP31 75.36,125.91 74.91,125.91 74.71,126.12 74.71,126.5 74.57,126.64 73.22,126.64
  BOTTOM w0.121: 73.22,126.64 72.68,127.18 72.68,127.9 71.35,129.22 v1(71.35,129.7) 70.97,129.7 70.92,129.65 R0731.2
CPU_THERM#: length 273.7
  TOP w0.102: v2(289.9,129.09) 290.28,129.09 290.58,129.39 R5011.2 290.58,130.46 290.77,130.64 291.16,130.64 291.31,130.8 291.31,131.06 291.16,131.21 U5000.4 ; v2(184.16,39.45) 184.36,39.25 184.36,38.21 184.18,38.03 R9214.1 ; SR5001.1 126.34,28.56 125.99,28.2 125.99,27.7 125.4,27.11 123.17,27.11 122.51,27.77 121.48,27.77 120.15,26.44 v2(120.15,23.73)
  IN1 w0.102: v2(156.04,18.04) 155.07,17.08 147.66,17.08 144.62,14.04 135.48,14.04 133.74,15.78 133.74,15.79 132.85,16.67 132.32,16.67 130.33,18.65 130.33,18.77 126.59,22.51 121.75,22.51 120.96,23.3 120.58,23.3 v2(120.15,23.73)
  IN2 w0.102: v2(279.1,106.84) 278.42,106.84 268.36,96.78 265.66,96.78 263.95,95.06 261.28,95.06 260.62,94.39 258.95,94.39 258.21,93.65 258.21,91.58 256.25,89.62 253.98,89.62 253.54,89.18 253.25,89.18 250.95,86.88 246.46,86.88 243.65,84.06 242.21,84.06 241.41,83.25 241.41,81.75 238.47,78.81 215.47,78.81 208.7,72.04 205.9,72.04 200.26,66.4 200.26,64.19 199.62,63.56 v2(199.62,62.47)
  BOTTOM w0.102: v2(156.04,18.04) 156.84,18.84 159.63,18.84 160.85,17.62 166.35,17.62 168.62,19.9 168.62,20.95 169.04,21.37 170.71,21.37 171.22,21.88 171.22,22.38 172.55,23.71 172.55,23.88 175.19,26.52 177.02,26.52 178.16,27.66 178.16,28.57 184.16,34.56 v2(184.16,39.45) 186.41,39.45 191.82,44.86 198.48,44.86 v1(198.71,45.09) 199.45,45.83 199.45,50.2 199.83,50.58 199.83,52.92 200.34,53.43 200.34,61.75 v2(199.62,62.47) ; v2(289.9,129.09) 285.34,124.53 285.34,116.96 283.29,114.92 283.29,113.6 283.61,113.28 283.61,109.52 283.16,109.07 282.1,109.07 281.25,108.23 U5003.3 281.25,106.97 280.86,106.57 280.56,106.57 R5018.2 279.51,107.25 v2(279.1,106.84)
CPU_VIDALERT#: length 7.1
  TOP w0.076: v3(78.95,125.79) 79.08,125.66 79.08,124.47 v1(78.52,123.91) 78.05,124.38 75.85,124.38 75.35,124.87 R0717.1
  BOTTOM w0.102: U0300.BH31 79.27,125.46 v3(78.95,125.79)
CPU_VRON: length 179.3
  TOP w0.102: SR8011.1 v2(58.12,189.94)
  IN1 w0.102: v2(119.87,75.34) 121.51,75.34 123.55,77.38 123.55,77.72 123.25,78.02 123.09,78.02 121.69,79.43 121.69,82.53 122.28,83.12 123.04,83.12 123.74,83.82 123.74,97.91 124.54,98.71 124.54,103.27 124.26,103.54 124.26,131.32 123.88,131.7 123.88,134.15 125.14,135.4 125.14,145.33 124.13,146.34 121.83,146.34 118.7,149.47 118.7,153.76 118.34,154.12 118.34,154.71 114.78,158.27 109.59,158.27 104.32,163.54 104.32,166.35 102.17,168.51 102.17,177.64 99.87,179.94 99.11,179.94 97.08,181.97 96.27,181.97 94.34,183.9 88.47,183.9 86.54,185.83 81.08,185.83 79.99,186.93 66.4,186.93 64.37,188.96 59.1,188.96 v2(58.12,189.94)
  BOTTOM w0.102: v2(119.87,75.34) 118.47,75.34 116.01,77.81 v1(116.01,78.72) SR0703.2
CPU_VRON_PWR: length 2.8
  TOP w0.102: JP9300.2 59.45,189.63 v2(59.56,189.74) 59.87,190.06 T9300.1
  BOTTOM w0.102: SR8010.1 59.52,189.7 v2(59.56,189.74)
CPU_VTT_CNTL: length 8.8
  BOTTOM w0.102: R0728.1 67.82,107.91 67.87,107.86 v1(68.33,107.86) 68.33,108.34 69.86,109.86 70.35,109.86 71.8,111.31 74.28,111.31 U0300.BT13
CPU_XDP_HOOK0: length 19.7
  BOTTOM w0.102: XDP4400.39 59.68,136.95 58.46,135.73 58.46,129.01 58.93,128.54 58.93,126.71 R4404.1 58.16,125.94 58.01,125.94 R4405.1 R4406.1 58.88,125.09 58.88,123.55 60.23,122.21 v1(60.23,121.52)
CPU_XDP_HOOK2: length 15.6
  BOTTOM w0.102: XDP4400.45 59.99,135.45 58.87,134.33 58.87,129.63 59.54,128.95 59.54,128.39 60.03,127.91 60.03,127.58 59.98,127.52 59.98,126.72 R4409.2 60.66,126.03 60.66,125.92 R4416.1 60.61,125.14 60.61,124.29 61.53,123.37 v1(62.11,123.37)
CPUFAN_PWM_C_L: length 39.4
  BOTTOM w0.102: CON5000.1 49.05,121.6 48.65,122 46.97,122 45.85,120.89 42.68,120.89 41.87,120.07 41.87,113.51 44.44,110.93 56.27,110.93 56.88,111.54 56.88,113.21 57.53,113.87 D5000.2 58.8,113.87 58.87,113.93 R5006.2
CPUFAN_PWM_C_R: length 12.2
  TOP w0.102: D5002.2 268.19,86.43 v1(268.32,86.3) 268.32,85.62 R5010.2 268.7,85.27 v2(268.99,85.57)
  BOTTOM w0.102: v2(268.99,85.57) 268.99,84.99 268.47,84.46 264.09,84.46 263.67,84.88 CON5001.1
CPUFAN_TACH_C_L: length 45.3
  BOTTOM w0.102: D5001.1 D5001.2 58.19,111.19 R5005.2 57.95,111.88 58.19,112.11 D5000.1 57.7,112.57 57.26,112.12 57.26,111.39 56.22,110.34 41.76,110.34 41.15,110.95 41.15,120.02 42.27,121.14 45.82,121.14 46.89,122.21 48.55,122.21 49.76,123.43 51.16,123.43 52.63,121.96 CON5000.3
CPUFAN_TACH_C_R: length 17.9
  TOP w0.102: v2(255.88,84.57) 255.88,85 257.31,86.43 259.84,86.43 259.88,86.47 v1(260.12,86.47) 260.89,87.25 D5003.2 D5003.1 263.17,87.25 263.54,87.61 R5009.2 264.41,87.61 264.53,87.73 D5002.1
  BOTTOM w0.102: CON5001.3 261.17,84.82 259.72,83.37 258.84,83.37 258.71,83.24 256.95,83.24 256.09,84.1 256.09,84.36 v2(255.88,84.57)
CPUPWRGD: length 369.6
  TOP w0.121: v1(57.44,129.09) 57.44,128.63 v2(57.61,128.45)
  IN1 w0.083: v3(73.49,125.2) 73.01,125.2 72.62,125.58 72.62,127.11 71.71,128.02 70.72,128.02 70.29,128.45 68.64,128.45 68.26,128.07 66.43,128.07 64.67,126.32 57.86,126.32 57.03,127.15 57.03,128.02 57.46,128.45 v2(57.61,128.45)
  IN2 w0.083: v2(57.61,128.45) 56.98,127.82 56.98,127.08 54.18,124.28 54.18,113.69 53.04,112.55 50.76,112.55 50.22,113.09 47.71,113.09 v2(47.53,113.27)
  IN3 w0.083: v2(230.82,75.35) 229.51,74.05 225.78,74.05 223.77,72.04 221.62,72.04 217.55,67.97 217.55,66.84 216.82,66.12 213.96,66.12 213.36,65.53 213.36,64.82 210.88,62.34 210.43,62.34 208.81,60.71 208.27,60.71 206.58,59.03 203.68,59.03 202.67,58.02 202.67,53.54 203.18,53.03 203.18,47.34 197.53,41.69 196.97,41.69 192.78,37.51 188.33,37.51 187.45,36.63 162.22,36.63 161.83,36.24 151.4,36.24 149.54,38.1 148.44,38.1 144.12,42.42 135.98,42.42 135.04,41.48 133.12,41.48 130.03,38.39 122.49,38.39 118.94,34.84 103.42,34.84 97.49,28.91 61.47,28.91 58.6,26.04 45.07,26.04 36.1,35.01 36.1,38.44 33.9,40.63 33.9,43.73 35.06,44.89 35.06,53.72 34.07,54.7 34.07,58.34 34.84,59.11 34.84,71.14 49.72,86.01 49.72,92.38 46.77,95.33 46.77,112.5 v2(47.53,113.27)
  BOTTOM w0.121: SR2406.1 231.04,75.12 v2(230.82,75.35) ; v3(73.49,125.2) 73.62,125.2 73.97,125.56 U0300.BT31 ; v2(57.61,128.45) 58.05,128.45 58.51,127.99 R4404.2
