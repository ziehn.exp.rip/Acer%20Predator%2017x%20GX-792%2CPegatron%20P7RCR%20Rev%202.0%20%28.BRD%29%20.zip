# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Nets (continued)
GND_LED: CON1.1 CON1.9(SIDE1) CON1.10(SIDE2) H804.1 H805.1 LC800.2 LC801.2 LC802.2 LC803.2 LQ800.2(SOURCE) LQ801.2(SOURCE) LQ802.2(SOURCE) LQ803.1(S) LQ803.4(S)
GND_RT8812A: R8901.1 R8910.2 SR8906.1
GND_RT8813A: C9720.1 R9736.1 SR9705.1
GND_SIGNAL: C8808.1 C8809.1 C8814.1 C8816.1 C8824.2 C8825.1 C8826.1 R8807.1 R8808.1 R8813.1 SR8806.2 U8800.29(GND_2) U8800.30(GND_3) U8800.31(GND_4) U8800.32(GND_5) U8800.33(GND_6)
VCC: C80108.1 SR8000.1 U8000.42(VCC)
VCC0P9_CIO: C1178.1 C1179.1 C1180.1 U1101.R8(VCC0P9_CIO_3) U1101.R9(VCC0P9_CIO_4) U1101.R11(VCC0P9_CIO_1) U1101.R12(VCC0P9_CIO_2)
VCC0P9_DP: C1167.1 C1168.1 C1169.1 C1170.1 C1171.1 C1172.1 C1173.1 U1101.L6(VCC0P9_ANA_DPSRC_1) U1101.L8(VCC0P9_DP_3) U1101.L11(VCC0P9_DP_1) U1101.L12(VCC0P9_DP_2) U1101.M6(VCC0P9_ANA_DPSRC_2) U1101.M8(VCC0P9_DP_4) U1101.T11(VCC0P9_DP_5) U1101.T12(VCC0P9_DP_6) U1101.V11(VCC0P9_ANA_DPSNK_1) U1101.V12(VCC0P9_ANA_DPSNK_2) U1101.V13(VCC0P9_ANA_DPSNK_3)
VCC0P9_LVR: C1163.1 C1164.1 C1165.1 C1166.1 U1101.F18(VCC0P9_LVR_1) U1101.H11(VCC0P9_LVR_SENSE) U1101.H18(VCC0P9_LVR_2) U1101.J11(VCC0P9_LVR_3)
VCC0P9_PCIE: C1174.1 C1175.1 C1176.1 C1177.1 U1101.L18(VCC0P9_ANA_PCIE_2_1) U1101.L19(VCC0P9_ANA_PCIE_1_1) U1101.M13(VCC0P9_PCIE_1) U1101.M15(VCC0P9_PCIE_2) U1101.M16(VCC0P9_PCIE_3) U1101.M18(VCC0P9_ANA_PCIE_2_2) U1101.N18(VCC0P9_ANA_PCIE_2_3) U1101.N19(VCC0P9_ANA_PCIE_1_2)
VCC0P9_SVR: C1148.1 C1149.1 C1150.1 C1151.1 C1152.1 C1153.1 C1154.1 C1159.1 C1160.1 C1161.1 L1101.2 U1101.E12(VCC0P9_SVR_ANA_1) U1101.E13(VCC0P9_SVR_ANA_2) U1101.F11(VCC0P9_SVR_ANA_3) U1101.F12(VCC0P9_SVR_ANA_4) U1101.F13(VCC0P9_SVR_ANA_5) U1101.F15(VCC0P9_SVR_ANA_6) U1101.J9(VCC0P9_SVR_SENSE) U1101.L9(VCC0P9_SVR_1) U1101.M9(VCC0P9_SVR_2)
VCC0P9_USB: C1181.1 C1182.1 U1101.R15(VCC0P9_USB_1) U1101.R16(VCC0P9_USB_2)
VCCGT_VCCSENSE: C8013.1 C8023.1 R0903.1 R8019.2 R8020.1 U0300.AH38(VCCGT_SENSE)
VCCGT_VSSSENSE: C8022.1 C8023.2 R0902.1 R8027.1 R8089.1 U0300.AH37(VSSGT_SENSE)
VCCIO_BST: R9400.2 U9400.10(BST)
VCCIO_BST_R: C9405.2 R9400.1
VCCIO_EN: C9411.1 D9400.1(ANODE) R9403.2 U9400.15(EN2)
VCCIO_FB: R9405.2 R9406.1 R9407.2 U9400.13(FB)
VCCIO_FB_R: JP9401.1 R9405.1
VCCIO_LX: C9405.1 L9400.1 R9401.2 R9408.1 T9400.1 U9400.9(SW)
VCCIO_O: C9406.1 C9407.1 C9408.1 C9409.1 C9410.1 C9416.1 JP9400.2 JP9401.2 JP9402.1 L9400.2 U9400.6(VDDQ)
VCCIO_RC: C9412.1 R9401.1
VCCSA_VCCSENSE: C8001.1 C8006.2 R8075.1 SR8014.2 U0300.M38(VCCSA_SENSE)
VCCSA_VSSSENSE: C8001.2 C8003.2 R8033.1 U0300.M37(VSSSA_SENSE) U8000.31(RTN_C)
VCCST_PG: R0729.1 R0730.1 R4405.2 U0702.4(Y)
VCCST_PG_R: R0730.2 U0300.H13(VCCST_PWRGD)
VCCST_PWRGD: R0751.1 R0756.2 SR0703.1 U0702.2(A) U0703.4(Y)
VDD18: C7533.1 C75144.1 C75145.1 C75146.1 C75147.1 C75148.1 C75149.1 C75150.1 C75151.1 C75152.1 C75153.1 C75154.1 C75155.1 R7505.2 U7000.AM10(VDD18_1) U7000.AM11(VDD18_2) U7000.AN10(VDD18_3) U7000.AN11(VDD18_4) U7000.AR10(VDD18_5) U7000.AR11(VDD18_6) U7000.AT10(VDD18_7) U7000.AT11(VDD18_8) U7000.AV10(VDD18_9) U7000.AV11(VDD18_10) U7000.AW10(VDD18_11) U7000.AW11(VDD18_12)
VDD_1P2V: C1301.1 C1302.1 C1303.1 C1304.1 C1313.1 C1317.1 C1319.1 C1322.1 R1302.2 U1301.12(VDD_1) U1301.19(VDD_2) U1301.20(VDD_3) U1301.31(VDD_5) U1301.40(VDD_4) U1302.6(VOUT)
VIN: C80107.1 SR8001.1 U8000.41(VIN)
15_17_ID: CON5602.28 R2309.2 U2000.AN36(GPP_D1)
+1P2V: C0701.1 C1323.1 C1324.1 C8325.1 C8326.1 JP1001.1 JP1601.1 JP1701.1 JP8302.2 JP8305.2 JP8306.2 JP8307.2 R1302.1 R2452.2 R5710.1 SR1002.1 U0701.5(VCC) U1302.2(VIN)
+1P2V_CPU: C1007.1 C1008.1 C1009.1 C1010.1 C1011.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 JP1001.2 SR1001.2 U0300.AA6(VDDQ_1) U0300.AE12(VDDQ_2) U0300.AF5(VDDQ_3) U0300.AF6(VDDQ_4) U0300.AG5(VDDQ_5) U0300.AG9(VDDQ_6) U0300.AJ12(VDDQ_7) U0300.AL11(VDDQ_8) U0300.AP6(VDDQ_9) U0300.AP7(VDDQ_10) U0300.AR6(VDDQ_12) U0300.AR12(VDDQ_11) U0300.AT12(VDDQ_13) U0300.AW6(VDDQ_14) U0300.AY6(VDDQ_15) U0300.J5(VDDQ_16) U0300.J6(VDDQ_17) U0300.K6(VDDQ_19) U0300.K12(VDDQ_18) U0300.L6(VDDQ_21) U0300.L12(VDDQ_20) U0300.R6(VDDQ_22) U0300.T6(VDDQ_23) U0300.W6(VDDQ_24)
+1P2V_DUAL: C1610.2 C1616.1 C1617.1 C1618.1 C1710.2 C1717.1 C1801.1 C1802.1 C1803.1 C1804.1 C1805.1 C1806.1 C1807.1 C1808.1 C1809.1 C1810.1 C1811.1 C1812.1 C1813.1 C1814.1 C1815.1 C1816.1 C1817.1 C1818.1 C1819.1 C1820.1 C1821.1 C1822.1 C1823.1 C1824.1 C1825.1 C1826.1 C1827.1 C1828.1 C1829.1 C1830.1 C1831.1 C1832.1 C1833.1 C1834.1 C1835.1 C1836.1 C1837.1 C1838.1 C1839.1 C1840.1 C1841.1 C1842.1 C1843.1 C1844.1 C1845.1 C1846.1 C1847.1 C1848.1 C1849.1 C1850.1 C1851.1 C1852.1 C1853.1 C1854.1 C1855.1 C1856.1 C1857.1 C1858.1 C1859.1 C1860.1 C1861.1 C1862.1 C1863.1 C1864.1 CE1801.1 CE1802.1 CE1803.1 CE1804.1 CON1600.12(DM0_N/DBI0_N) CON1600.33(DM1_N/DBI_N) CON1600.54(DM2_N/DBI2_N) CON1600.75(DM3_N/DBI3_N) CON1600.96(DM8_N/DBI_N/NC) CON1600.111(VDD1) CON1600.112(VDD2) CON1600.117(VDD3) CON1600.118(VDD4) CON1600.123(VDD5) CON1600.124(VDD6) CON1600.129(VDD7) CON1600.130(VDD8) CON1600.135(VDD9) CON1600.136(VDD10) CON1600.141(VDD11) CON1600.142(VDD12) CON1600.147(VDD13) CON1600.148(VDD14) CON1600.153(VDD15) CON1600.154(VDD16) CON1600.159(VDD17) CON1600.160(VDD18) CON1600.163(VDD19) CON1600.178(DM4_N/DBI4_N) CON1600.199(DM5_N/DBI5_N) CON1600.220(DM6_N/DBI6_N) CON1600.241(DM7_N/DBI7_N) CON1601.12(DM0_N/DBI0_N) CON1601.33(DM1_N/DBI_N) CON1601.54(DM2_N/DBI2_N) CON1601.75(DM3_N/DBI3_N) CON1601.96(DM8_N/DBI_N/NC) CON1601.111(VDD1) CON1601.112(VDD2) CON1601.117(VDD3) CON1601.118(VDD4) CON1601.123(VDD5) CON1601.124(VDD6) CON1601.129(VDD7) CON1601.130(VDD8) CON1601.135(VDD9) CON1601.136(VDD10) CON1601.141(VDD11) CON1601.142(VDD12) CON1601.147(VDD13) CON1601.148(VDD14) CON1601.153(VDD15) CON1601.154(VDD16) CON1601.159(VDD17) CON1601.160(VDD18) CON1601.163(VDD19) CON1601.178(DM4_N/DBI4_N) CON1601.199(DM5_N/DBI5_N) CON1601.220(DM6_N/DBI6_N) CON1601.241(DM7_N/DBI7_N) CON1700.12(DM0_N/DBI0_N) CON1700.33(DM1_N/DBI_N) CON1700.54(DM2_N/DBI2_N) CON1700.75(DM3_N/DBI3_N) CON1700.96(DM8_N/DBI_N/NC) CON1700.111(VDD1) CON1700.112(VDD2) CON1700.117(VDD3) CON1700.118(VDD4) CON1700.123(VDD5) CON1700.124(VDD6) CON1700.129(VDD7) CON1700.130(VDD8) CON1700.135(VDD9) CON1700.136(VDD10) CON1700.141(VDD11) CON1700.142(VDD12) CON1700.147(VDD13) CON1700.148(VDD14) CON1700.153(VDD15) CON1700.154(VDD16) CON1700.159(VDD17) CON1700.160(VDD18) CON1700.163(VDD19) CON1700.178(DM4_N/DBI4_N) CON1700.199(DM5_N/DBI5_N) CON1700.220(DM6_N/DBI6_N) CON1700.241(DM7_N/DBI7_N) CON1701.12(DM0_N/DBI0_N) CON1701.33(DM1_N/DBI_N) CON1701.54(DM2_N/DBI2_N) CON1701.75(DM3_N/DBI3_N) CON1701.96(DM8_N/DBI_N/NC) CON1701.111(VDD1) CON1701.112(VDD2) CON1701.117(VDD3) CON1701.118(VDD4) CON1701.123(VDD5) CON1701.124(VDD6) CON1701.129(VDD7) CON1701.130(VDD8) CON1701.135(VDD9) CON1701.136(VDD10) CON1701.141(VDD11) CON1701.142(VDD12) CON1701.147(VDD13) CON1701.148(VDD14) CON1701.153(VDD15) CON1701.154(VDD16) CON1701.159(VDD17) CON1701.160(VDD18) CON1701.163(VDD19) CON1701.178(DM4_N/DBI4_N) CON1701.199(DM5_N/DBI5_N) CON1701.220(DM6_N/DBI6_N) CON1701.241(DM7_N/DBI7_N) JP1601.2 JP1701.2 R1600.1 R1601.1 R1610.1 R1700.1 R1701.1 R1710.1
+2P5_3VS_DIM: C1604.1 C1605.2 C1606.1 C1607.1 C1608.2 C1609.1 C1704.1 C1705.2 C1706.1 C1707.2 C1708.1 C1709.1 CON1600.255(VDDSPD) CON1601.255(VDDSPD) CON1700.255(VDDSPD) CON1701.255(VDDSPD) R1602.1 R1603.1 R1604.1 R1605.1 R1606.1 R1607.1 R1608.1 R1609.1 R1704.1 R1705.1 R1706.1 R1707.1 R1708.1 R1709.1 R3103.2
+2P5VPP: C1897.1 C1898.1 C1899.1 C9514.1 C9515.1 C18100.1 C18101.1 C18102.1 C18103.1 C18104.1 C18105.1 C18106.1 C18107.1 C18108.1 C18109.1 C18110.1 C18111.1 C18112.1 CON1600.257(VPP1) CON1600.259(VPP2) CON1601.257(VPP1) CON1601.259(VPP2) CON1700.257(VPP1) CON1700.259(VPP2) CON1701.257(VPP1) CON1701.259(VPP2) JP9500.1 R1603.2 R5714.1 T9501.1 T9502.1
+A/D_DOCK_IN: C6003.2 C6004.2 C8800.1 D8801.1(ANODE1) L6001.2 L6002.2 L6003.2 Q8801.5(DRAIN1) R8801.2 R8805.2 R8835.2 T8808.1 T8809.1
+A/D_DOCK_IN_CON: C6002.2 C6005.2 CON6001.5 CON6001.6 CON6001.7 CON6001.8 L6001.1 L6002.1 L6003.1 R6002.2 R6008.2
+A/D_DOCK_IN_Q: C8801.2 Q8801.1(SOURCE1) Q8801.2(SOURCE2) Q8801.3(SOURCE3) Q8802.1(SOURCE1) Q8802.2(SOURCE2) Q8802.3(SOURCE3) R8804.2
+A/D_DOCK_IN_Q_Q: JP8801.1 Q8802.5(DRAIN1) R8800.1
+AC_BAT_SYS: C8053.1 C8059.1 C8064.1 C8087.1 C8088.1 C8089.1 C8090.1 C8101.1 C8102.1 C8103.1 C8104.1 C8105.1 C8106.1 C8132.1 C8202.1 C8203.1 C8214.1 C8215.1 C8304.1 C8305.1 C8306.1 C8307.1 C8323.1 C8324.1 C8601.1 C8612.1 C8613.1 C8803.1 C8804.2 C8810.1 C8811.1 C8812.1 C8813.1 C9400.1 C9401.1 C9402.1 C9500.1 C9501.1 C9502.1 C9604.1 C9605.1 C9610.1 C80005.1 C80006.1 C80027.1 C80070.1 C80074.1 C80076.1 C80079.1 C80091.1 CE8017.1 CE8018.1 CE8020.1 CE8021.1 CE8022.1 CE8023.1 CE8024.1 CE8025.1 CE8026.1 JP8802.1 Q8002.5(D) Q8102.5(D) Q8104.5(D) Q8300.5(D) Q8800.5(DRAIN1) Q8803.5(DRAIN1) Q8803.6(DRAIN2) Q8803.7(DRAIN3) Q8803.8(DRAIN4) R8300.1 R8800.2 R9702.1 SR4504.1 SR8001.2 T8806.1 T8807.1 U8001.8(VIN1) U8001.32(VIN2) U8002.8(VIN1) U8002.32(VIN2) U8003.8(VIN1) U8003.32(VIN2) U8004.8(VIN1) U8004.32(VIN2) U8006.8(VIN1) U8006.32(VIN2) U8100.12(VIN) U8200.1(VIN) U8601.1(VIN) U9400.1(VIN) U9500.1(VIN) U9600.1(VIN)
+AC_BAT_SYS_FBVDDQ: C8900.1 C8901.1 C8902.1 C8925.1 C8926.1 C8928.1 Q8901.5(D) Q8904.5(D) R8912.2 R9702.4 R9715.1 R9732.1
+AC_BAT_SYS_NVVDD: C8724.1 C8725.1 C8729.1 C8730.1 C8734.1 C8735.1 C8739.1 C8740.1 C8769.1 C8770.1 C8771.1 C8772.1 C8773.1 C8774.1 C8775.1 C8776.1 CE8716.1 CE8717.1 CE8718.1 CE8719.1 Q8702.5(D) Q8704.5(D) Q8706.5(D) Q8708.5(D) Q8709.5(D) Q8710.5(D) Q8711.5(D) Q8712.5(D) R8710.1 R9715.4
+AC_BAT_SYS_NVVDDS: C9702.1 C9710.1 C9714.1 C9717.1 C9718.1 C9722.1 C9724.1 Q9701.5(D) Q9704.5(D) R9700.2 R9732.4
+BAT: C8818.1 C8819.1 C8820.1 D8801.2(ANODE2) JP8800.1 JP8803.1 JP8805.1 R8809.2 T8804.1 T8805.1
+BAT_CON: CON6000.1 CON6000.2 CON6000.3 JP8800.2 JP8803.2 T6001.1 T6002.1 T8802.1 T8803.1
+BAT_R: C8802.2 JP8804.1 L8800.2 Q8800.1(SOURCE1) Q8800.2(SOURCE2) Q8800.3(SOURCE3) R8802.2 R8809.1
+CPU_VCC_OBS_AB: SR4402.2 XDP4400.44
+CPU_VCC_OBS_CD: SR4401.2 XDP4400.43
+FBVDDQ: C7506.1 C7507.1 C7508.1 C7509.1 C7510.1 C7511.1 C7512.1 C7513.1 C7514.1 C7515.1 C7516.1 C7517.1 C7518.1 C7519.1 C7520.1 C7521.1 C7522.1 C7523.1 C7551.1 C7552.1 C7553.1 C7554.1 C7555.1 C7556.1 C7557.1 C7558.1 C7559.1 C7560.1 C7561.1 C7562.1 C7563.1 C7564.1 C7565.1 C7566.1 C7567.1 C7568.1 C7569.1 C7570.1 C7571.1 C7572.1 C7573.1 C7574.1 C7575.1 C7576.1 C7577.1 C7605.1 C7606.1 C7607.1 C7608.1 C7609.1 C7610.1 C7611.1 C7612.1 C7613.1 C7614.1 C7615.1 C7616.1 C7617.1 C7618.1 C7619.1 C7620.1 C7621.1 C7622.1 C7623.1 C7624.1 C7625.1 C7626.1 C7627.1 C7628.1 C7629.1 C7630.1 C7631.1 C7632.1 C7633.1 C7636.1 C7637.1 C7638.1 C7639.1 C7640.1 C7641.1 C7642.1 C7643.1 C7644.1 C7645.1 C7646.1 C7647.1 C7648.1 C7649.1 C7650.1 C7651.1 C7652.1 C7653.1 C7654.1 C7655.1 C7656.1 C7657.1 C7658.1 C7659.1 C7660.1 C7663.1 C7664.1 C7665.1 C7666.1 C7705.1 C7706.1 C7707.1 C7708.1 C7709.1 C7710.1 C7711.1 C7712.1 C7713.1 C7714.1 C7715.1 C7716.1 C7717.1 C7718.1 C7719.1 C7720.1 C7721.1 C7722.1 C7723.1 C7724.1 C7725.1 C7726.1 C7727.1 C7728.1 C7729.1 C7730.1 C7731.1 C7732.1 C7733.1 C7734.1 C7737.1 C7738.1 C7739.1 C7740.1 C7741.1 C7742.1 C7743.1 C7744.1 C7745.1 C7746.1 C7747.1 C7748.1 C7749.1 C7750.1 C7751.1 C7752.1 C7753.1 C7754.1 C7755.1 C7756.1 C7757.1 C7758.1 C7759.1 C7760.1 C7763.1 C7764.1 C7765.1 C7766.1 C7805.1 C7806.1 C7807.1 C7808.1 C7809.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7815.1 C7816.1 C7817.1 C7818.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7824.1 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C7830.1 C7831.1 C7832.1 C7833.1 C7835.1 C7836.1 C7838.1 C7839.1 C7840.1 C7841.1 C7842.1 C7843.1 C7844.1 C7845.1 C7846.1 C7847.1 C7848.1 C7849.1 C7850.1 C7851.1 C7852.1 C7853.1 C7854.1 C7855.1 C7856.1 C7857.1 C7858.1 C7859.1 C7860.1 C7863.1 C7864.1 C7865.1 C7866.1 C7905.1 C7906.1 C7907.1 C7908.1 C7909.1 C7910.1 C7911.1 C7912.1 C7913.1 C7914.1 C7915.1 C7916.1 C7917.1 C7918.1 C7919.1 C7920.1 C7921.1 C7922.1 C7923.1 C7924.1 C7925.1 C7926.1 C7927.1 C7928.1 C7929.1 C7930.1 C7931.1 C7932.1 C7933.1 C7935.1 C7936.1 C7938.1 C7939.1 C7940.1 C7941.1 C7942.1 C7943.1 C7944.1 C7945.1 C7946.1 C7947.1 C7948.1 C7949.1 C7950.1 C7951.1 C7952.1 C7953.1 C7954.1 C7955.1 C7956.1 C7957.1 C7958.1 C7959.1 C7960.1 C7963.1 C7964.1 C7965.1 C7966.1 C8916.1 CE8900.1 CE8901.1 CE8902.1 CE8903.1 L8900.2 L8901.2 R5728.2 R5729.2 R5730.2 R7100.2 R7101.2 R7102.2 R7103.2 R7104.2 R7105.2 R7106.2 R7107.2 R7501.2 R7511.2 R7512.2 R7610.2 R7710.2 R7810.2 R7910.2 R8909.2 T8901.1 T8902.1 U7000.AA10(FBVDDQ_1) U7000.AA11(FBVDDQ_2) U7000.AA42(FBVDDQ_3) U7000.AA43(FBVDDQ_4) U7000.AC10(FBVDDQ_5) U7000.AC11(FBVDDQ_6) U7000.AC42(FBVDDQ_7) U7000.AC43(FBVDDQ_8) U7000.AD10(FBVDDQ_9) U7000.AD11(FBVDDQ_10) U7000.AD42(FBVDDQ_11) U7000.AD43(FBVDDQ_12) U7000.AF10(FBVDDQ_13) U7000.AF43(FBVDDQ_14) U7000.AG10(FBVDDQ_15) U7000.AG11(FBVDDQ_16) U7000.AG42(FBVDDQ_17) U7000.AG43(FBVDDQ_18) U7000.AJ10(FBVDDQ_19) U7000.AJ11(FBVDDQ_20) U7000.AJ42(FBVDDQ_21) U7000.AJ43(FBVDDQ_22) U7000.AK10(FBVDDQ_23) U7000.AK11(FBVDDQ_24) U7000.AK42(FBVDDQ_25) U7000.AK43(FBVDDQ_26) U7000.AM42(FBVDDQ_27) U7000.AM43(FBVDDQ_28) U7000.AN43(FBVDDQ_29) U7000.AR42(FBVDDQ_30) U7000.AR43(FBVDDQ_31) U7000.AT43(FBVDDQ_32) U7000.K12(FBVDDQ_33) U7000.K14(FBVDDQ_34) U7000.K15(FBVDDQ_35) U7000.K17(FBVDDQ_36) U7000.K18(FBVDDQ_37) U7000.K20(FBVDDQ_38) U7000.K21(FBVDDQ_39) U7000.K23(FBVDDQ_40) U7000.K24(FBVDDQ_41) U7000.K26(FBVDDQ_42) U7000.K27(FBVDDQ_43) U7000.K29(FBVDDQ_44) U7000.K30(FBVDDQ_45) U7000.K32(FBVDDQ_46) U7000.K33(FBVDDQ_47) U7000.K35(FBVDDQ_48) U7000.K36(FBVDDQ_49) U7000.K38(FBVDDQ_50) U7000.K39(FBVDDQ_51) U7000.K41(FBVDDQ_52) U7000.L14(FBVDDQ_53) U7000.L15(FBVDDQ_54) U7000.L18(FBVDDQ_55) U7000.L20(FBVDDQ_56) U7000.L21(FBVDDQ_57) U7000.L23(FBVDDQ_58) U7000.L24(FBVDDQ_59) U7000.L26(FBVDDQ_60) U7000.L27(FBVDDQ_61) U7000.L30(FBVDDQ_62) U7000.L32(FBVDDQ_63) U7000.L33(FBVDDQ_64) U7000.L35(FBVDDQ_65) U7000.L36(FBVDDQ_66) U7000.L39(FBVDDQ_67) U7000.M10(FBVDDQ_68) U7000.M43(FBVDDQ_69) U7000.P10(FBVDDQ_70) U7000.P11(FBVDDQ_71) U7000.P42(FBVDDQ_72) U7000.P43(FBVDDQ_73) U7000.R10(FBVDDQ_74) U7000.R11(FBVDDQ_75) U7000.R42(FBVDDQ_76) U7000.R43(FBVDDQ_77) U7000.U10(FBVDDQ_78) U7000.U11(FBVDDQ_79) U7000.U43(FBVDDQ_80) U7000.V10(FBVDDQ_81) U7000.V42(FBVDDQ_82) U7000.V43(FBVDDQ_83) U7000.Y10(FBVDDQ_84) U7000.Y11(FBVDDQ_85) U7000.Y42(FBVDDQ_86) U7000.Y43(FBVDDQ_87) U7600.A1(VDD_1) U7600.A2(VDDQ_2) U7600.A4(VDD_4) U7600.A11(VDD_2) U7600.A13(VDDQ_1) U7600.A14(VDD_3) U7600.B5(VDDQ_4) U7600.B10(VDDQ_3) U7600.C1(VDDQ_5) U7600.C2(VDDQ_8) U7600.C13(VDDQ_6) U7600.C14(VDDQ_7) U7600.D10(VDD_5) U7600.E1(VDDQ_9) U7600.E2(VDDQ_13) U7600.E4(VDDQ_14) U7600.E11(VDDQ_10) U7600.E13(VDDQ_11) U7600.E14(VDDQ_12) U7600.F5(VDDQ_16) U7600.F10(VDDQ_15) U7600.G1(VDD_6) U7600.G2(VDDQ_18) U7600.G13(VDDQ_17) U7600.G14(VDD_7) U7600.H3(VDDQ_20) U7600.H5(VDD_9) U7600.H10(VDD_8) U7600.H12(VDDQ_19) U7600.J1(VDD_10) U7600.J2(VDDQ_22) U7600.J13(VDDQ_21) U7600.J14(VDD_11) U7600.L1(VDD_12) U7600.L2(VDDQ_24) U7600.L13(VDDQ_23) U7600.L14(VDD_13) U7600.M3(VDDQ_26) U7600.M5(VDD_15) U7600.M10(VDD_14) U7600.M12(VDDQ_25) U7600.N1(VDD_16) U7600.N2(VDDQ_28) U7600.N13(VDDQ_27) U7600.N14(VDD_17) U7600.P5(VDDQ_30) U7600.P10(VDDQ_29) U7600.R1(VDDQ_31) U7600.R2(VDDQ_35) U7600.R4(VDDQ_36) U7600.R11(VDDQ_32) U7600.R13(VDDQ_33) U7600.R14(VDDQ_34) U7600.T10(VDD_18) U7600.U1(VDDQ_37) U7600.U2(VDDQ_40) U7600.U13(VDDQ_38) U7600.U14(VDDQ_39) U7600.V5(VDDQ_42) U7600.V10(VDDQ_41) U7600.W1(VDD_19) U7600.W2(VDDQ_44) U7600.W4(VDD_22) U7600.W11(VDD_20) U7600.W12(MF) U7600.W13(VDDQ_43) U7600.W14(VDD_21) U7601.A1(VDD_1) U7601.A2(VDDQ_2) U7601.A4(VDD_4) U7601.A11(VDD_2) U7601.A13(VDDQ_1) U7601.A14(VDD_3) U7601.B5(VDDQ_4) U7601.B10(VDDQ_3) U7601.C1(VDDQ_5) U7601.C2(VDDQ_8) U7601.C13(VDDQ_6) U7601.C14(VDDQ_7) U7601.D10(VDD_5) U7601.E1(VDDQ_9) U7601.E2(VDDQ_13) U7601.E4(VDDQ_14) U7601.E11(VDDQ_10) U7601.E13(VDDQ_11) U7601.E14(VDDQ_12) U7601.F5(VDDQ_16) U7601.F10(VDDQ_15) U7601.G1(VDD_6) U7601.G2(VDDQ_18) U7601.G13(VDDQ_17) U7601.G14(VDD_7) U7601.H3(VDDQ_20) U7601.H5(VDD_9) U7601.H10(VDD_8) U7601.H12(VDDQ_19) U7601.J1(VDD_10) U7601.J2(VDDQ_22) U7601.J13(VDDQ_21) U7601.J14(VDD_11) U7601.L1(VDD_12) U7601.L2(VDDQ_24) U7601.L13(VDDQ_23) U7601.L14(VDD_13) U7601.M3(VDDQ_26) U7601.M5(VDD_15) U7601.M10(VDD_14) U7601.M12(VDDQ_25) U7601.N1(VDD_16) U7601.N2(VDDQ_28) U7601.N13(VDDQ_27) U7601.N14(VDD_17) U7601.P5(VDDQ_30) U7601.P10(VDDQ_29) U7601.R1(VDDQ_31) U7601.R2(VDDQ_35) U7601.R4(VDDQ_36) U7601.R11(VDDQ_32) U7601.R13(VDDQ_33) U7601.R14(VDDQ_34) U7601.T10(VDD_18) U7601.U1(VDDQ_37) U7601.U2(VDDQ_40) U7601.U13(VDDQ_38) U7601.U14(VDDQ_39) U7601.V5(VDDQ_42) U7601.V10(VDDQ_41) U7601.W1(VDD_19) U7601.W2(VDDQ_44) U7601.W4(VDD_22) U7601.W11(VDD_20) U7601.W13(VDDQ_43) U7601.W14(VDD_21) U7700.A1(VDD_1) U7700.A2(VDDQ_2) U7700.A4(VDD_4) U7700.A11(VDD_2) U7700.A13(VDDQ_1) U7700.A14(VDD_3) U7700.B5(VDDQ_4) U7700.B10(VDDQ_3) U7700.C1(VDDQ_5) U7700.C2(VDDQ_8) U7700.C13(VDDQ_6) U7700.C14(VDDQ_7) U7700.D10(VDD_5) U7700.E1(VDDQ_9) U7700.E2(VDDQ_13) U7700.E4(VDDQ_14) U7700.E11(VDDQ_10) U7700.E13(VDDQ_11) U7700.E14(VDDQ_12) U7700.F5(VDDQ_16) U7700.F10(VDDQ_15) U7700.G1(VDD_6) U7700.G2(VDDQ_18) U7700.G13(VDDQ_17) U7700.G14(VDD_7) U7700.H3(VDDQ_20) U7700.H5(VDD_9) U7700.H10(VDD_8) U7700.H12(VDDQ_19) U7700.J1(VDD_10) U7700.J2(VDDQ_22) U7700.J13(VDDQ_21) U7700.J14(VDD_11) U7700.L1(VDD_12) U7700.L2(VDDQ_24) U7700.L13(VDDQ_23) U7700.L14(VDD_13) U7700.M3(VDDQ_26) U7700.M5(VDD_15) U7700.M10(VDD_14) U7700.M12(VDDQ_25) U7700.N1(VDD_16) U7700.N2(VDDQ_28) U7700.N13(VDDQ_27) U7700.N14(VDD_17) U7700.P5(VDDQ_30) U7700.P10(VDDQ_29) U7700.R1(VDDQ_31) U7700.R2(VDDQ_35) U7700.R4(VDDQ_36) U7700.R11(VDDQ_32) U7700.R13(VDDQ_33) U7700.R14(VDDQ_34) U7700.T10(VDD_18) U7700.U1(VDDQ_37) U7700.U2(VDDQ_40) U7700.U13(VDDQ_38) U7700.U14(VDDQ_39) U7700.V5(VDDQ_42) U7700.V10(VDDQ_41) U7700.W1(VDD_19) U7700.W2(VDDQ_44) U7700.W4(VDD_22) U7700.W11(VDD_20) U7700.W12(MF) U7700.W13(VDDQ_43) U7700.W14(VDD_21) U7701.A1(VDD_1) U7701.A2(VDDQ_2) U7701.A4(VDD_4) U7701.A11(VDD_2) U7701.A13(VDDQ_1) U7701.A14(VDD_3) U7701.B5(VDDQ_4) U7701.B10(VDDQ_3) U7701.C1(VDDQ_5) U7701.C2(VDDQ_8) U7701.C13(VDDQ_6) U7701.C14(VDDQ_7) U7701.D10(VDD_5) U7701.E1(VDDQ_9) U7701.E2(VDDQ_13) U7701.E4(VDDQ_14) U7701.E11(VDDQ_10) U7701.E13(VDDQ_11) U7701.E14(VDDQ_12) U7701.F5(VDDQ_16) U7701.F10(VDDQ_15) U7701.G1(VDD_6) U7701.G2(VDDQ_18) U7701.G13(VDDQ_17) U7701.G14(VDD_7) U7701.H3(VDDQ_20) U7701.H5(VDD_9) U7701.H10(VDD_8) U7701.H12(VDDQ_19) U7701.J1(VDD_10) U7701.J2(VDDQ_22) U7701.J13(VDDQ_21) U7701.J14(VDD_11) U7701.L1(VDD_12) U7701.L2(VDDQ_24) U7701.L13(VDDQ_23) U7701.L14(VDD_13) U7701.M3(VDDQ_26) U7701.M5(VDD_15) U7701.M10(VDD_14) U7701.M12(VDDQ_25) U7701.N1(VDD_16) U7701.N2(VDDQ_28) U7701.N13(VDDQ_27) U7701.N14(VDD_17) U7701.P5(VDDQ_30) U7701.P10(VDDQ_29) U7701.R1(VDDQ_31) U7701.R2(VDDQ_35) U7701.R4(VDDQ_36) U7701.R11(VDDQ_32) U7701.R13(VDDQ_33) U7701.R14(VDDQ_34) U7701.T10(VDD_18) U7701.U1(VDDQ_37) U7701.U2(VDDQ_40) U7701.U13(VDDQ_38) U7701.U14(VDDQ_39) U7701.V5(VDDQ_42) U7701.V10(VDDQ_41) U7701.W1(VDD_19) U7701.W2(VDDQ_44) U7701.W4(VDD_22) U7701.W11(VDD_20) U7701.W13(VDDQ_43) U7701.W14(VDD_21) U7800.A1(VDD_1) U7800.A2(VDDQ_2) U7800.A4(VDD_4) U7800.A11(VDD_2) U7800.A13(VDDQ_1) U7800.A14(VDD_3) U7800.B5(VDDQ_4) U7800.B10(VDDQ_3) U7800.C1(VDDQ_5) U7800.C2(VDDQ_8) U7800.C13(VDDQ_6) U7800.C14(VDDQ_7) U7800.D10(VDD_5) U7800.E1(VDDQ_9) U7800.E2(VDDQ_13) U7800.E4(VDDQ_14) U7800.E11(VDDQ_10) U7800.E13(VDDQ_11) U7800.E14(VDDQ_12) U7800.F5(VDDQ_16) U7800.F10(VDDQ_15) U7800.G1(VDD_6) U7800.G2(VDDQ_18) U7800.G13(VDDQ_17) U7800.G14(VDD_7) U7800.H3(VDDQ_20) U7800.H5(VDD_9) U7800.H10(VDD_8) U7800.H12(VDDQ_19) U7800.J1(VDD_10) U7800.J2(VDDQ_22) U7800.J13(VDDQ_21) U7800.J14(VDD_11) U7800.L1(VDD_12) U7800.L2(VDDQ_24) U7800.L13(VDDQ_23) U7800.L14(VDD_13) U7800.M3(VDDQ_26) U7800.M5(VDD_15) U7800.M10(VDD_14) U7800.M12(VDDQ_25) U7800.N1(VDD_16) U7800.N2(VDDQ_28) U7800.N13(VDDQ_27) U7800.N14(VDD_17) U7800.P5(VDDQ_30) U7800.P10(VDDQ_29) U7800.R1(VDDQ_31) U7800.R2(VDDQ_35) U7800.R4(VDDQ_36) U7800.R11(VDDQ_32) U7800.R13(VDDQ_33) U7800.R14(VDDQ_34) U7800.T10(VDD_18) U7800.U1(VDDQ_37) U7800.U2(VDDQ_40) U7800.U13(VDDQ_38) U7800.U14(VDDQ_39) U7800.V5(VDDQ_42) U7800.V10(VDDQ_41) U7800.W1(VDD_19) U7800.W2(VDDQ_44) U7800.W4(VDD_22) U7800.W11(VDD_20) U7800.W12(MF) U7800.W13(VDDQ_43) U7800.W14(VDD_21) U7801.A1(VDD_1) U7801.A2(VDDQ_2) U7801.A4(VDD_4) U7801.A11(VDD_2) U7801.A13(VDDQ_1) U7801.A14(VDD_3) U7801.B5(VDDQ_4) U7801.B10(VDDQ_3) U7801.C1(VDDQ_5) U7801.C2(VDDQ_8) U7801.C13(VDDQ_6) U7801.C14(VDDQ_7) U7801.D10(VDD_5) U7801.E1(VDDQ_9) U7801.E2(VDDQ_13) U7801.E4(VDDQ_14) U7801.E11(VDDQ_10) U7801.E13(VDDQ_11) U7801.E14(VDDQ_12) U7801.F5(VDDQ_16) U7801.F10(VDDQ_15) U7801.G1(VDD_6) U7801.G2(VDDQ_18) U7801.G13(VDDQ_17) U7801.G14(VDD_7) U7801.H3(VDDQ_20) U7801.H5(VDD_9) U7801.H10(VDD_8) U7801.H12(VDDQ_19) U7801.J1(VDD_10) U7801.J2(VDDQ_22) U7801.J13(VDDQ_21) U7801.J14(VDD_11) U7801.L1(VDD_12) U7801.L2(VDDQ_24) U7801.L13(VDDQ_23) U7801.L14(VDD_13) U7801.M3(VDDQ_26) U7801.M5(VDD_15) U7801.M10(VDD_14) U7801.M12(VDDQ_25) U7801.N1(VDD_16) U7801.N2(VDDQ_28) U7801.N13(VDDQ_27) U7801.N14(VDD_17) U7801.P5(VDDQ_30) U7801.P10(VDDQ_29) U7801.R1(VDDQ_31) U7801.R2(VDDQ_35) U7801.R4(VDDQ_36) U7801.R11(VDDQ_32) U7801.R13(VDDQ_33) U7801.R14(VDDQ_34) U7801.T10(VDD_18) U7801.U1(VDDQ_37) U7801.U2(VDDQ_40) U7801.U13(VDDQ_38) U7801.U14(VDDQ_39) U7801.V5(VDDQ_42) U7801.V10(VDDQ_41) U7801.W1(VDD_19) U7801.W2(VDDQ_44) U7801.W4(VDD_22) U7801.W11(VDD_20) U7801.W13(VDDQ_43) U7801.W14(VDD_21) U7900.A1(VDD_1) U7900.A2(VDDQ_2) U7900.A4(VDD_4) U7900.A11(VDD_2) U7900.A13(VDDQ_1) U7900.A14(VDD_3) U7900.B5(VDDQ_4) U7900.B10(VDDQ_3) U7900.C1(VDDQ_5) U7900.C2(VDDQ_8) U7900.C13(VDDQ_6) U7900.C14(VDDQ_7) U7900.D10(VDD_5) U7900.E1(VDDQ_9) U7900.E2(VDDQ_13) U7900.E4(VDDQ_14) U7900.E11(VDDQ_10) U7900.E13(VDDQ_11) U7900.E14(VDDQ_12) U7900.F5(VDDQ_16) U7900.F10(VDDQ_15) U7900.G1(VDD_6) U7900.G2(VDDQ_18) U7900.G13(VDDQ_17) U7900.G14(VDD_7) U7900.H3(VDDQ_20) U7900.H5(VDD_9) U7900.H10(VDD_8) U7900.H12(VDDQ_19) U7900.J1(VDD_10) U7900.J2(VDDQ_22) U7900.J13(VDDQ_21) U7900.J14(VDD_11) U7900.L1(VDD_12) U7900.L2(VDDQ_24) U7900.L13(VDDQ_23) U7900.L14(VDD_13) U7900.M3(VDDQ_26) U7900.M5(VDD_15) U7900.M10(VDD_14) U7900.M12(VDDQ_25) U7900.N1(VDD_16) U7900.N2(VDDQ_28) U7900.N13(VDDQ_27) U7900.N14(VDD_17) U7900.P5(VDDQ_30) U7900.P10(VDDQ_29) U7900.R1(VDDQ_31) U7900.R2(VDDQ_35) U7900.R4(VDDQ_36) U7900.R11(VDDQ_32) U7900.R13(VDDQ_33) U7900.R14(VDDQ_34) U7900.T10(VDD_18) U7900.U1(VDDQ_37) U7900.U2(VDDQ_40) U7900.U13(VDDQ_38) U7900.U14(VDDQ_39) U7900.V5(VDDQ_42) U7900.V10(VDDQ_41) U7900.W1(VDD_19) U7900.W2(VDDQ_44) U7900.W4(VDD_22) U7900.W11(VDD_20) U7900.W12(MF) U7900.W13(VDDQ_43) U7900.W14(VDD_21) U7901.A1(VDD_1) U7901.A2(VDDQ_2) U7901.A4(VDD_4) U7901.A11(VDD_2) U7901.A13(VDDQ_1) U7901.A14(VDD_3) U7901.B5(VDDQ_4) U7901.B10(VDDQ_3) U7901.C1(VDDQ_5) U7901.C2(VDDQ_8) U7901.C13(VDDQ_6) U7901.C14(VDDQ_7) U7901.D10(VDD_5) U7901.E1(VDDQ_9) U7901.E2(VDDQ_13) U7901.E4(VDDQ_14) U7901.E11(VDDQ_10) U7901.E13(VDDQ_11) U7901.E14(VDDQ_12) U7901.F5(VDDQ_16) U7901.F10(VDDQ_15) U7901.G1(VDD_6) U7901.G2(VDDQ_18) U7901.G13(VDDQ_17) U7901.G14(VDD_7) U7901.H3(VDDQ_20) U7901.H5(VDD_9) U7901.H10(VDD_8) U7901.H12(VDDQ_19) U7901.J1(VDD_10) U7901.J2(VDDQ_22) U7901.J13(VDDQ_21) U7901.J14(VDD_11) U7901.L1(VDD_12) U7901.L2(VDDQ_24) U7901.L13(VDDQ_23) U7901.L14(VDD_13) U7901.M3(VDDQ_26) U7901.M5(VDD_15) U7901.M10(VDD_14) U7901.M12(VDDQ_25) U7901.N1(VDD_16) U7901.N2(VDDQ_28) U7901.N13(VDDQ_27) U7901.N14(VDD_17) U7901.P5(VDDQ_30) U7901.P10(VDDQ_29) U7901.R1(VDDQ_31) U7901.R2(VDDQ_35) U7901.R4(VDDQ_36) U7901.R11(VDDQ_32) U7901.R13(VDDQ_33) U7901.R14(VDDQ_34) U7901.T10(VDD_18) U7901.U1(VDDQ_37) U7901.U2(VDDQ_40) U7901.U13(VDDQ_38) U7901.U14(VDDQ_39) U7901.V5(VDDQ_42) U7901.V10(VDDQ_41) U7901.W1(VDD_19) U7901.W2(VDDQ_44) U7901.W4(VDD_22) U7901.W11(VDD_20) U7901.W13(VDDQ_43) U7901.W14(VDD_21)
+FBVDDQ_ENABLE: D7402.3(CATHODE) R7482.1 SR8902.1
+LX: L3300.2 U3300.40(LX)
+NVVDD: C7501.1 C7502.1 C7503.1 C7504.1 C7505.1 C7531.1 C7532.1 C7534.1 C7535.1 C7536.1 C7537.1 C7538.1 C7539.1 C7540.1 C7541.1 C7542.1 C7543.1 C7544.1 C7545.1 C7546.1 C7547.1 C7548.1 C7549.1 C7550.1 C7578.1 C7579.1 C7580.1 C7581.1 C7582.1 C7583.1 C7584.1 C7585.1 C7586.1 C7587.1 C7588.1 C7589.1 C7591.1 C7592.1 C7593.1 C7594.1 C7595.1 C7596.1 C7597.1 C7598.1 C7599.1 C8752.2 C8753.2 C8754.2 C8755.2 C8756.2 C8757.2 C8758.2 C8759.2 C8760.2 C8761.2 C8762.2 C8763.2 C8764.2 C8765.2 C8766.2 C8767.2 C8781.2 C8782.2 C8783.2 C8784.2 C8785.2 C8786.2 C8787.2 C8788.2 C75100.1 C75101.1 C75102.1 C75103.1 C75105.1 C75106.1 C75107.1 C75108.1 C75109.1 C75110.1 C75111.1 C75112.1 C75113.1 C75114.1 C75115.1 C75116.1 C75117.1 C75118.1 C75119.1 C75120.1 C75121.1 C75122.1 C75123.1 C75160.1 C75161.1 CE8700.1 CE8701.1 CE8702.1 CE8703.1 CE8704.1 CE8705.1 CE8706.1 CE8707.1 CE8708.1 CE8709.1 CE8710.1 CE8711.1 JP8702.1 JP8704.1 JP8706.1 JP8708.1 L8701.2 L8702.2 L8703.2 L8704.2 R5742.2 R5743.2 R8748.1 U7000.AA14(VDD_1) U7000.AA15(VDD_2) U7000.AA16(VDD_3) U7000.AA17(VDD_4) U7000.AA18(VDD_5) U7000.AA19(VDD_6) U7000.AA20(VDD_7) U7000.AA21(VDD_8) U7000.AA22(VDD_9) U7000.AA23(VDD_10) U7000.AA24(VDD_11) U7000.AA25(VDD_12) U7000.AA26(VDD_13) U7000.AA27(VDD_14) U7000.AA28(VDD_15) U7000.AA29(VDD_16) U7000.AA30(VDD_17) U7000.AA31(VDD_18) U7000.AA32(VDD_19) U7000.AA33(VDD_20) U7000.AA34(VDD_21) U7000.AA35(VDD_22) U7000.AA36(VDD_23) U7000.AA37(VDD_24) U7000.AA38(VDD_25) U7000.AA39(VDD_26) U7000.AB13(VDD_27) U7000.AB40(VDD_28) U7000.AC19(VDD_29) U7000.AC20(VDD_30) U7000.AC21(VDD_31) U7000.AC22(VDD_32) U7000.AC23(VDD_33) U7000.AC30(VDD_34) U7000.AC31(VDD_35) U7000.AC32(VDD_36) U7000.AC33(VDD_37) U7000.AC34(VDD_38) U7000.AE14(VDD_39) U7000.AE15(VDD_40) U7000.AE16(VDD_41) U7000.AE17(VDD_42) U7000.AE18(VDD_43) U7000.AE19(VDD_44) U7000.AE20(VDD_45) U7000.AE21(VDD_46) U7000.AE22(VDD_47) U7000.AE23(VDD_48) U7000.AE24(VDD_49) U7000.AE25(VDD_50) U7000.AE26(VDD_51) U7000.AE27(VDD_52) U7000.AE28(VDD_53) U7000.AE29(VDD_54) U7000.AE30(VDD_55) U7000.AE31(VDD_56) U7000.AE32(VDD_57) U7000.AE33(VDD_58) U7000.AE34(VDD_59) U7000.AE35(VDD_60) U7000.AE36(VDD_61) U7000.AE37(VDD_62) U7000.AE38(VDD_63) U7000.AE39(VDD_64) U7000.AF13(VDD_65) U7000.AF30(VDD_66) U7000.AF31(VDD_67) U7000.AF32(VDD_68) U7000.AF33(VDD_69) U7000.AF34(VDD_70) U7000.AF40(VDD_71) U7000.AG13(VDD_72) U7000.AG19(VDD_73) U7000.AG20(VDD_74) U7000.AG21(VDD_75) U7000.AG22(VDD_76) U7000.AG23(VDD_77) U7000.AG40(VDD_78) U7000.AH14(VDD_79) U7000.AH15(VDD_80) U7000.AH16(VDD_81) U7000.AH17(VDD_82) U7000.AH18(VDD_83) U7000.AH19(VDD_84) U7000.AH20(VDD_85) U7000.AH21(VDD_86) U7000.AH22(VDD_87) U7000.AH23(VDD_88) U7000.AH24(VDD_89) U7000.AH25(VDD_90) U7000.AH26(VDD_91) U7000.AH27(VDD_92) U7000.AH28(VDD_93) U7000.AH29(VDD_94) U7000.AH30(VDD_95) U7000.AH31(VDD_96) U7000.AH32(VDD_97) U7000.AH33(VDD_98) U7000.AH34(VDD_99) U7000.AH35(VDD_100) U7000.AH36(VDD_101) U7000.AH37(VDD_102) U7000.AH38(VDD_103) U7000.AH39(VDD_104) U7000.AK19(VDD_105) U7000.AK20(VDD_106) U7000.AK21(VDD_107) U7000.AK22(VDD_108) U7000.AK23(VDD_109) U7000.AK30(VDD_110) U7000.AK31(VDD_111) U7000.AK32(VDD_112) U7000.AK33(VDD_113) U7000.AK34(VDD_114) U7000.AL13(VDD_115) U7000.AL40(VDD_116) U7000.AM14(VDD_117) U7000.AM15(VDD_118) U7000.AM16(VDD_119) U7000.AM17(VDD_120) U7000.AM18(VDD_121) U7000.AM19(VDD_122) U7000.AM20(VDD_123) U7000.AM21(VDD_124) U7000.AM22(VDD_125) U7000.AM23(VDD_126) U7000.AM24(VDD_127) U7000.AM25(VDD_128) U7000.AM26(VDD_129) U7000.AM27(VDD_130) U7000.AM28(VDD_131) U7000.AM29(VDD_132) U7000.AM30(VDD_133) U7000.AM31(VDD_134) U7000.AM32(VDD_135) U7000.AM33(VDD_136) U7000.AM34(VDD_137) U7000.AM35(VDD_138) U7000.AM36(VDD_139) U7000.AM37(VDD_140) U7000.AM38(VDD_141) U7000.AM39(VDD_142) U7000.AP19(VDD_143) U7000.AP20(VDD_144) U7000.AP21(VDD_145) U7000.AP22(VDD_146) U7000.AP23(VDD_147) U7000.AP30(VDD_148) U7000.AP31(VDD_149) U7000.AP32(VDD_150) U7000.AP33(VDD_151) U7000.AP34(VDD_152) U7000.AR13(VDD_153) U7000.AR40(VDD_154) U7000.AT14(VDD_155) U7000.AT15(VDD_156) U7000.AT16(VDD_157) U7000.AT17(VDD_158) U7000.AT18(VDD_159) U7000.AT19(VDD_160) U7000.AT20(VDD_161) U7000.AT21(VDD_162) U7000.AT22(VDD_163) U7000.AT23(VDD_164) U7000.AT24(VDD_165) U7000.AT25(VDD_166) U7000.AT26(VDD_167) U7000.AT27(VDD_168) U7000.AT28(VDD_169) U7000.AT29(VDD_170) U7000.AT30(VDD_171) U7000.AT31(VDD_172) U7000.AT32(VDD_173) U7000.AT33(VDD_174) U7000.AT34(VDD_175) U7000.AT35(VDD_176) U7000.AT36(VDD_177) U7000.AT37(VDD_178) U7000.AT38(VDD_179) U7000.AT39(VDD_180) U7000.AT42(VDD_181) U7000.AU43(VDD_182) U7000.AV19(VDD_183) U7000.AV20(VDD_184) U7000.AV21(VDD_185) U7000.AV22(VDD_186) U7000.AV23(VDD_187) U7000.AV30(VDD_188) U7000.AV31(VDD_189) U7000.AV32(VDD_190) U7000.AV33(VDD_191) U7000.AV34(VDD_192) U7000.AV42(VDD_193) U7000.AV43(VDD_194) U7000.AV44(VDD_195) U7000.AW13(VDD_196) U7000.AW40(VDD_197) U7000.AW42(VDD_198) U7000.AW43(VDD_199) U7000.AW44(VDD_200) U7000.AW45(VDD_201) U7000.AY14(VDD_202) U7000.AY18(VDD_203) U7000.AY22(VDD_204) U7000.AY26(VDD_205) U7000.AY27(VDD_206) U7000.AY31(VDD_207) U7000.AY35(VDD_208) U7000.AY39(VDD_209) U7000.AY43(VDD_210) U7000.AY45(VDD_211) U7000.BA43(VDD_212) U7000.BA44(VDD_213) U7000.BA45(VDD_214) U7000.BA46(VDD_215) U7000.BA47(VDD_216) U7000.BB38(VDD_217) U7000.BB39(VDD_218) U7000.BB45(VDD_219) U7000.BB46(VDD_220) U7000.BB47(VDD_221) U7000.BB48(VDD_222) U7000.BC38(VDD_223) U7000.BC39(VDD_224) U7000.BC40(VDD_225) U7000.BC41(VDD_226) U7000.BC45(VDD_227) U7000.BC47(VDD_228) U7000.BC49(VDD_229) U7000.BD39(VDD_230) U7000.BD41(VDD_231) U7000.BD46(VDD_232) U7000.BD47(VDD_233) U7000.BD48(VDD_234) U7000.BD49(VDD_235) U7000.BD50(VDD_236) U7000.BD51(VDD_237) U7000.BE41(VDD_238) U7000.BE42(VDD_239) U7000.BE43(VDD_240) U7000.BE46(VDD_241) U7000.BE47(VDD_242) U7000.BE48(VDD_243) U7000.BE49(VDD_244) U7000.BE50(VDD_245) U7000.BE51(VDD_246) U7000.BE52(VDD_247) U7000.BF42(VDD_248) U7000.BF44(VDD_249) U7000.BF45(VDD_250) U7000.BF47(VDD_251) U7000.BF49(VDD_252) U7000.BF51(VDD_253) U7000.BG43(VDD_254) U7000.BG44(VDD_255) U7000.BG45(VDD_256) U7000.BG46(VDD_257) U7000.BG47(VDD_258) U7000.BG48(VDD_259) U7000.BG49(VDD_260) U7000.BG50(VDD_261) U7000.BG51(VDD_262) U7000.BG52(VDD_263) U7000.BH44(VDD_264) U7000.BH45(VDD_265) U7000.BH47(VDD_266) U7000.BH48(VDD_267) U7000.BH49(VDD_268) U7000.BH50(VDD_269) U7000.BH51(VDD_270) U7000.BH52(VDD_271) U7000.BJ44(VDD_272) U7000.BJ45(VDD_273) U7000.BJ46(VDD_274) U7000.BJ47(VDD_275) U7000.BJ48(VDD_276) U7000.BJ49(VDD_277) U7000.BJ50(VDD_278) U7000.BJ51(VDD_279) U7000.BJ52(VDD_280) U7000.BK47(VDD_281) U7000.BK48(VDD_282) U7000.BK49(VDD_283) U7000.BK50(VDD_284) U7000.BK51(VDD_285) U7000.BK52(VDD_286) U7000.BL46(VDD_287) U7000.BL47(VDD_288) U7000.BL48(VDD_289) U7000.BL49(VDD_290) U7000.BL50(VDD_291) U7000.BL51(VDD_292) U7000.BL52(VDD_293) U7000.BM47(VDD_294) U7000.BM48(VDD_295) U7000.BM49(VDD_296) U7000.BM50(VDD_297) U7000.BM51(VDD_298) U7000.N14(VDD_299) U7000.N18(VDD_300) U7000.N22(VDD_301) U7000.N26(VDD_302) U7000.N27(VDD_303) U7000.N31(VDD_304) U7000.N35(VDD_305) U7000.N39(VDD_306) U7000.P13(VDD_307) U7000.P40(VDD_308) U7000.R19(VDD_309) U7000.R20(VDD_310) U7000.R21(VDD_311) U7000.R22(VDD_312) U7000.R23(VDD_313) U7000.R30(VDD_314) U7000.R31(VDD_315) U7000.R32(VDD_316) U7000.R33(VDD_317) U7000.R34(VDD_318) U7000.U14(VDD_319) U7000.U15(VDD_320) U7000.U16(VDD_321) U7000.U17(VDD_322) U7000.U18(VDD_323) U7000.U19(VDD_324) U7000.U20(VDD_325) U7000.U21(VDD_326) U7000.U22(VDD_327) U7000.U23(VDD_328) U7000.U24(VDD_329) U7000.U25(VDD_330) U7000.U26(VDD_331) U7000.U27(VDD_332) U7000.U28(VDD_333) U7000.U29(VDD_334) U7000.U30(VDD_335) U7000.U31(VDD_336) U7000.U32(VDD_337) U7000.U33(VDD_338) U7000.U34(VDD_339) U7000.U35(VDD_340) U7000.U36(VDD_341) U7000.U37(VDD_342) U7000.U38(VDD_343) U7000.U39(VDD_344) U7000.V13(VDD_345) U7000.V40(VDD_346) U7000.W19(VDD_347) U7000.W20(VDD_348) U7000.W21(VDD_349) U7000.W22(VDD_350) U7000.W23(VDD_351) U7000.W30(VDD_352) U7000.W31(VDD_353) U7000.W32(VDD_354) U7000.W33(VDD_355) U7000.W34(VDD_356)
+NVVDD_ADD: R8742.1 U8700.26(LLTH/I2C_ADD)
+NVVDD_COMP: C8717.1 C8718.1 U8700.30(COMP)
+NVVDD_CSCOMP: C8714.1 C8715.1 R8738.1 R8739.1 R8740.2 U8700.23(CSCOMP)
+NVVDD_CSN1: JP8702.2 R8730.2
+NVVDD_CSN2: JP8704.2 R8729.2
+NVVDD_CSN3: JP8706.2 R8728.2
+NVVDD_CSN4: JP8708.2 R8727.2
+NVVDD_CSP1: C8705.2 R8724.1 R8764.1 U8700.20(CSP1)
+NVVDD_CSP2: C8706.2 R8723.1 R8765.1 U8700.19(CSP2)
+NVVDD_CSP3: C8707.2 R8722.1 R8766.1 U8700.18(CSP3)
+NVVDD_CSP4: C8708.2 R8721.1 R8767.1 U8700.17(CSP4)
+NVVDD_CSP5: C8709.2 R8719.2 U8700.16(CSP5)
+NVVDD_CSP6: C8710.2 R8720.2 U8700.15(CSP6)
+NVVDD_CSP7: C8711.2 R8717.2 U8700.14(CSP7)
+NVVDD_CSP8: C8712.2 R8718.2 U8700.13(CSP8)
+NVVDD_CSREF: C8705.1 C8706.1 C8707.1 C8708.1 C8709.1 C8710.1 C8711.1 C8712.1 C8713.1 R8727.1 R8728.1 R8729.1 R8730.1 R8764.2 R8765.2 R8766.2 R8767.2 U8700.21(CSREF)
+NVVDD_CSSUM: C8714.2 C8715.2 R8731.1 R8732.1 R8733.1 R8734.1 R8737.2 U8700.22(CSSUM)
+NVVDD_DIFF: R8745.2 R8746.2 U8700.28(DIFF)
+NVVDD_DRON: U8700.12(DRON) U8702.3(EN) U8703.3(EN) U8704.3(EN) U8705.3(EN)
+NVVDD_FB: C8718.2 C8719.1 R8744.2 R8745.1 U8700.29(FB)
+NVVDD_FSW: R8743.1 U8700.27(FSW)
+NVVDD_ILIM: R8740.1 U8700.24(ILIM)
+NVVDD_IOUT: C8716.1 R8741.1 U8700.25(IOUT)
+NVVDD_PGOOD: SR8704.2 U8700.38(PGOOD)
+NVVDD_PSI: R8703.2 R8704.2 SR8702.2 U8700.37(PSI)
+NVVDD_PWM1: R8716.1 U8700.11(PWM1/PHTH4) U8702.2(PWM)
+NVVDD_PWM2: R8715.1 U8700.10(PWM2/PHTH3) U8703.2(PWM)
+NVVDD_PWM3: R8714.1 U8700.9(PWM3/PHTH2) U8704.2(PWM)
+NVVDD_PWM4: R8713.1 U8700.8(PWM4/PHTH1) U8705.2(PWM)
+NVVDD_PWM5: R8712.2 U8700.7(PWM5/LPC2)
+NVVDD_PWM6: R8711.2 U8700.6(PWM6/LPC1)
+NVVDD_PWM7: R8763.2 U8700.5(PWM7/OCP)
+NVVDD_PWM8: R8762.2 U8700.4(PWM8/SS)
+NVVDD_PWM_VID: SR8703.2 U8700.39(PWM_VID)
+NVVDD_REFADJ: R8705.1 U8700.40(VID_BUFF)
+NVVDD_REFIN: C8702.1 R8707.2 R8708.2 T8700.1 U8700.1(REFIN)
+NVVDD_SCL: R8701.2 SR8706.2 U8700.35(SCL)
+NVVDD_SDA: R8702.2 SR8701.2 U8700.34(SDA)
+NVVDD_SWN1: JP8701.2 R8724.2 R8731.2
+NVVDD_SWN2: JP8703.2 R8723.2 R8732.2
+NVVDD_SWN3: JP8705.2 R8722.2 R8733.2
+NVVDD_SWN4: JP8707.2 R8721.2 R8734.2
+NVVDD_VCC: C8721.1 R8749.2 U8700.33(VCC)
+NVVDD_VREF: C8703.1 R8706.1 U8700.2(VREF)
+NVVDD_VRMP: C8704.1 R8710.2 U8700.3(VRMP)
+NVVDD_VRON: C8768.1 D8701.1(ANODE) R8700.2 T8702.1 U8700.36(EN)
+NVVDD_VSN: C8720.2 R8747.2 SR8707.1 U8700.32(VSN)
+NVVDD_VSP: C8720.1 R8748.2 SR8708.1 U8700.31(VSP)
+NVVDDS: C7590.1 C9705.1 C9706.1 C75104.1 C75124.1 C75125.1 C75126.1 C75127.1 C75128.1 C75129.1 C75130.1 C75131.1 C75132.1 C75133.1 C75134.1 C75135.1 C75136.1 C75137.1 C75138.1 C75139.1 C75140.1 C75141.1 C75142.1 C75143.1 CE9701.1 CE9702.1 CE9703.1 CE9704.1 L9701.2 L9702.2 R5701.2 R5702.2 R5703.2 R5705.2 R5731.2 R9720.2 T9700.1 T9703.1 T9705.1 T9706.1 T9707.1 T9708.1 U7000.AC14(VDDS_1) U7000.AC15(VDDS_2) U7000.AC16(VDDS_3) U7000.AC17(VDDS_4) U7000.AC18(VDDS_5) U7000.AC24(VDDS_6) U7000.AC25(VDDS_7) U7000.AC26(VDDS_8) U7000.AC27(VDDS_9) U7000.AC28(VDDS_10) U7000.AC29(VDDS_11) U7000.AC35(VDDS_12) U7000.AC36(VDDS_13) U7000.AC37(VDDS_14) U7000.AC38(VDDS_15) U7000.AC39(VDDS_16) U7000.AF14(VDDS_17) U7000.AF15(VDDS_18) U7000.AF16(VDDS_19) U7000.AF17(VDDS_20) U7000.AF18(VDDS_21) U7000.AF24(VDDS_22) U7000.AF25(VDDS_23) U7000.AF26(VDDS_24) U7000.AG27(VDDS_25) U7000.AG28(VDDS_26) U7000.AG29(VDDS_27) U7000.AG35(VDDS_28) U7000.AG36(VDDS_29) U7000.AG37(VDDS_30) U7000.AG38(VDDS_31) U7000.AG39(VDDS_32) U7000.AK14(VDDS_33) U7000.AK15(VDDS_34) U7000.AK16(VDDS_35) U7000.AK17(VDDS_36) U7000.AK18(VDDS_37) U7000.AK24(VDDS_38) U7000.AK25(VDDS_39) U7000.AK26(VDDS_40) U7000.AK27(VDDS_41) U7000.AK28(VDDS_42) U7000.AK29(VDDS_43) U7000.AK35(VDDS_44) U7000.AK36(VDDS_45) U7000.AK37(VDDS_46) U7000.AK38(VDDS_47) U7000.AK39(VDDS_48) U7000.AP14(VDDS_49) U7000.AP15(VDDS_50) U7000.AP16(VDDS_51) U7000.AP17(VDDS_52) U7000.AP18(VDDS_53) U7000.AP24(VDDS_54) U7000.AP25(VDDS_55) U7000.AP26(VDDS_56) U7000.AP27(VDDS_57) U7000.AP28(VDDS_58) U7000.AP29(VDDS_59) U7000.AP35(VDDS_60) U7000.AP36(VDDS_61) U7000.AP37(VDDS_62) U7000.AP38(VDDS_63) U7000.AP39(VDDS_64) U7000.AV14(VDDS_65) U7000.AV15(VDDS_66) U7000.AV16(VDDS_67) U7000.AV17(VDDS_68) U7000.AV18(VDDS_69) U7000.AV24(VDDS_70) U7000.AV25(VDDS_71) U7000.AV26(VDDS_72) U7000.AV27(VDDS_73) U7000.AV28(VDDS_74) U7000.AV29(VDDS_75) U7000.AV35(VDDS_76) U7000.AV36(VDDS_77) U7000.AV37(VDDS_78) U7000.AV38(VDDS_79) U7000.AV39(VDDS_80) U7000.R14(VDDS_81) U7000.R15(VDDS_82) U7000.R16(VDDS_83) U7000.R17(VDDS_84) U7000.R18(VDDS_85) U7000.R24(VDDS_86) U7000.R25(VDDS_87) U7000.R26(VDDS_88) U7000.R27(VDDS_89) U7000.R28(VDDS_90) U7000.R29(VDDS_91) U7000.R35(VDDS_92) U7000.R36(VDDS_93) U7000.R37(VDDS_94) U7000.R38(VDDS_95) U7000.R39(VDDS_96) U7000.W14(VDDS_97) U7000.W15(VDDS_98) U7000.W16(VDDS_99) U7000.W17(VDDS_100) U7000.W18(VDDS_101) U7000.W24(VDDS_102) U7000.W25(VDDS_103) U7000.W26(VDDS_104) U7000.W27(VDDS_105) U7000.W28(VDDS_106) U7000.W29(VDDS_107) U7000.W35(VDDS_108) U7000.W36(VDDS_109) U7000.W37(VDDS_110) U7000.W38(VDDS_111) U7000.W39(VDDS_112)
+NVVDDS_BOOT1: SR9707.1 U9700.1(BOOT1)
+NVVDDS_BOOT1_R: C9701.1 SR9707.2
+NVVDDS_BOOT2: SR9709.1 U9700.15(BOOT2)
+NVVDDS_BOOT2_R: C9704.1 SR9709.2
+NVVDDS_LGATE1: Q9702.4(G) Q9703.4(G) U9700.19(LGATE1)
+NVVDDS_LGATE2: Q9705.4(G) Q9706.4(G) U9700.17(LGATE2)
+NVVDDS_PHASE1: C9701.2 L9701.1 Q9701.1(S_1) Q9701.2(S_2) Q9701.3(S_3) Q9702.5(D) Q9703.5(D) R9705.1 T9709.1 U9700.20(PHASE1)
+NVVDDS_PHASE2: C9704.2 L9702.1 Q9704.1(S_1) Q9704.2(S_2) Q9704.3(S_3) Q9705.5(D) Q9706.5(D) R9706.1 T9712.1 U9700.16(PHASE2)
+NVVDDS_PSI_R: R9724.2 R9725.1 SR9710.2 U9700.4(PSI)
+NVVDDS_REFADJ: R9723.1 U9700.6(REFADJ)
+NVVDDS_REFIN: C9703.1 R9713.2 R9716.2 U9700.7(REFIN)
+NVVDDS_UGATE1: SR9706.1 U9700.2(UGATE1)
+NVVDDS_UGATE1_R: Q9701.4(G) SR9706.2
+NVVDDS_UGATE2: SR9708.1 U9700.14(UGATE2)
+NVVDDS_UGATE2_R: Q9704.4(G) SR9708.2
+NVVDDS_VCCP: C9709.1 R9710.2 U9700.18(PVCC)
+NVVDDS_VREF: C9721.1 R9721.1 R9728.2 U9700.8(VREF)
+NVVDDS_VRON: C9713.1 D9700.1(ANODE) R9701.2 R9722.2 U9700.3(EN)
+RTC_POWER: C8117.1 D2801.1(ANODE1) JP8106.1 T8107.1 U8100.3(VREG3)
+V_SM_VREF_R: C8303.1 U8300.4(VTTREF)
+VCORE: C0900.1 C0901.1 C0902.1 C0903.1 C0904.1 C0905.1 C0906.1 C0907.1 C0908.1 C0909.1 C0910.1 C0911.1 C0912.1 C0913.1 C0914.1 C0915.1 C0916.1 C0917.1 C0918.1 C0919.1 C0920.1 C0921.1 C0922.1 C0923.1 C0924.1 C0925.1 C0926.1 C0927.1 C0928.1 C0929.1 C0930.1 C0931.1 C0932.1 C0933.1 C0934.1 C0935.1 C0936.1 C0937.1 C0938.1 C0939.1 C0940.1 C0941.1 C0942.1 C0943.1 C0944.1 C0945.1 C0946.1 C0947.1 C0948.1 C0949.1 C0950.1 C0951.1 C0952.1 C0953.1 C0954.1 C0955.1 C0956.1 C0957.1 C0958.1 C0959.1 C0960.1 C0961.1 C0962.1 C8074.2 C8075.2 C8076.2 C8077.2 C8078.2 C8079.2 C8080.2 C8081.2 C8082.2 C8083.2 C8084.2 C8085.2 C8091.2 C8092.2 C8093.2 C8094.2 C8095.2 C8096.2 C8097.2 C8098.2 C8099.2 C80002.2 C80020.2 C80026.2 C80036.2 C80038.2 C80050.2 C80055.2 C80073.2 C80075.2 C80078.2 C80083.2 C80087.2 C80092.2 C80122.1 C80123.1 CE8000.1 CE8001.1 JP8051.2 JP8053.2 JP8055.2 L8000.2 L8001.2 L8002.2 R80112.1 U0300.AA13(VCC_1) U0300.AA31(VCC_2) U0300.AA32(VCC_3) U0300.AA33(VCC_4) U0300.AA34(VCC_5) U0300.AA35(VCC_6) U0300.AA36(VCC_7) U0300.AA37(VCC_8) U0300.AA38(VCC_9) U0300.AB29(VCC_10) U0300.AB30(VCC_11) U0300.AB31(VCC_12) U0300.AB32(VCC_13) U0300.AB35(VCC_14) U0300.AB36(VCC_15) U0300.AB37(VCC_16) U0300.AB38(VCC_17) U0300.AC13(VCC_18) U0300.AC14(VCC_19) U0300.AC29(VCC_20) U0300.AC30(VCC_21) U0300.AC31(VCC_22) U0300.AC32(VCC_23) U0300.AC33(VCC_24) U0300.AC34(VCC_25) U0300.AC35(VCC_26) U0300.AC36(VCC_27) U0300.AD13(VCC_28) U0300.AD14(VCC_29) U0300.AD31(VCC_30) U0300.AD32(VCC_31) U0300.AD33(VCC_32) U0300.AD34(VCC_33) U0300.AD35(VCC_34) U0300.AD36(VCC_35) U0300.AD37(VCC_36) U0300.AD38(VCC_37) U0300.AE13(VCC_38) U0300.AE14(VCC_39) U0300.AE30(VCC_40) U0300.AE31(VCC_41) U0300.AE32(VCC_42) U0300.AE35(VCC_43) U0300.AE36(VCC_44) U0300.AE37(VCC_45) U0300.AE38(VCC_46) U0300.AF35(VCC_47) U0300.AF36(VCC_48) U0300.AF37(VCC_49) U0300.AF38(VCC_50) U0300.K13(VCC_51) U0300.K14(VCC_52) U0300.L13(VCC_53) U0300.L14(VCC_54) U0300.N13(VCC_55) U0300.N14(VCC_56) U0300.N30(VCC_57) U0300.N31(VCC_58) U0300.N32(VCC_59) U0300.N35(VCC_60) U0300.N36(VCC_61) U0300.N37(VCC_62) U0300.N38(VCC_63) U0300.P13(VCC_64) U0300.P14(VCC_65) U0300.P29(VCC_66) U0300.P30(VCC_67) U0300.P31(VCC_68) U0300.P32(VCC_69) U0300.P33(VCC_70) U0300.P34(VCC_71) U0300.P35(VCC_72) U0300.P36(VCC_73) U0300.R13(VCC_74) U0300.R31(VCC_75) U0300.R32(VCC_76) U0300.R33(VCC_77) U0300.R34(VCC_78) U0300.R35(VCC_79) U0300.R36(VCC_80) U0300.R37(VCC_81) U0300.R38(VCC_82) U0300.T29(VCC_83) U0300.T30(VCC_84) U0300.T31(VCC_85) U0300.T32(VCC_86) U0300.T35(VCC_87) U0300.T36(VCC_88) U0300.T37(VCC_89) U0300.T38(VCC_90) U0300.U29(VCC_91) U0300.U30(VCC_92) U0300.U31(VCC_93) U0300.U32(VCC_94) U0300.U33(VCC_95) U0300.U34(VCC_96) U0300.U35(VCC_97) U0300.U36(VCC_98) U0300.V13(VCC_99) U0300.V14(VCC_100) U0300.V31(VCC_101) U0300.V32(VCC_102) U0300.V33(VCC_103) U0300.V34(VCC_104) U0300.V35(VCC_105) U0300.V36(VCC_106) U0300.V37(VCC_107) U0300.V38(VCC_108) U0300.W13(VCC_109) U0300.W14(VCC_110) U0300.W29(VCC_111) U0300.W30(VCC_112) U0300.W31(VCC_113) U0300.W32(VCC_114) U0300.W35(VCC_115) U0300.W36(VCC_116) U0300.W37(VCC_117) U0300.W38(VCC_118) U0300.Y29(VCC_119) U0300.Y30(VCC_120) U0300.Y31(VCC_121) U0300.Y32(VCC_122) U0300.Y33(VCC_123) U0300.Y34(VCC_124) U0300.Y35(VCC_125) U0300.Y36(VCC_126)
+VTT_DDR: C1600.1 C1601.1 C1700.1 C1701.1 C1865.1 C1866.1 C1867.1 C1868.1 C1869.1 C1872.1 C1880.1 C1881.1 C1882.1 C1883.1 C1886.1 C1888.1 C1893.1 C1894.1 C1895.1 C1896.1 CON1600.258(VTT) CON1601.258(VTT) CON1700.258(VTT) CON1701.258(VTT) JP8301.1 R5713.1
A_DVDD: C3623.1 C3624.1 SR3601.2 U3600.1(DVDD)
AC_IN_OC: R3010.2 R8806.1 R8808.2 R8815.1 U3002.120(TMRI0/GPC4) U8800.5(ACOK)
ACDRV: R8803.1 R8816.2 U8800.4(ACDRV)
ACG: C8800.2 C8801.1 Q8801.4(GATE) Q8802.4(GATE) R8803.2
ACPRESENT_EC: SR3012.1 U3002.16(PWUREQ#/BBO/SMCLK2ALT/GPC7)
AD_IINP: C8815.1 SR8813.1 U3002.66(ADC0/GPI0)
ADP_ID: CON6004.1 Q8810.1(GATE) R6009.2 R8834.2 R8835.1
ALERT#: SR8008.2 U8000.44(ALERT#)
ALL_SYSTEM_PWRGD: D9202.2(CATHODE) SR9204.1 T9203.1 U3002.68(ADC2/GPI2) U9200.4(Y) U9201.2(B)
AMP_EN: CON6700.15 R3022.2 R3023.1
AMP_G0: CON6700.12 U3002.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
AMP_G1: CON6700.11 U3002.95(CTX1/SOUT1/SMDAT3/GPH2/ID2)
AMP_SPK_LN: C3620.1 CON3600.2 SR3606.2
AMP_SPK_LP: C3619.1 CON3600.1 SR3607.2
AMP_SPK_RN: C3621.1 CON3600.3 SR3605.2
AMP_SPK_RP: C3622.1 CON3600.4 SR3604.2
AMP_WOF_LN: C3707.1 CON3700.3 L3703.2
AMP_WOF_LN_R: L3703.1 U3700.2(OUT-LN)
AMP_WOF_LP: C3708.1 CON3700.4 L3704.2
AMP_WOF_LP_R: L3704.1 U3700.1(OUT-LP)
AMP_WOF_RN: C3705.1 CON3700.2 L3701.2
AMP_WOF_RN_R: L3701.1 U3700.5(OUT-RN)
AMP_WOF_RP: C3706.1 CON3700.1 L3702.2
AMP_WOF_RP_R: L3702.1 U3700.6(OUT-RP)
ANALOG_INL: C3648.2 R3704.1
ANALOG_INL_C: C3648.1 U3600.24(LINE2-L(PORT-E-L))
ANALOG_INL_CR: C3703.2 R3704.2 R3712.2
ANALOG_INL_CR_C: C3703.1 U3700.10(INPUT-L/DIFF-)
ANALOG_INR: C3649.2 R3700.1
ANALOG_INR_C: C3649.1 U3600.23(LINE2-R(PORT-E-R))
ANALOG_INR_CR: C3702.2 R3700.2 R3711.2
ANALOG_INR_CR_C: C3702.1 U3700.9(INPUT-R/DIFF+)
AR_PCIE_CLKREQ_N: R1109.1 R1119.1 U1101.AC5(PCIE_CLKREQ_N) U1102.2(A)
BAT: CON2800.1(+) Q2801.1(GATE) R2803.2 R2811.1
BAT1_IN_OC#: JP9000.1 R3065.2 U3002.124(TMRI1/GPC6)
BAT_IINP: C8839.1 SR8814.1 U3002.69(ADC3/GPI3)
BAT_LEARN: SR8807.2 U3002.85(PS2CLK0/TMB0/CEC/GPF0)
BATDRV: R8814.1 U8800.18(BATDRV)
BATG: Q8800.4(GATE) R8814.2
BATSRC: R8802.1 U8800.17(BATSRC)
BATT_IN: CON6000.4 Q6001.3(DRAIN)
BKLT_EN: D4502.3(ANODE) D4503.1(ANODE) R4525.2 SR4505.1 SR4507.2
BOOT_C: SR8015.1 U8005.2(BOOT)
BP_PWRGD_RST#: C4401.1 R4412.2 R4415.1 XDP4400.41
BPM_N2: T0700.1 U0300.BM31(BPM#[2])
BPM_N3: T0701.1 U0300.BT30(BPM#[3])
BT_DISABLE#: C5347.1 CON5300.54 R2141.1 R5300.2 U2000.AC43(GPP_F3/SATAXPCIE6/SATAGP6)
BT_LED: CON5300.16 T5301.1
BUF_PLT_RST#_WIGIG: C5349.1 CON5300.66 D5308.1(ANODE) R5354.1 R5355.1 R5356.1
BUF_PLT_RST#_WLAN: C5348.1 CON5300.52 D5303.1(ANODE) R5319.1 R5341.1 R5349.1
BVREF_CA_RC: C0502.2 R0511.1
C_CC1: C1223.1 CON1201.A5(CC1) U1201.L9(C_CC1) U1208.1(CH1) U1208.10(N.C.4)
C_CC2: C1224.1 CON1201.B5(CC2) U1201.L10(C_CC2) U1207.1(CH1) U1207.10(N.C.4)
C_USB_BN: L1201.4 RN1201.4(Y) U1201.L7(C_USB_BN)
C_USB_BN_CON: CON1201.B7(DN2) L1201.3 RN1201.3(X) U1207.5(CH4) U1207.6(N.C.1)
C_USB_BP: L1201.1 RN1201.2(Y) U1201.K7(C_USB_BP)
C_USB_BP_CON: CON1201.B6(DP2) L1201.2 RN1201.1(X) U1207.4(CH3) U1207.7(N.C.2)
C_USB_TN: L1202.1 RN1202.2(Y) U1201.L6(C_USB_TN)
C_USB_TN_CON: CON1201.A7(DN1) L1202.2 RN1202.1(X) U1208.5(CH4) U1208.6(N.C.1)
C_USB_TN_CON_CHG: R1221.2 U1202.11(DM_IN)
C_USB_TP: L1202.4 RN1202.4(Y) U1201.K6(C_USB_TP)
C_USB_TP_CON: CON1201.A6(DP1) L1202.3 RN1202.3(X) U1208.4(CH3) U1208.7(N.C.2)
C_USB_TP_CON_CHG: R1217.2 U1202.10(DP_IN)
CA_DET: CON4601.13 Q7206.2(G) R4609.1
CATERR#: T0745.1 U0300.BM30(CATERR#)
CFG_RCOMP: R0742.1 U0300.BT25(CFG_RCOMP)
CGH_SRN: SR8805.2 U8800.19(SRN)
CGH_SRP: SR8804.2 U8800.20(SRP)
CHA_DIMM0_EVENT#: C1619.1 CON1600.134(EVENT_N/NF) R1600.2
CHA_DIMM1_EVENT#: C1620.1 CON1601.134(EVENT_N/NF) R1601.2
CHB_DIMM0_EVENT#: C1718.1 CON1701.134(EVENT_N/NF) R1700.2
CHB_DIMM1_EVENT#: C1719.1 CON1700.134(EVENT_N/NF) R1701.2
CHG_ACN: C8807.2 C8809.2 JP8802.2 U8800.1(ACN)
CHG_ACP: C8807.1 C8808.2 JP8801.2 U8800.2(ACP)
CHG_BST: SR8803.2 U8800.25(BTST)
CHG_BST_R: C8817.2 D8800.3(CATHODE) SR8803.1
CHG_GPIO12_AC_BATT#_Q: Q8807.3(D) SR8810.1
CHG_HG: Q8803.4(GATE) T8800.1 U8800.26(HIDRV)
CHG_ILIM: C8824.1 R8811.1 R8813.2 U8800.21(ILIM)
CHG_LDO: C8821.1 D8800.1(ANODE1) D8800.2(ANODE2) R8806.2 U8800.24(REGN)
CHG_LED_RED: CON5602.22 R5602.1 U3002.25(PWM1/GPA1)
CHG_LED_RED_LED: CON1.4 LC801.1 LQ801.1(GATE)
CHG_LED_YELLOW: CON5602.23 R5601.1 U3002.28(PWM2/GPA2)
CHG_LED_YELLOW_LED: CON1.3 LC802.1 LQ802.1(GATE)
CHG_LG: Q8804.4(GATE) T8801.1 U8800.23(LODRV)
CHG_LX: C8817.1 L8800.1 Q8803.1(SOURCE1) Q8803.2(SOURCE2) Q8803.3(SOURCE3) Q8804.5(DRAIN1) Q8804.6(DRAIN2) Q8804.7(DRAIN3) Q8804.8(DRAIN4) R8810.1 U8800.27(PHASE)
CHG_PROCHOT#: Q8806.1(GATE) R8837.2 U8800.10(PROCHOT#)
CHG_PROCHOT#_Q: Q8807.6(D) SR8811.1
CHG_RC: C8822.1 R8810.2
CHG_SRN_R: C8823.2 C8826.2 JP8805.2 SR8805.1
CHG_SRP_R: C8823.1 C8825.2 JP8804.2 SR8804.1
CHG_VCC: C8816.2 R8812.2 U8800.28(VCC)
CHG_VCC_R: D8801.3(CATHODE) R8812.1
CK_24M_85OHM_BCK: SR2504.2 U2000.G1(CLKOUT_CPUNSSC_P)
CK_24M_85OHM_BCK#: SR2506.2 U2000.F1(CLKOUT_CPUNSSC_N)
CK_24M_BCK: SR2504.1 U0300.E31(CLK24P)
CK_24M_BCK#: SR2506.1 U0300.D31(CLK24N)
CK_100M_85OHM_BCK: SR2501.2 U2000.G2(CLKOUT_CPUBCLK_P)
CK_100M_85OHM_BCK#: SR2502.2 U2000.H2(CLKOUT_CPUBCLK_N)
CK_100M_85OHM_CPUXDP: SR2508.2 U2000.L2(CLKOUT_ITPXDP_P)
CK_100M_85OHM_CPUXDP#: SR2509.2 U2000.L1(CLKOUT_ITPXDP_N)
CK_100M_85OHM_PCIE: SR2511.2 U2000.J2(CLKOUT_CPUPCIBCLK_P)
CK_100M_85OHM_PCIE#: SR2512.2 U2000.J1(CLKOUT_CPUPCIBCLK_N)
CK_100M_BCK: SR2501.1 U0300.B31(BCLKP)
CK_100M_BCK#: SR2502.1 U0300.A32(BCLKN)
CK_100M_CPUXDP: SR2508.1 XDP4400.40
CK_100M_CPUXDP#: SR2509.1 XDP4400.42
CK_100M_LAN: SR2517.2 U3300.33(REFCLK_P)
CK_100M_LAN#: SR2518.2 U3300.32(REFCLK_N)
CK_100M_LAN#_R: SR2518.1 U2000.P3(CLKOUT_PCIE_N10)
CK_100M_LAN_R: SR2517.1 U2000.P2(CLKOUT_PCIE_P10)
CK_100M_PCIE: SR2511.1 U0300.D35(PCI_BCLKP)
CK_100M_PCIE#: SR2512.1 U0300.C36(PCI_BCLKN)
CK_100M_PE0: CON5300.47 SR2510.2
CK_100M_PE0#: CON5300.49 SR2503.2
CK_100M_PE0#_R: SR2503.1 U2000.N7(CLKOUT_PCIE_N0)
CK_100M_PE0_R: SR2510.1 U2000.N8(CLKOUT_PCIE_P0)
CK_100M_PE1: CON5300.73 SR2505.2
CK_100M_PE1#: CON5300.71 SR2507.2
CK_100M_PE1#_R: SR2507.1 U2000.L7(CLKOUT_PCIE_N1)
CK_100M_PE1_R: SR2505.1 U2000.L5(CLKOUT_PCIE_P1)
CK_100M_PE8: CON5102.55 SR2513.2
CK_100M_PE8#: CON5102.53 SR2514.2
CK_100M_PE8#_R: SR2514.1 U2000.W10(CLKOUT_PCIE_N8)
CK_100M_PE8_R: SR2513.1 U2000.W11(CLKOUT_PCIE_P8)
CL_CLK: R5312.2 U2000.AV2(CL_CLK)
CL_CLK_R: CON5300.42 R5312.1
CL_DATA: R5311.2 U2000.AV3(CL_DATA)
CL_DATA_R: CON5300.40 R5311.1
CL_RST#: R5310.2 U2000.AW2(CL_RST#)
CL_RST#_R: CON5300.38 R5310.1 SR5302.2
CLK_KBCPCI_DEBUG: CON4400.1 R2227.1
CLK_KBCPCI_PCH: C2203.1 C3022.1 R2265.1 U3002.13(LPCCLK/GPM4)
CLKOUT_LPC0_ESPI_CLK: R2227.2 R2265.2 U2000.BC17(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
CLKOUT_LPC1_CLK: C2202.1 R2264.1 U6200.21(LCLK/SCLK)
CLKOUT_LPC1_CLK_R: R2264.2 U2000.AV19(GPP_A10/CLKOUT_LPC1)
CLKREQ0_WLAN#: CON5300.53 R2421.2 R2425.1 R5306.1 U2000.BC24(GPP_B5/SRCCLKREQ0#)
CLKREQ1_WIGI#: CON5300.68 R2410.2 R5305.1 U2000.AW24(GPP_B6/SRCCLKREQ1#)
CLKREQ#: SR3302.2 U3300.4(CLKREQN)
CLKREQ#_MSATA: R2430.2 R2490.1 SR5103.1 U2000.BD32(GPP_H2/SRCCLKREQ8#)
CMSRC: R8804.1 U8800.3(CMSRC)
COEX1_1.8V: CON5300.48 T5309.1
COEX2_1.8V: CON5300.46 T5308.1
COEX3_1.8V: CON5300.44 T5306.1
COMP_A: C8032.2 R8096.2 U8000.16(COMP_A)
COMP_B: C8015.2 R8030.2 U8000.4(COMP_B)
COMP_C: C8005.1 R8093.1 U8000.29(COMP_C)
CORE_PLLVDD: C7206.1 C7209.1 L7205.2 SR7202.1
CORE_PLLVDD_GPU: C7201.1 C7212.1 C7213.1 C7214.1 SR7203.2 U7000.AF11(GPCPLL_AVDD1) U7000.BB24(XS_PLLVDD) U7000.U42(GPCPLL_AVDD0)
CPU_PECI: R0733.2 R0746.2 U0300.BT34(PECI)
CPU_PM_DOWN: R0731.2 U0300.BP31(PM_DOWN)
CPU_THERM#: R5011.2 R5018.2 R9214.1 SR5001.1 U5000.4(THERM#) U5003.3(OT#)
CPU_VIDALERT#: R0717.1 U0300.BH31(VIDALERT#)
CPU_VRON: SR0703.2 SR8011.1
CPU_VRON_PWR: JP9300.2 SR8010.1 T9300.1
CPU_VTT_CNTL: R0728.1 U0300.BT13(DDR_VTT_CNTL)
CPU_XDP_HOOK0: R4404.1 R4405.1 R4406.1 XDP4400.39
CPU_XDP_HOOK2: R4409.2 R4416.1 XDP4400.45
CPUFAN_PWM_C_L: CON5000.1 D5000.2(ANODE2) R5006.2
CPUFAN_PWM_C_R: CON5001.1 D5002.2(ANODE2) R5010.2
CPUFAN_TACH_C_L: CON5000.3 D5000.1(ANODE1) D5001.1(CATHODE1) D5001.2(CATHODE2) R5005.2
CPUFAN_TACH_C_R: CON5001.3 D5002.1(ANODE1) D5003.1(CATHODE1) D5003.2(CATHODE2) R5009.2
CPUPWRGD: R4404.2 SR2406.1 U0300.BT31(PROCPWRGD)
CRITICAL: R9719.1 SR9713.1 T8715.1 U9702.9(CRITICAL)
CSBU_1_R: SR1204.1 U1201.K8(C_SBU1)
CSBU_2_R: SR1205.1 U1201.L8(C_SBU2)
DCPRTC: C2623.1 U2000.BA26(DCPRTC)
DDC_GATE: Q7202.1(GATE) Q7203.1(GATE) Q7206.5(G) Q7206.6(D) R7218.2
DDC_GATE_G: Q4601.2(G) Q4601.5(G) Q7206.3(D) R7230.2
DDI1_BKLT_CTL: R4596.1 U2000.W36(GPP_F21/EDP_BKLTCTL)
DDR_BST: SR8301.2 U8300.18(BOOT)
DDR_BST_R: C8309.1 SR8301.1
DDR_CS: R8302.1 U8300.13(CS)
DDR_FB: C8320.2 R8306.2 R8308.1 U8300.6(FB)
DDR_FB_R: C8320.1 C8321.1 JP8304.2 R8306.1
DDR_HG: Q8300.4(G) U8300.17(UGATE)
DDR_LG: Q8301.4(G) U8300.15(LGATE)
DDR_LX: C8309.2 L8300.1 Q8300.1(S_1) Q8300.2(S_2) Q8300.3(S_3) Q8301.5(D) R8301.1 T8301.1 U8300.16(PHASE)
