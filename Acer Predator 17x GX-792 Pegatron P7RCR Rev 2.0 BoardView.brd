# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NVVDD_VSS_SENSE: length 60.3
  TOP w0.254: SR8707.2 133.64,153.78 133.64,152.79 v2(133.15,152.31)
  BOTTOM w0.15: 143.72,107.28 143.78,107.22 143.87,107.22 144.24,106.85 U7000.BL45
  BOTTOM w0.254: v2(133.15,152.31) 133.28,152.18 133.28,151.21 131.86,149.79 130.29,149.79 128.66,148.16 128.66,147.45 v1(128.26,147.06) 126.63,145.42 126.63,137.2 129.89,133.93 129.89,124.7 136.61,117.98 136.61,115.48 138.16,113.93 138.16,110.1 140.98,107.28 143.72,107.28
NVVDDS_EN: length 478.2
  TOP w0.102: R5741.1 R5737.1 128.61,144.48 128.4,144.28 v2(127.95,144.28) ; SR5705.1 204.08,133.84 203.82,134.1 SR5701.1 204.29,134.77 v2(204.58,134.47) ; v2(122.66,150.31) 122.66,150.21 123.85,149.03 124.77,149.03 124.92,148.88 125.89,148.88 126.53,149.51 127.36,149.51 128.05,150.2 130.59,150.2 v2(130.88,150.49) ; v1(141.79,54.85) v2(142.47,54.85) 142.47,53.12 139.45,50.09 139.45,48.8 135.28,44.63 134.06,44.63 132.09,42.66 132.09,37.14 130.99,36.05 130.99,30.56 130.49,30.06 v2(130.49,26.75) ; v2(205.97,184.89) 205.85,185.02 R9722.1 206.84,185.68 207.27,185.24 D9700.2
  IN1 w0.102: v2(127.95,144.28) 127.72,144.51 127.72,146.57 128.38,147.23 128.38,147.76 130.88,150.26 v2(130.88,150.49) 132.14,151.75 132.14,155.76 133.56,157.18 133.56,159.5 133.2,159.86 133.2,162.67 131.32,164.55 v2(131.32,165.74) 133.56,167.98 133.56,170.9 136.25,173.59 184.99,173.59 187.73,170.85 193.36,170.85 194.29,171.78 194.29,178.79 196.34,180.83 196.34,185.47 197.34,186.47 204.27,186.47 205.85,184.89 v2(205.97,184.89) 205.77,184.69 205.77,173.16 209.91,169.02 209.91,141.16 204.58,135.83 v2(204.58,134.47)
  IN3 w0.102: v2(142.47,54.85) 141.33,54.85 129.27,66.91 129.27,67.89 126.99,70.17 126.99,72.32 124.34,74.97 124.34,111.02 123.69,111.67 123.69,123.47 120.99,126.17 119.97,126.17 118.85,127.29 118.85,129.96 119.6,130.71 119.6,132.74 118.43,133.9 116.6,133.9 116.01,134.5 116.01,134.86 114.61,136.25 114.61,141.43 v2(114.33,141.71) 114.61,141.99 114.61,145.38 117.47,148.24 120.63,148.24 121.37,148.97 121.37,149.36 122.32,150.31 v2(122.66,150.31)
  IN4 w0.102: v2(233.79,26.58) 233.33,26.12 231.54,26.12 228.73,23.31 211.77,23.31 210.91,22.45 210.78,22.45 209.23,20.9 209.23,19.46 206.22,16.45 186.65,16.45 186.41,16.22 180.48,16.22 179.2,14.93 162.66,14.93 v2(161.9,15.69)
  BOTTOM w0.102: v2(130.49,26.75) 130.49,22.13 136.55,16.07 136.55,15.16 133.94,12.55 133.94,12.13 134.64,11.44 138.2,11.44 140.74,13.98 147.99,13.98 149.97,15.96 155.05,15.96 155.71,15.3 161.5,15.3 v2(161.9,15.69) ; SR5707.1 234.07,26.85 v2(233.79,26.58) ; D9600.2 114.31,139.78 113.65,140.44 R9602.1 114,142.04 v2(114.33,141.71) ; v2(142.47,54.85) 142.09,54.85 141.73,55.21 U7416.4 ; v2(131.32,165.74) 130.61,166.45 129.17,166.45 128.12,165.41 R5745.1
NVVDDS_PSI: length 194.3
  TOP w0.102: SR9710.1 204.62,189.85 v2(204.96,189.85) ; v1(146.7,74.98) 146.26,74.53 v3(146.26,73.95) 146.26,73.6 145.81,73.15 SR7418.2
  IN3 w0.102: v2(204.96,189.85) 203.56,188.45 203.56,186.14 187,169.58 187,161.99 186,160.99 185.03,160.99 184.65,161.37 149.04,161.37 147.97,160.31 135.74,160.31 133.71,158.28 133.71,156.92 131.78,154.99 131.78,149.18 126.45,143.85 126.45,135.33 125.36,134.24 125.36,132.39 127.73,130.02 128.9,130.02 130.54,128.38 130.54,122.42 130.16,122.04 130.16,93.95 132.23,91.88 132.23,91.41 134.07,89.58 134.07,84.82 136.63,82.25 139.15,82.25 141.99,79.41 141.99,75.74 143.32,74.41 145.79,74.41 v3(146.26,73.95)
NVVDDS_PWROK: length 222.3
  TOP w0.102: R9215.1 214.92,22 v2(214.86,21.95) ; SR9700.1 v2(197.36,188.27) ; R7495.1 208.9,136.23 v2(208.49,136.63)
  IN1 w0.102: v2(211.05,77.96) 211.25,77.96 212.37,79.08 215.2,79.08 216.03,79.92 216.03,94.67 215.17,95.54 215.17,100.03 210.5,104.71 210.5,109.98 212.6,112.09 212.6,115.98 210.65,117.94 210.65,123.86 210.12,124.4 210.12,135.01 v2(208.49,136.63) 208.49,139.45 210.12,141.08 210.12,169.1 206.38,172.84 206.38,185.06 204.67,186.77 198.86,186.77 v2(197.36,188.27)
  IN2 w0.102: v2(196.96,20.38) 199.04,18.29 206.89,18.29 208.44,19.84 208.44,21.23 209.34,22.13 214.69,22.13 v2(214.86,21.95)
  BOTTOM w0.102: T9212.1 197.31,188.22 v2(197.36,188.27) ; v2(196.96,20.38) 196.27,21.06 196.27,29.73 199.07,32.53 199.07,34.58 197.77,35.87 197.77,38.03 199.57,39.83 199.57,44.41 200.67,45.51 200.67,49.33 200.03,49.96 200.03,52.84 200.54,53.35 200.54,62.29 199.85,62.97 199.85,68.54 201.43,70.11 201.43,70.94 203.86,73.37 209.43,73.37 210.83,74.77 210.83,76.87 211.05,77.1 v2(211.05,77.96)
NVVDDS_VDD_SENSE: length 154.1
  TOP w0.254: SR9712.1 194.29,186.27 194.82,185.73 v2(194.82,185.2)
  IN1 w0.254: v2(194.82,185.2) 194.57,184.94 194.57,184.46 192.51,182.4 192.51,176.66 189.92,174.07 135.95,174.07 132.95,171.08 132.95,170.42 131.12,168.59 131.12,167.49 129.52,165.89 129.52,165.13 131.43,163.22 131.43,161.75 132.31,160.86 132.31,159.24 131.86,158.78 131.86,152.69 131.25,152.08 v2(131.15,152.08)
  BOTTOM w0.254: v2(131.15,152.08) 129.24,152.08 128.47,151.3 128.47,150.09 v1(127.31,148.93) 127.09,148.93 125.99,147.83 125.99,137 129.3,133.68 129.3,124.48 136,117.79 136,115.3 137.78,113.52 137.78,109.98 141.02,106.74 143.64,106.74 U7000.BM45
NVVDDS_VDD_SENSE_IC: length 6.8
  TOP w0.203: 198.86,189.21 198.86,188.83 198.65,188.61 U9700.11
  TOP w0.254: SR9712.2 195.61,189.99 R9720.1 C9723.2 197.52,190.18 v1(197.67,190.02) 198.66,190.02 198.86,189.82 198.86,189.21
NVVDDS_VID: length 195
  TOP w0.102: SR9703.1 204.87,190.48 v2(204.96,190.48) ; v1(144.93,74.49) 144.93,73.91 v3(144.99,73.84)
  IN3 w0.102: v3(144.99,73.84) 144.69,74.15 143.29,74.15 141.79,75.65 141.79,79.32 140,81.11 135.03,81.11 133.86,82.28 133.86,89.49 132.03,91.33 132.03,91.8 129.95,93.87 129.95,122.12 130.33,122.5 130.33,128.29 128.81,129.81 127.65,129.81 125.15,132.31 125.15,134.32 126.24,135.41 126.24,143.93 131.58,149.26 131.58,155.07 133.51,157 133.51,158.36 135.65,160.51 147.89,160.51 149.21,161.83 185.98,161.83 186.79,162.65 186.79,169.65 203.35,186.21 203.35,188.87 v2(204.96,190.48)
  BOTTOM w0.102: v3(144.99,73.84) 145.17,73.67 145.17,72.3 145.27,72.2 SR7405.2
NVVDDS_VSS_SENSE: length 154.6
  TOP w0.254: SR9711.1 193.91,187.34 193.91,186.01 194.24,185.68 v2(194.24,185.55)
  IN1 w0.254: v2(194.24,185.55) 194.19,185.5 194.19,184.69 192.08,182.58 192.08,176.84 189.74,174.5 135.77,174.5 132.57,171.3 132.57,170.54 130.77,168.74 130.77,167.65 129.17,166.05 129.17,164.98 131.07,163.08 131.07,161.6 131.96,160.71 131.96,159.39 131.5,158.93 131.5,153.07 v2(131.12,152.69)
  BOTTOM w0.254: U7000.BM44 143.52,106.38 140.87,106.38 137.42,109.83 137.42,113.34 135.62,115.14 135.62,117.66 128.95,124.33 128.95,133.54 125.63,136.85 125.63,147.97 128.11,150.45 128.11,150.86 v1(127.96,151.01) 127.96,151.29 129.1,152.43 130.69,152.43 130.94,152.69 v2(131.12,152.69)
NVVDDS_VSS_SENSE_IC: length 9
  TOP w0.203: 199.21,190.27 U9700.10
  TOP w0.254: SR9711.2 193.43,189.41 v1(193.59,189.58) 193.83,189.82 SR9705.2 194.21,190.48 194.72,190.99 R9718.1 C9723.1 198.43,191.04 199.21,190.27
OC0#: length 132.6
  TOP w0.102: v2(305.09,62.97) 305.03,63.03 U5200.13 ; v2(296.27,72.55) 296.13,72.69 U1202.13
  IN1 w0.102: v2(293.4,64.75) 293.33,64.83 293.33,68.08 294.77,69.53 294.77,70.8 296.27,72.3 v2(296.27,72.55)
  IN3 w0.102: v2(228.45,41.69) 228.46,41.69 229.75,42.98 239.86,42.98 240.6,43.72 248.8,43.72 251,45.92 252.15,45.92 253.37,47.14 253.37,59.88 250.91,62.34 250.17,62.34 249.66,62.85 249.66,65.51 251.56,67.41 255.75,67.41 256.65,68.31 256.65,71.61 v2(256.36,71.9)
  IN4 w0.102: v2(273.18,66.94) 270.69,66.94 267.8,69.83 261.86,69.83 259.77,71.91 256.4,71.91 256.38,71.9 v2(256.36,71.9)
  BOTTOM w0.089: U2000.AD43 229.06,48.82 229.06,48.43 228.99,48.36 228.99,47.75 228.76,47.52 228.76,47.45
  BOTTOM w0.102: v2(305.09,62.97) 301.22,62.97 300.08,64.12 296.64,64.12 296.47,64.29 293.86,64.29 v2(293.4,64.75) 285.83,64.75 285.71,64.88 v1(284.56,64.88) 283.19,64.88 282.2,63.89 280.94,63.89 279.66,65.17 279.66,65.81 277.64,67.83 277.25,67.83 276.36,66.94 v2(273.18,66.94) ; 228.76,47.45 228.76,45.39 228.45,45.08 R2118.2 228.02,43.34 228.02,42.12 228.45,41.69 v2(228.45,41.69)
OC1#: length 286.6
  IN1 w0.102: v2(227.18,41.69) 226.7,42.17 226.7,42.49 226.46,42.73 211.81,42.73 211.19,42.11 211.19,39.66 211.23,39.62 211.23,39.25 204.86,32.87 204.86,28.36 202.04,25.55 143.32,25.55 140.49,28.38 128.48,28.38 127.92,28.94 119.26,28.94 116.15,25.83 113.39,25.83 112.2,24.64 71.46,24.64 69.89,23.07 42.85,23.07 39.28,26.64 36.97,26.64 36.93,26.68 36.26,26.68 35.88,26.3 33.08,26.3 32.7,26.68 32.7,27.21 32.34,27.57 32.04,27.57 31.42,28.2 31.42,37.54 30.89,38.06 30.89,44.2 26.27,48.83 25.46,48.83 24.85,49.43 24.85,50.6 19.18,56.27 19.18,57.59 v2(18.78,58)
  BOTTOM w0.089: 228.35,47.45 228.35,47.66 228.62,47.92 228.62,48.34 228.55,48.48 228.55,49.28 228.68,49.41 U2000.AD42
  BOTTOM w0.102: v2(18.78,58) 18.47,58 18.27,58.2 13.77,58.2 12.36,59.61 9.92,59.61 9.73,59.42 9.73,56.94 8.57,55.78 8.56,55.78 8.44,55.66 8.44,47.89 9.82,46.5 9.92,46.5 9.93,46.5 12.72,46.5 13.02,46.2 CON6700.24 ; 228.35,47.45 228.35,46.06 v1(228.07,45.78) 227.54,45.24 227.54,44.12 R2117.2 227.59,43.36 227.59,42.09 227.19,41.69 v2(227.18,41.69)
OC2#: length 163.5
  TOP w0.102: v2(228.2,51.01) 228.2,51 227.41,50.21 227.41,49.97 226.37,48.93 226.37,45.88 R2119.2 223.83,43.34 223.83,41.26 v1(221.57,39) 221.57,37.95 220.68,37.07 218.6,37.07 216.61,35.08 213.8,35.08 205.84,27.12 205.84,25.29 204.72,24.18 v2(204.63,24.18) ; U5501.3 303.32,73.07 v2(303.13,73.26)
  IN2 w0.102: v2(303.13,73.26) 303.13,72.04 299.55,68.46 293.63,68.46 292.18,67.01 288.33,67.01 286.32,65.01 284.87,65.01 283.22,63.35 279.47,63.35 278.64,62.53 278.64,60.73 267.57,49.66 267.57,47.16 260.57,40.15 259.8,40.15 258.26,38.62 257.93,38.62 252.78,33.46 250.85,33.46 249.99,32.6 247.43,32.6 240.29,25.46 238.77,25.46 238.11,24.8 237.03,24.8 236.91,24.92 226.27,24.92 225.76,24.42 208.63,24.42 208.39,24.18 v2(204.63,24.18)
  BOTTOM w0.102: v2(228.2,51.01) 228.43,50.78 U2000.AD39
OE: length 3.7
  TOP w0.102: C1318.1 296.83,86.65 296.8,86.62 U1301.36
OP_SD#: length 273.8
  TOP w0.102: v2(33.07,21.16) 33.6,21.7 40.46,21.7 44.4,25.64 v2(44.4,26.04) ; Q3601.2 21.7,21.44 21.47,21.22 21.14,21.22 20.34,20.42 20.34,19.57 20.06,19.29 19.66,19.29 19.31,19.64 18.29,19.64 18.04,19.9 17.46,19.9 16.87,20.48 16.87,21.22 17.66,22 17.66,24.11 18.7,25.15 20.16,25.15 21.35,26.34 21.93,26.34 23.69,28.1 v1(24.82,28.1) 25.13,28.4 v2(29.89,28.4)
  IN1 w0.102: v2(44.4,26.04) 44.61,26.25 111.36,26.25 112.55,27.44 115.49,27.44 119.7,31.66 140.66,31.66 143.53,28.79 161.13,28.79 161.69,28.23 165.14,28.23 165.75,28.84 196.39,28.84 203.48,35.92 203.48,37.71 207.95,42.18 207.95,43.11 211.33,46.49 222.21,46.49 222.79,45.9 231.98,45.9 232.85,46.77 234.58,46.77 235.4,47.6 238.01,47.6 239.2,48.78 239.2,52.65 240.75,54.2 240.75,57.82 242.2,59.27 v2(242.2,59.71)
  IN3 w0.102: v2(33.07,21.16) 33.07,21.94 31.15,23.86 31.15,25.74 29.83,27.06 29.83,28.3 29.89,28.37 v2(29.89,28.4)
  BOTTOM w0.102: R2420.2 242.23,59.74 v2(242.2,59.71) 242.08,59.82 240.95,59.82 240.84,59.71 240.58,59.71 240.16,59.29 240.16,58.91 239.76,58.51 238.69,58.51 U2000.BD24
OPC_RCOMP: length 5
  TOP w0.254: R1014.1 71.56,124.36 v3(71.56,124.52)
  BOTTOM w0.102: v3(71.56,124.52) 71.38,124.7 71.3,124.7 v1(71.08,124.92)
  BOTTOM w0.203: v3(71.56,124.52) 71.56,124.31 71.79,124.09 72.78,124.09 73.07,123.79 74.17,123.79 U0300.BT29
OPCE_RCOMP: length 10.8
  BOTTOM w0.102: v1(65.57,122.91) 67.04,121.44 R1015.1
  BOTTOM w0.216: 74.04,120.48 74.05,120.47 74.65,120.47 U0300.BR25
  BOTTOM w0.254: 74.04,120.48 69.73,120.48 69.25,120.96 68.08,120.96 67.88,121.17 R1015.1
OPCE_RCOMP2: length 9.5
  BOTTOM w0.102: R1016.1 70.57,122.99 70.29,123.27 69.4,123.27 69.33,123.2 v1(67.3,123.2)
  BOTTOM w0.229: U0300.BP25 75.29,121.25 72.61,121.25 71,122.87 R1016.1
OUT_AUXN: length 30.3
  TOP w0.108: 301.25,120.41 300.66,120.41 299.72,121.35 295.16,121.35 292.62,118.81 292.62,118.21 291.92,117.51 291.75,117.51 291.65,117.61 291.65,120.73 291.32,121.06 C4627.2 290.86,120.57 290.98,120.44 Q4601.3 ; 301.25,120.41 301.67,120.41 R4607.2 302.7,120.43 304.45,120.43 v2(304.93,120.91) ; 301.25,120.41 v1(301.25,120.64)
  IN1 w0.095: CON4601.17 311.01,121.98 304.78,121.98 304.53,121.73 304.53,121.03 304.66,120.91 v2(304.93,120.91)
OUT_AUXP: length 30.3
  TOP w0.108: v1(303.97,119.97) 303.97,120.19 ; 303.97,120.19 304.83,120.19 v2(304.93,120.3) ; 303.97,120.19 302.69,120.19 R4608.2 301.7,120.17 300.56,120.17 299.62,121.11 295.26,121.11 292.86,118.71 292.86,118.11 291.6,116.86 289.05,116.86 288.6,117.3 C4626.2 288.6,118.03 288.6,118.03 Q4601.6
  IN1 w0.095: v2(304.93,120.3) 304.3,120.94 304.3,121.83 304.68,122.21 311.3,122.21 CON4601.15
OVERT#: length 22.4
  IN4 w0.102: v3(147.61,78.49) 148.07,78.03 148.07,74.77 147.58,74.28 147.58,72.17 147.66,72.09 147.66,70.67 147.67,70.66 147.67,70.06 145.97,68.36 145.97,66.38 143.93,64.34 142.64,64.34 v2(142.2,64.78)
  BOTTOM w0.102: U7417.1 140.05,65.65 R7440.1 v1(141.15,65.87) 141.62,65.41 141.62,65.37 v2(142.2,64.78) ; v3(147.61,78.49) U7000.BG5
PCBEEP: length 323.6
  TOP w0.102: R3606.2 17.25,24.04 18.62,25.4 19.93,25.4 21.09,26.57 21.65,26.57 23.76,28.68 28.05,28.68 28.43,29.06 v2(29.89,29.06) ; U3002.34 146.11,33.11 145.81,32.81 145.81,32.48 143.57,30.23 135.12,30.23 130.37,25.48 v1(124.31,25.48) 123.17,25.48 v2(121.9,26.75)
  IN1 w0.102: v2(29.89,29.06) 30.36,28.6 30.36,27.31 32.09,25.58 34.6,25.58 36.13,24.05 39.79,24.05 41.32,22.51 113.04,22.51 114.64,24.11 116.15,24.11 118.8,26.75 v2(121.9,26.75) 122.46,26.19 139.83,26.19 142.59,23.44 157.13,23.44 157.47,23.1 164.23,23.1 164.36,23.22 167.27,23.22 167.32,23.28 171.45,23.28 171.54,23.37 174.27,23.37 174.94,22.7 177.76,22.7 178.31,23.25 183.96,23.25 184.57,22.64 201.65,22.64 209.43,30.42 231.64,30.42 232.57,29.5 243.41,29.5 247.28,33.36 250.16,33.36 250.67,33.87 252.89,33.87 255.1,36.09 255.1,40.87 254.1,41.87 252.32,41.87 251.3,42.89 251.3,49.73 251.45,49.88 251.45,52.34 251.19,52.6 251.19,57.42 250.54,58.06 250.17,58.06 v2(249.76,57.66)
  BOTTOM w0.102: v2(249.76,57.66) 249.33,58.1 248.54,58.1 R2449.1 246.72,57.69 R2460.2 245.88,57.66 245.01,57.66 244.43,57.08 244.43,56.29 244.29,56.15 241.2,56.15 241.07,56.28 240.48,56.28 239.83,56.93 238.96,56.93 U2000.BD26
PCH_BATL#: length 7.4
  BOTTOM w0.102: U2000.BD13 238.73,64.25 239.4,64.25 239.48,64.32 241.28,64.32 241.37,64.42 241.91,64.42 242.71,65.21 v1(244.57,65.21) 244.77,65.41 R2444.2
PCH_BKLT_EN: length 463.2
  TOP w0.102: C2311.1 234.14,41.26 v2(234.58,41.69) ; v2(81.77,189.34) 81.77,189.59 v1(82.4,190.23) 83.55,191.37 85.32,191.37 85.83,190.86 SR4507.1
  IN1 w0.102: v2(234.58,41.69) 234.47,41.69 233.86,41.08 217.72,41.08 209.67,33.03 207.04,33.03 205.82,31.81 205.82,27.96 202.44,24.58 195.42,24.58 194.38,23.54 188.85,23.54 187.41,24.99 142.84,24.99 140.23,27.59 128.01,27.59 127.23,28.38 120.14,28.38 116.07,24.31 114.13,24.31 v2(112.78,22.97)
  IN2 w0.102: v2(112.78,22.97) 112.78,22.36 111,20.58 95.38,20.58 91.73,24.24 62.87,24.24 61.11,22.47 40.08,22.47 38.49,20.89 34.25,20.89 33.13,19.77 27.26,19.77 26.17,20.86 26.17,23.54 24.19,25.52 24.19,30.49 25.39,31.69 25.39,36.47 24.75,37.12 24.75,38.41 23.93,39.22 23.93,41.56 23.2,42.3 23.2,44.15 22.59,44.76 22.59,46.45 19.67,49.37 19.67,57.34 26.12,63.79 28.38,63.79 29.72,65.13 29.72,68.71 37.37,76.36 37.37,86.42 38.56,87.61 38.56,102.77 43.43,107.64 43.43,110.82 46.29,113.67 46.29,117.28 52.61,123.6 52.61,126.08 52.61,126.24 53.25,126.88 53.25,130.01 55.23,131.99 55.23,146.07 54,147.29 54,152.43 52.41,154.03 49.73,154.03 46.68,157.08 46.68,164.27 48.18,165.76 64.31,165.76 65.82,167.27 65.82,171.38 66.06,171.62 66.06,178.44 72.09,184.46 73.19,184.46 77.56,188.83 80.12,188.83 80.43,189.14 81.57,189.14 v2(81.77,189.34)
  BOTTOM w0.102: v2(234.58,41.69) 234.17,42.09 234.17,42.6 R2360.2 234.83,42.91 234.93,43.01 234.93,44.69 234.47,45.14 234.47,45.41 232.99,46.89 232.99,47.7 232.99,47.7 232.99,48.23 232.95,48.32 232.84,48.43 U2000.AM44
PCH_C1: length 2.8
  TOP w0.102: v2(216.97,70.72) 216.97,70.39 T2502.1
  BOTTOM w0.102: v2(216.97,70.72) 217.38,70.31 217.7,70.31 U2000.C1
PCH_CPUPWRGD: length 6.3
  BOTTOM w0.102: 232.47,69.58 232.47,69.4 232.42,69.36 232.42,68.91 U2000.AM3
  BOTTOM w0.121: 232.47,69.58 232.47,70.35 232.71,70.59 232.71,71.97 231.98,72.71 231.73,72.71 231.48,72.96 231.48,73.5 SR2406.2
PCH_D1: length 2.5
  TOP w0.102: v2(217.58,70.72) 217.58,71.56 T2503.1
  BOTTOM w0.102: U2000.D1 218.44,70.08 218.22,70.08 217.58,70.72 v2(217.58,70.72)
PCH_DEVSLP1: length 252.9
  TOP w0.102: v2(32.77,34.12) 32.77,33.71 32.56,33.5 31.95,33.5 30.99,34.45 30.99,38.97 29.41,40.55 24.65,40.55 23.9,39.8 23.9,33.65 v1(24.2,33.34) 24.2,32.34 24.52,32.02 SR5101.1
  IN1 w0.102: v2(32.77,34.12) 37.34,29.55 37.34,28.24 37.04,27.93 37.04,27.48 37.47,27.04 39.45,27.04 43.02,23.48 69.72,23.48 71.29,25.05 111.86,25.05 113.05,26.24 115.98,26.24 119.09,29.34 128.09,29.34 128.65,28.79 140.66,28.79 143.49,25.95 201.75,25.95 204.45,28.66 204.45,33.04 209.58,38.17 209.58,39.71 210.78,40.9 210.78,42.27 211.64,43.13 229.95,43.13 230.66,42.42 230.66,41.8 v2(230.71,41.75)
  BOTTOM w0.089: U2000.AG43 229.84,48.88 229.84,48.37 229.85,48.36 229.85,47.92 229.72,47.79 229.72,47.45
  BOTTOM w0.102: 229.72,47.45 229.72,45.07 230.6,44.19 230.6,42.59 230.64,42.55 230.64,41.83 v2(230.71,41.75) 230.84,41.63 R2102.2
PCH_DEVSLP3: length 200.8
  TOP w0.102: v2(226.97,50.82) 226.4,50.25 226.4,49.49 225.3,48.39 225.3,46.1 v2(223.75,44.55) 223.69,44.48 v1(222.99,44.48)
  IN3 w0.102: v2(223.75,44.55) 223.08,43.87 205.84,43.87 199.14,37.17 198.19,37.17 196.25,35.23 195.58,35.23 193.13,32.78 190.43,32.78 189.75,32.1 188.79,32.1 187.29,33.6 165.1,33.6 164.62,33.12 164.62,32.32 164.48,32.17 162.33,32.17 160.98,33.52 148.26,33.52 144.57,37.22 143.07,37.22 142.78,37.51 133.01,37.51 131.22,35.72 123.51,35.72 123.21,36.02 122.4,36.02 119.32,32.94 113.15,32.94 112.18,31.98 103.94,31.98 98.36,26.4 61.78,26.4 v2(60.86,25.48)
  BOTTOM w0.102: SR5108.1 50.57,17.76 52.18,17.76 59.9,25.48 v2(60.86,25.48) ; U2000.AB41 227.53,50.26 v2(226.97,50.82)
PCH_DGPU_EN: length 41
  TOP w0.102: v2(251.82,45.22) 251.24,45.8 251.24,47.45 251.67,47.89 v1(252.67,47.89) 253.19,48.41 253.19,48.82 253.19,48.82 253.19,50.67 253.19,50.68 253.19,52.05 252.56,52.69 252.56,54.54 252.24,54.86 250.79,54.86 R2407.2 R2427.1 249.66,54.56 v2(249.66,53.58)
  IN4 w0.102: v2(232.25,56.72) 232.9,56.07 236.81,56.07 240.2,52.69 245.15,52.69 246.54,54.08 247.62,54.08 248.13,53.58 v2(249.66,53.58)
  BOTTOM w0.102: R2496.2 252.1,43.11 252.23,43.24 R2495.2 251.72,43.62 251.62,43.72 251.62,45.02 v2(251.82,45.22) ; v2(232.25,56.72) 232.01,56.97 U2000.AL27
PCH_DRAM_RESET#: length 15.4
  TOP w0.102: R2478.1 244.28,68.74 244.28,68.31 243.79,67.82 241.85,67.82 241.3,67.27 241.3,66.28 240.21,65.19 239.95,65.19 239.1,64.35 238.22,64.35 v2(237.42,63.54) ; v1(247.2,70.59) SR2407.2 R2452.1
  TOP w0.121: C2402.1 R2478.1 R2452.1
  BOTTOM w0.102: v2(237.42,63.54) 237.47,63.6 U2000.BC14
PCH_DSW_PWROK: length 11.6
  TOP w0.102: v2(235.97,65.56) 236.4,65.99 237.25,65.99 237.55,66.29 237.55,66.46 238.52,67.43 238.94,67.43 v1(239.41,67.9) 239.69,68.18 240.31,68.18 240.82,68.69 240.82,71.4 R2476.1 SR2409.2
  BOTTOM w0.102: v2(235.97,65.56) 235.97,65.4 U2000.AV11
PCH_EN_PWR: length 162.2
  TOP w0.102: v2(134.37,42.65) 134.56,42.46 136.38,42.46 140.97,47.05 v2(140.97,48.19)
  IN2 w0.102: v2(251.54,36.84) 251.54,36.54 249.6,34.6 249.32,34.6 248.54,33.81 245.09,33.81 244.53,33.26 241.84,33.26 241,32.42 241,30.89 239.73,29.62 231.4,29.62 230.69,30.33 218.71,30.33 216.55,32.49 199.31,32.49 198.96,32.15 193.19,32.15 192.13,33.22 142.49,33.22 134.02,41.69 134.02,42.3 v2(134.37,42.65)
  BOTTOM w0.102: U7411.1 143.63,47.48 143.84,47.28 145.12,47.28 D7401.1 144.9,46.83 v1(144.25,46.18) 141.92,46.18 140.97,47.13 v2(140.97,48.19) ; R2495.1 252.23,45.02 252.32,45.11 252.32,45.94 252.99,46.61 253.16,46.61 R2498.1 253.3,47.35 251.42,45.46 251.42,36.96 v2(251.54,36.84)
PCH_FLASH_DESCRIPTOR: length 149.8
  TOP w0.102: v2(238.21,79.42) 238.33,79.53 D2301.1 ; v2(189.49,27.77) v1(189.49,29.24) 189.49,30.17 188.09,31.57 188.09,39.79 190.64,42.34 192.62,42.34 192.81,42.53 194.04,42.53 195.1,43.59 195.1,46.18 196,47.08 196,50.75 v2(194.16,52.59) ; v2(154.36,27.52) 154.18,27.69 154.18,30.5 157.7,34.02 160.17,34.02 160.47,34.31 U3002.2
  IN2 w0.102: v2(189.49,27.77) 188.54,28.72 177.68,28.72 176.14,27.17 174.29,27.17 172.91,28.56 162.19,28.56 161.7,28.07 158.83,28.07 157.91,27.15 155.13,27.15 154.76,27.52 v2(154.36,27.52) ; v2(238.21,79.42) 237.74,79.89 236.48,79.89 235.82,79.23 215.32,79.23 208.65,72.56 205.58,72.56 199.83,66.81 199.83,64.34 194.87,59.38 194.87,53.29 v2(194.16,52.59)
  BOTTOM w0.102: v2(154.36,27.52) 154.36,28.14 154.6,28.38 156.55,28.38 157.97,29.8 R3007.2
PCH_GPP_F23: length 58.9
  TOP w0.102: v2(251.91,46.91) 252.32,46.91 253.4,47.99 253.4,48.9 253.39,48.91 253.39,50.59 253.4,50.59 253.4,52.23 252.96,52.66 252.96,56.47 251.75,57.69 v1(251.75,58.2) 252.18,58.63 252.18,59.13 251.32,59.99 251.32,60.18 250.13,61.37 249.79,61.37 249.37,61.8 SR2101.2
  IN3 w0.102: v2(222.28,42.29) 223.46,43.47 226.46,43.47 226.69,43.7 239.71,43.7 240.42,44.41 248.49,44.41 250.99,46.91 v2(251.91,46.91)
  BOTTOM w0.102: U2000.V44 225.54,47.84 225.43,47.73 225.43,46.67 223.91,45.16 223.45,45.16 222.85,44.56 222.26,44.56 221.81,44.11 221.81,43.98 R2146.1 221.9,43.77 222.08,43.59 222.08,42.49 v2(222.28,42.29)
PCH_GSXDIN: length 11.3
  BOTTOM w0.102: U2000.R42 224.17,49.55 224.54,49.19 224.54,48.85 224.53,48.84 224.53,48.48 224.48,48.39 224.41,48.32 224.41,47.11 223.47,46.17 222.92,46.17 222.32,45.57 221.04,45.57 220.42,44.96 219.26,44.96 v1(219.02,44.72) 218.46,44.17 218.46,43.48 218.22,43.24 218.22,43.08 R2261.1
PCH_GSXSLOAD: length 11.6
  TOP w0.102: v2(223.6,52.06) 223.11,51.57 223.11,50.2 223.08,50.13 222.56,49.61 221.95,49.61 220.53,48.19 v1(220.53,47.76) 220.53,47.58 218.67,45.73 218.67,44.4 R2248.2
  BOTTOM w0.102: U2000.R36 223.78,52.06 v2(223.6,52.06)
PCH_GSXSRST#: length 3.1
  TOP w0.102: R2260.1 223.88,49.38 224.01,49.51 224.01,50.08 v2(223.6,50.49) 223.6,50.49 v1(223.6,51.21)
  BOTTOM w0.102: v2(223.6,50.49) 223.76,50.49 U2000.R41
PCH_H_TRST#: length 8.3
  TOP w0.102: SR2301.1 235.44,72.57 v1(235.18,72.32) 234.89,72.02 234.89,68.1 235.11,67.88 235.54,67.88 235.95,67.47 v2(236.28,67.47)
  BOTTOM w0.102: U2000.AY5 236.53,67.47 v2(236.28,67.47)
PCH_JTAG_TCK: length 353.8
  IN3 w0.102: v2(233.41,78.09) 233.41,78.49 233.15,78.75 217.09,78.75 214.84,76.5 214.84,73.96 213.1,72.21 205.49,72.21 200.54,67.26 200.54,64.39 197.62,61.47 197.62,48.52 194.18,45.08 190.62,45.08 187.61,42.08 169.92,42.08 169.39,41.54 154.69,41.54 148.61,47.62 142.3,47.62 141.78,47.1 134.23,47.1 128.86,41.73 121.32,41.73 118.67,39.08 102.51,39.08 96.07,32.65 49.49,32.65 47.66,30.82 47.66,29.32 47.2,28.86 46.24,28.86 43.17,31.93 43.17,40.96 38.29,45.83 38.29,69.06 53.55,84.32 53.55,99.36 51.29,101.62 51.29,105.07 59.63,113.41 59.92,113.41 60.89,114.39 60.89,115.74 v2(61.7,116.56)
  BOTTOM w0.102: SR4403.2 64.28,129.64 63.98,129.33 v1(63.98,128) 64.14,127.83 64.14,124.27 61.91,122.03 61.91,117.41 61.7,117.2 v2(61.7,116.56) ; U2000.AN3 233.23,69.07 233.49,69.33 233.49,69.93 233.59,70.03 233.59,71.82 233.91,72.14 233.91,72.77 233.8,72.88 233.8,73.46 233.74,73.53 R2350.1 234.14,74.33 234.14,76.72 233.41,77.45 v2(233.41,78.09)
PCH_JTAG_TDI: length 5.6
  BOTTOM w0.089: U2000.AP2 233.79,69.38 234.04,69.63 234.04,69.97 234.02,69.99
  BOTTOM w0.102: SR2304.1 235.44,72.75 235.21,72.52 234.87,72.52 234.02,71.67 234.02,69.99
PCH_JTAG_TDO: length 4.6
  BOTTOM w0.102: SR2303.1 234.01,73.36 234.01,72.97 234.12,72.85 234.12,72.06 233.79,71.74 U2000.AP1
PCH_JTAG_TMS: length 8.7
  BOTTOM w0.089: U2000.AR2 234.41,69.46 234.42,69.47 234.42,70.33
  BOTTOM w0.102: v1(236.4,75.7) 236.73,75.37 236.73,74.05 236.85,73.93 SR2302.1 236.79,73.55 236.79,72.65 236.25,72.12 235.04,72.12 234.42,71.5 234.42,70.33
PCH_JTAGX: length 6.6
  BOTTOM w0.089: U2000.AR3 234.16,69.09 234.16,69.48 234.23,69.55 234.23,70.1 234.22,70.11
  BOTTOM w0.102: SR2305.1 236.3,72.87 v1(236.18,72.74) 235.76,72.32 234.96,72.32 234.22,71.59 234.22,70.11
PCH_NMI#: length 12.4
  BOTTOM w0.102: R2205.2 213.65,44.25 214.51,45.12 215.5,45.12 v1(215.55,45.17) 216.36,45.98 219.79,45.98 220.45,46.64 221.49,46.64 222.92,48.06 222.92,48.78 U2000.N43
PCH_OCB4: length 7.2
  BOTTOM w0.102: U2000.Y43 226.79,48.82 226.79,48.47 226.74,48.38 226.66,48.3 226.66,46.23 225.2,44.78 225.2,44.08 v1(224.95,43.82) 224.9,43.77 R2114.2
PCH_OCB5: length 13
  TOP w0.102: R2113.2 221.18,41.52 221.18,43.95 222.44,45.22 223.7,45.22 v1(224.39,45.9) 225.02,46.54 225.02,48.6 225.8,49.37 v2(225.8,50.45)
  BOTTOM w0.102: v2(225.8,50.45) 226.18,50.07 U2000.Y41
PCH_OCB6: length 11.1
  BOTTOM w0.102: R2115.2 222.55,40.76 222.42,40.76 v1(222.05,41.13) 222.69,41.76 222.69,42.48 222.56,42.6 222.56,44.03 222.89,44.36 222.97,44.36 223.56,44.95 224,44.95 226.25,47.21 226.25,48.14 226.02,48.49 U2000.W44
PCH_OCB7: length 7.4
  BOTTOM w0.102: U2000.W43 226.28,48.97 226.28,48.46 226.45,48.2 226.45,46.77 v1(225.81,46.13) 225.06,45.39 225.06,45.28 223.92,44.14 223.36,44.14 R2116.2
PCH_PLTRST#: length 12.4
  TOP w0.102: v2(237.25,56.71) 237.43,56.53 238.73,56.53 239.46,55.8 241.01,55.8 241.39,55.41 243.15,55.41 243.4,55.66 243.4,56.28 244.05,56.94 244.05,57.17 244.62,57.74 245.13,57.74 SR2405.2 245.43,58.49 245.05,58.88 v1(244.58,58.88)
  BOTTOM w0.102: v2(237.25,56.71) 237.25,56.81 U2000.BB27
PCH_PME_IN#: length 4.4
  BOTTOM w0.102: R2250.2 242.55,61.49 242.44,61.38 242.23,61.38 242.23,61.38 241.14,61.38 241.14,61.38 240.77,61.38 240.48,61.67 238.76,61.67 U2000.BD17
PCH_PWROK: length 38.6
  TOP w0.102: R2475.1 242.55,68.43 242.34,68.23 241.69,68.23 240.14,66.68 238.63,66.68 238.16,66.2 238.16,65.45 237.66,64.95 236.33,64.95 v2(235.85,64.47)
  TOP w0.121: R2475.1 243.05,69.46 v2(243.05,70.86)
  BOTTOM w0.102: U2000.AW11 236.12,64.78 236.12,64.74 v2(235.85,64.47) ; v1(251.49,76.87) 251.49,76.38 251.19,76.09 U2402.4 251.71,75.43 251.8,75.34 251.8,74.28 252.2,73.87 R2493.2 R2494.2 256.62,73.87 256.98,73.51 256.98,71.91 255.78,70.72 253.76,70.72 253.28,71.19 252.62,71.19 251.95,71.86 249.15,71.86 248.48,71.19 245.92,71.19 245.42,71.69 243.32,71.69 243.05,71.41 v2(243.05,70.86)
PCH_RCIN#: length 16.9
  TOP w0.102: v2(234.17,62.49) 234.81,63.13 237.58,63.13 238.59,64.14 239.19,64.14 240.03,64.99 240.3,64.99 241.5,66.2 241.5,67.19 241.94,67.62 243.13,67.62 C2200.1 243.94,66.81 v1(244.56,66.81) 245.08,66.81 R2202.2 245.87,67.6 246.21,67.6 246.31,67.69 SR2201.2
  BOTTOM w0.102: U2000.AT17 234.68,62.08 234.57,62.08 v2(234.17,62.49)
PCH_RSMRST#: length 17.5
  TOP w0.102: v2(237.22,65.56) 237.75,66.1 237.75,66.37 238.46,67.09 239.5,67.09 241.03,68.61 241.03,71.6 240.82,71.8 240.82,73.86 240.7,73.98 SR2409.1 240.39,74.29 240.58,74.48 241.75,74.48 242.12,74.85 v1(242.12,75.8) 242.12,76.36 R2477.1 242.07,77.22 242.07,77.5 242.23,77.66 SR2408.2
  BOTTOM w0.102: U2000.BA11 237.12,65.46 v2(237.22,65.56)
PCH_SATALED#: length 431.2
  TOP w0.102: v2(84.92,183.06) 86.65,184.79 89.01,184.79 89.26,184.54 93.28,184.54 93.39,184.65 D5601.1
  IN2 w0.102: v2(84.92,183.06) 83.92,182.06 81.5,182.06 75.09,175.66 75.09,171.42 73.35,169.69 73.35,161.95 71.6,160.19 71.6,154.55 70.12,153.06 70.12,149.6 68.76,148.25 68.76,144.92 65.82,141.97 65.82,135.14 66.48,134.48 66.48,128.52 68.23,126.77 68.23,122.51 69.42,121.33 69.42,118.34 65.53,114.46 65.53,113.4 58.8,106.67 53.19,106.67 46.82,100.29 46.82,99.63 46.82,91.8 47.33,91.29 v2(47.61,91.29)
  IN3 w0.102: v2(227.22,38.34) 226.82,37.93 226.22,37.93 225.18,38.97 217.07,38.97 212.51,34.41 205.69,34.41 203.63,32.34 199.16,32.34 195.81,29 187.49,29 186.94,29.55 185.88,29.55 185.61,29.81 171.57,29.81 171.43,29.67 168.16,29.67 167.34,28.85 159.23,28.85 158.69,29.39 146.92,29.39 142.78,33.54 134.29,33.54 132,31.25 126.48,31.25 125.96,31.77 125.36,31.77 124.94,31.35 121.18,31.35 115.87,26.04 108.49,26.04 105.14,22.69 98.41,22.69 96.98,24.11 63.18,24.11 60.56,21.5 40.75,21.5 39.1,23.15 32.75,23.15 31.55,24.34 31.55,26.68 30.79,27.44 30.79,45.45 29.22,47.02 28.38,47.02 26.9,48.5 26.02,48.5 25.08,49.44 25.08,55.61 30.28,60.81 30.28,68.74 47.61,86.06 v2(47.61,91.29)
  BOTTOM w0.089: 228.56,47.45 228.56,47.59 228.81,47.84 U2000.AD44
  BOTTOM w0.102: v2(227.22,38.34) 227.22,37.89 227.37,37.74 v1(227.68,37.74) 228.07,38.13 228.07,39.33 228,39.4 228,39.81 227.92,39.89 227.92,40.68 R2106.2 228.34,41.1 227.79,41.66 227.79,44.71 228.56,45.47 228.56,47.45
PCH_SLP_S3#: length 13.9
  TOP w0.102: SR2401.2 233.53,73.31 234.38,72.46 T2407.1 234.38,68.68 233.36,67.65 233.36,64.3 233.62,64.04 234.78,64.04 v2(235.26,63.56)
  BOTTOM w0.102: v2(235.26,63.56) 235.53,63.56 236.03,63.05 U2000.AW15
PCH_SLP_S4#: length 10.3
  BOTTOM w0.102: SR2402.2 247.8,64.65 247.72,64.73 T2406.1 246.92,64.38 244.1,64.38 243.73,64.01 242.69,64.01 241.77,63.09 238.65,63.09 U2000.BD15
PCH_SLP_S5#: length 12.4
  TOP w0.102: v2(236.12,63.54) 236.96,64.37 237.36,64.37 238.36,65.37 238.36,66.12 238.72,66.48 240.22,66.48 241.77,68.03 243.39,68.03 243.8,68.43 T2405.1 243.8,69.05 SR2403.2
  BOTTOM w0.102: v2(236.12,63.54) 236.63,64.04 U2000.BA13
PCH_SLP_WLAN#: length 12
  TOP w0.102: T2403.1 241.57,70.45 241.24,70.12 241.24,69.06 241.33,68.98 SR2404.2 241.66,68.51 240.03,66.88 238.55,66.88 237.95,66.29 237.95,65.72 237.39,65.16 235.82,65.16 235.16,64.49 v2(235.16,64.47)
  BOTTOM w0.102: v2(235.16,64.47) 235.16,64.32 U2000.AV13
PCH_SML2ALERT#: length 12.1
  BOTTOM w0.102: R2464.2 R2484.2 247.76,50.73 v1(247.61,50.88) 247.35,50.63 246.48,50.63 246.38,50.73 244.46,50.73 243.83,51.36 242.86,51.36 242.7,51.52 242.2,51.52 241.97,51.29 241.62,51.29 241.37,51.54 240.82,51.54 240,52.36 238.98,52.36 U2000.BD35
PCH_SRCCLKREQ2#: length 11.9
  TOP w0.102: v2(234.49,57.74) 234.92,57.31 235.26,57.31 235.44,57.13 v1(235.95,57.13) 237.42,57.13 237.79,56.76 238.83,56.76 239.56,56.03 241.1,56.03 241.49,55.64 243.06,55.64 243.15,55.73 243.15,56.88 R2411.2
  BOTTOM w0.102: U2000.AT24 234.49,57.92 v2(234.49,57.74)
PCH_SRCCLKREQ4#: length 11.2
  TOP w0.102: v1(234.8,59.01) 235.49,59.01 v2(235.49,59.02) 236.1,58.41 237.64,58.41 238,58.05 240.62,58.05 240.94,58.37 241.32,58.37 241.32,58.37 241.49,58.37 241.95,58.83 242.59,58.83 R2422.2
  BOTTOM w0.102: U2000.BB24 237.47,58.6 235.92,58.6 v2(235.49,59.02)
PCH_SRCCLKREQ5#: length 4.8
  BOTTOM w0.102: R2423.2 242.97,57.61 241.51,57.61 241,58.11 v1(241,58.5) 240.57,58.07 239.18,58.07 U2000.BE25
PCH_SRCCLKREQ6#: length 16.9
  TOP w0.102: R2428.2 247.66,52.77 247.66,51.6 247.37,51.32 246.36,51.32 v1(245.55,50.5) 241.61,50.5 240.77,51.34 239.55,51.34 238.99,51.9 238.7,51.9 237.84,52.76 235.45,52.76 v2(234.78,53.43)
  BOTTOM w0.102: U2000.AT33 234.7,53.51 v2(234.78,53.43)
PCH_SRCCLKREQ11#: length 14.9
  BOTTOM w0.102: R2433.2 250.55,50.86 250.6,50.91 250.6,51.8 250.35,52.05 v1(250.04,52.05) 249.49,52.05 249.28,52.26 247.69,52.26 247.42,52.53 244.51,52.53 244.43,52.61 242.63,52.61 242.55,52.53 241.48,52.53 241.43,52.48 241.02,52.48 240.29,53.22 239.54,53.22 239.14,53.63 238.43,53.63 U2000.BC33
PCH_SUSACK#: length 8.4
  TOP w0.102: T2205.1 242.08,60.73 241.58,60.73 240.9,60.05 236.96,60.05 236.91,60.1 v2(236.58,60.1)
  BOTTOM w0.102: v2(236.58,60.1) 236.78,59.9 237.33,59.9 237.39,59.85 237.67,59.85 237.86,60.04 237.86,60.48 U2000.BB19
PCH_SYS_PWROK: length 24.5
  IN2 w0.102: v2(239.63,77.91) 240.29,77.25 244.89,77.25 v2(246.11,78.47)
  BOTTOM w0.102: U2000.AY1 236.49,69.94 236.49,71.16 237.35,72.03 237.81,72.03 238.89,73.11 239.27,73.11 R2479.1 239.38,74.12 239.38,75.42 239.63,75.67 v2(239.63,77.91)
  BOTTOM w0.121: v2(246.11,78.47) 247.5,78.47 v1(248.16,77.81) 247.83,77.48 R2489.2 247.83,76.36 248.12,76.07 U2403.4 247.37,75.51 246.87,75.01 R2491.2
PCH_TGR_L900MIL: length 6.1
  BOTTOM w0.121: U2000.AL2 232.24,69.7 232.24,70.44 232.49,70.68 232.49,71.88 232.08,72.3 v1(231.45,72.3) 231.22,72.3 230.9,72.62 230.9,73.23 R2326.1
PCH_THMTRIP#_R: length 11.4
  BOTTOM w0.089: 231,69.98 231,69.64 231.11,69.53 231.11,69.04 U2000.AJ3
  BOTTOM w0.121: 231,69.98 231,70.71 230.45,71.26 229.65,71.26 228.51,72.4 227.08,72.4 226.67,72.81 226.67,73.32 226.32,73.67 226.32,73.82 R2454.1 225.79,74.35 225.79,75.97 v1(226.28,76.46)
PCH_VR_ICC_THROTTLING: length 9.7
  BOTTOM w0.102: R2408.2 246.79,60.56 246.41,60.17 244.68,60.17 244.48,60.38 240.93,60.38 240.75,60.2 240.74,60.2 240.67,60.13 239.81,60.13 238.73,59.05 U2000.BD23
PCH_VSS_AB10: length 5.6
  TOP w0.254: v1(228.68,66.48) 228.53,66.48 v2(228.06,66.01) 227.75,66.01 227.49,66.28 227.49,68.95 227.27,69.17 SR2702.1
  BOTTOM w0.254: U2000.AB10 227.66,65.61 v2(228.06,66.01)
PCH_VSS_AB11: length 2.2
  TOP w0.254: v1(228.68,64.73) 228.57,64.73 v2(228.05,65.24) 228.04,65.26 SR2701.1
  BOTTOM w0.254: U2000.AB11 227.66,64.85 v2(228.05,65.24)
PCHXDP_OBSDATA_A0_R: length 13.5
  TOP w0.102: v2(229.34,52.69) 228.61,51.95 228.61,49.61 228.14,49.14 228.14,47.27 v1(227.44,46.57) 227.18,46.31 R2107.2 227.59,43.36 227.59,41.67 227.66,41.59 R2111.1
  BOTTOM w0.102: U2000.AG35 229.59,52.69 v2(229.34,52.69)
PCHXDP_OBSDATA_A1_R: length 10.5
  TOP w0.102: v2(228.2,50.4) 227.78,49.98 227.71,49.98 226.57,48.84 226.57,45.7 226.29,45.42 v1(226.29,44.79) R2112.1 R2108.2
  BOTTOM w0.102: U2000.AG39 229.32,50.78 228.94,50.4 v2(228.2,50.4)
PCHXDP_OBSDATA_A2_R: length 7.3
  BOTTOM w0.089: U2000.AF41 230.24,49.75 230.24,49.17 230.32,49.09 230.32,48.63 230.33,48.62 230.33,48.4 230.22,48.28 230.22,47.75 230.13,47.66 230.13,47.45
  BOTTOM w0.102: R2100.2 231.91,44 v1(231.22,44.69) 230.13,45.78 230.13,47.45
PCHXDP_OBSDATA_B1_R: length 7.6
  BOTTOM w0.089: 229.26,47.45 229.34,47.54 229.34,48.06 U2000.AE45
  BOTTOM w0.102: R2103.2 229.36,41.76 229.36,41.97 v1(229.3,42.02) 229.06,42.26 229.06,45.12 229.26,45.31 229.26,47.45
PCHXDP_OBSDATA_B2_R: length 10.3
  BOTTOM w0.089: U2000.AE44 229.43,48.53 229.16,48.27 229.16,47.65 228.97,47.45
  BOTTOM w0.102: v1(229.01,38.95) 229.01,39.71 228.78,39.94 228.78,40.7 R2104.2 229.19,41.43 228.86,41.76 228.86,45.2 228.97,45.31 228.97,47.45
PCHXDP_PRDY#: length 8.1
  BOTTOM w0.089: U2000.AT4 234.66,68.48 234.66,69.52 234.61,69.56 234.61,70.05 234.65,70.09
  BOTTOM w0.102: R2325.1 238.06,73.49 237.9,73.33 v1(237.9,73.01) 237.9,72.95 237.48,72.53 237.29,72.53 236.67,71.92 235.12,71.92 234.65,71.44 234.65,70.09
PCHXDP_PREQ_R#: length 373.3
  TOP w0.102: v2(59.16,109.33) 59.67,108.82 v1(59.95,108.82)
  IN2 w0.102: v2(59.16,109.33) 60.43,110.6 60.43,112.55 62.11,114.23 62.11,117.37 62.95,118.21 62.95,122.9 63.28,123.23 63.28,128.09 62.69,128.67 62.69,134.09 64.19,135.59 64.19,139.35 v2(63.86,139.68)
  IN3 w0.102: v2(59.16,109.33) 55.84,109.33 51.49,104.98 51.49,101.71 53.75,99.44 53.75,84.24 38.49,68.98 38.49,46.06 43.44,41.11 43.44,31.94 46.32,29.06 47.11,29.06 47.45,29.4 47.45,30.9 49.4,32.85 95.99,32.85 102.42,39.28 118.59,39.28 121.23,41.93 128.78,41.93 134.15,47.3 141.69,47.3 142.21,47.82 148.7,47.82 154.78,41.74 169.3,41.74 169.84,42.28 187.53,42.28 190.54,45.29 194.1,45.29 197.35,48.54 197.35,61.49 200.34,64.48 200.34,67.34 205.42,72.43 210.47,72.43 217,78.95 234.77,78.95 236.02,77.7 236.02,77.02 236.39,76.65 237.4,76.65 238.42,75.62 238.42,73.66 236.28,71.51 v2(235.91,71.51)
  BOTTOM w0.102: v2(63.86,139.68) 64.98,139.68 65.21,139.91 R4403.2 ; v2(235.91,71.51) 235.91,70.22 235.18,69.49 235.18,69.06 234.92,68.81 U2000.AT3
PCI_IRQA: length 13.6
  TOP w0.121: v2(235.6,61.24) 236.33,61.97 236.78,61.97 237.5,62.69 237.77,62.69 238.78,63.7 239.37,63.7 240.02,64.36 v1(240.52,64.36) 241.43,64.36 242.42,65.34 243.24,65.34 R2206.2 243.66,65.25 244.25,65.84 245.04,65.84 SR2208.2
  BOTTOM w0.121: U2000.AW17 236.17,61.7 236.06,61.7 v2(235.6,61.24)
PCIE_CLK_N_GPU: length 165.8
  IN1 w0.102: v2(139.02,94.11) 138.61,94.52 135.31,94.52 132.28,91.49 132.28,82.7 131.08,81.5 131.08,78.81 130.45,78.18 130.45,62.93 151.86,41.52 188.08,41.52 191.9,45.35 192.29,45.35 194.89,47.95 194.89,59.1 202.22,66.43 v2(202.22,67.42)
  BOTTOM w0.121: v2(139.02,94.11) 139.25,93.89 142.76,93.89 143.01,94.14 143.64,94.14 U7000.BM27 ; 202.32,70.21 202.32,70.63 204.21,72.52 209.8,72.52 212.29,75 212.82,75 213.86,76.04 220.14,76.04 220.38,75.81 220.38,75.61 SR2516.2 ; 202.32,70.21 202.32,69.35 201.82,68.85 201.82,67.82 v2(202.22,67.42) ; 202.32,70.21 v1(202.54,70.21)
PCIE_CLK_N_GPU_R: length 6.8
  BOTTOM w0.121: U2000.N3 222.69,69.2 222.69,71.29 220.32,73.66 220.32,74.17 SR2516.1
PCIE_CLK_P_GPU: length 165.7
  IN1 w0.102: v2(201.76,66.99) 201.99,66.76 201.99,66.51 194.67,59.19 194.67,48.04 192.2,45.56 191.81,45.56 187.99,41.74 151.95,41.74 130.66,63.02 130.66,78.09 131.3,78.72 131.3,81.41 132.49,82.61 132.49,91.4 135.4,94.3 138.16,94.3 138.39,94.08 v2(138.39,94.07)
  BOTTOM w0.121: v2(138.39,94.07) 138.81,93.65 142.85,93.65 143.11,93.9 143.51,93.9 143.75,93.66 U7000.BM26 ; v2(201.76,66.99) 201.76,67.54 201.58,67.72 201.58,68.16 ; 201.58,68.16 201.58,68.94 202.09,69.45 202.09,70.72 204.12,72.75 209.71,72.75 212.19,75.23 212.72,75.23 213.76,76.28 220.24,76.28 220.61,75.9 220.61,75.6 SR2515.2 ; 201.58,68.16 v1(201.36,68.16)
PCIE_CLK_P_GPU_R: length 6.9
  BOTTOM w0.121: SR2515.1 221.19,74.19 221.19,74.04 221.1,73.95 220.88,73.95 220.8,74.03 220.62,74.03 220.55,73.96 220.55,73.76 222.93,71.39 222.93,69.47 U2000.N2
PCIE_LAN_TXN: length 10.8
  BOTTOM w0.089: U2000.B21 217.77,60.01 217.52,60.25 216.64,60.25 216.52,60.14
  BOTTOM w0.102: 216.51,60.14 216.52,60.14
  BOTTOM w0.121: 211.54,57.54 211,57 C2013.2 ; 211.54,57.54 211.73,57.74 211.73,57.94 213.69,59.9 214.38,59.9 214.49,60.01 216.11,60.01 216.24,60.14 216.51,60.14 ; 211.54,57.54 v1(211.36,57.72)
PCIE_LAN_TXP: length 10.7
  BOTTOM w0.102: 216.59,59.9 216.76,60.07 217.32,60.07 U2000.A21
  BOTTOM w0.121: 209.94,56.77 209.6,56.77 209.48,56.65 209.48,56.21 209.38,56.11 C2012.2 ; 209.94,56.77 v1(209.94,56.55) ; 209.94,56.77 211.1,56.77 211.97,57.64 211.97,57.85 213.79,59.67 214.48,59.67 214.59,59.77 216.21,59.77 216.34,59.9 216.59,59.9
PCIE_RCOMPN: length 2.5
  TOP w0.381: R2516.2 v2(216.16,62.13)
  BOTTOM w0.203: U2000.B18 217.41,61.62 217.39,61.64 216.61,61.64 216.34,61.91 216.16,62.09 v2(216.16,62.13)
PCIE_RCOMPP: length 3.1
  TOP w0.381: v2(216.92,62.13) 217.02,62.02 R2516.1 v1(217.94,61.5)
  BOTTOM w0.203: v2(216.92,62.13) 217.1,61.95 217.9,61.95 218.13,61.71 U2000.C17
PCIE_RXN7_WLAN: length 109.1
  IN4 w0.102: v2(221.93,62.51) 221.31,63.14 218.64,63.14 217.85,63.93 214.52,63.93 213.85,64.6 213.85,65.76 214.4,66.31 214.4,67.69 216.66,69.95 218.63,69.95 225.06,76.37 232.39,76.37 232.99,75.78 238.29,75.78 238.88,76.37 249.4,76.37 249.84,75.93 252.13,75.93 257.71,81.51 259.13,81.51 262.27,84.64 269.3,84.64 270.66,86 277.95,86 278.24,85.71 279.63,85.71 279.93,86 286.63,86 287.66,87.03 291.62,87.03 293.39,88.79 297.38,88.79 297.91,89.33 297.91,89.63 v2(298.05,89.77)
  BOTTOM w0.121: CON5300.43 298.25,90.96 298.08,90.79 298.08,89.8 v2(298.05,89.77) ; U2000.L17 222.4,61.91 221.93,62.38 v2(221.93,62.51)
PCIE_RXN8_WIGI: length 125.4
  IN1 w0.102: v2(219.49,62.51) 219.49,62.18 219.8,61.87 224,61.87 224.25,62.12 231.29,62.12 233.36,64.19 233.36,73.31 234.7,74.66 239,74.66 240.06,75.72 242.21,75.72 242.87,75.06 244.35,75.06 245.01,75.72 249.41,75.72 249.61,75.93 250.58,75.93 250.73,75.78 253.19,75.78 254.53,74.44 254.53,73.15 255.58,72.09 255.58,70.87 256.79,69.67 256.79,67.81 258.44,66.16 271.52,66.16 272.03,65.65 281.02,65.65 283.03,63.65 287.98,63.65 291.69,67.36 291.69,68.3 294,70.61 294,71.01 295.55,72.56 295.55,76.57 304.95,85.97 304.95,88.44 v2(305.57,89.06)
  BOTTOM w0.121: CON5300.65 303.75,90.95 303.88,90.82 303.88,90.06 304.88,89.06 v2(305.57,89.06) ; U2000.E17 219.49,62.04 v2(219.49,62.51)
PCIE_RXP7_WLAN: length 109
  IN4 w0.102: v2(297.41,89.77) 297.69,89.49 297.69,89.41 297.29,89.01 293.3,89.01 291.53,87.24 287.57,87.24 286.54,86.21 279.76,86.21 279.51,85.96 278.36,85.96 278.11,86.21 270.57,86.21 269.21,84.86 262.18,84.86 259.04,81.73 257.62,81.73 252.04,76.14 249.93,76.14 249.49,76.59 238.79,76.59 238.2,75.99 233.07,75.99 232.48,76.59 224.97,76.59 218.54,70.16 216.57,70.16 214.18,67.78 214.18,66.4 213.63,65.85 213.63,64.51 214.43,63.71 217.76,63.71 218.55,62.92 221.22,62.92 221.32,62.82 v2(221.32,62.51)
  BOTTOM w0.121: v2(221.32,62.51) 221.32,62.24 U2000.K17 ; v2(297.41,89.77) 297.84,90.2 297.84,90.84 297.75,90.93 CON5300.41
PCIE_RXP8_WIGI: length 125.4
  IN1 w0.102: v2(220.1,62.51) 219.83,62.24 219.83,62.15 219.89,62.08 223.91,62.08 224.16,62.34 231.2,62.34 233.14,64.28 233.14,73.4 234.61,74.87 238.91,74.87 239.97,75.94 242.3,75.94 242.96,75.28 244.26,75.28 244.93,75.94 249.32,75.94 249.52,76.14 250.67,76.14 250.82,75.99 253.28,75.99 254.74,74.53 254.74,73.24 255.8,72.18 255.8,70.96 257,69.76 257,67.9 258.53,66.38 271.61,66.38 272.12,65.87 281.11,65.87 283.11,63.86 287.89,63.86 291.47,67.44 291.47,68.38 293.78,70.7 293.78,71.1 295.33,72.65 295.33,76.66 304.73,86.06 304.73,88.53 305.14,88.93 305.14,89.29 v2(305.57,89.72)
  BOTTOM w0.121: U2000.G17 219.87,62.17 219.87,62.28 v2(220.1,62.51) ; CON5300.67 304.25,90.94 304.12,90.81 304.12,90.16 304.98,89.29 305.14,89.29 v2(305.57,89.72)
PCIE_SATA_PEDET: length 2.4
  BOTTOM w0.102: CON5103.69 T5103.1
PCIE_SATA_PEDET1: length 6.6
  TOP w0.102: v2(33.99,12.17) 33.51,11.69 33.51,11.01 34.04,10.47 T5105.1
  BOTTOM w0.102: v2(33.99,12.17) 35.79,12.17 36.05,12.43 36.05,12.94 35.75,13.23 CON5104.69
PCIE_SATA_RXN0: length 207.3
  IN4 w0.114: v2(33.43,29.48) 33.43,29.25 33.61,29.07 34.1,29.07 34.4,29.37 34.93,29.37 35.56,30 38.09,30 40.03,28.06 69.52,28.06 70.15,27.43 115.48,27.43 117.54,29.48 141.95,29.48 142.69,28.75 158.39,28.75 158.62,28.52 192.91,28.52 198.47,34.08 198.65,34.08 206.37,41.8 206.37,42.28 210.89,46.81 214.7,46.81 216.1,48.2 216.1,48.46 217.49,49.86 217.49,53.16 219.14,54.81 220.01,54.81 220.11,54.91 220.11,55.03 v2(219.72,55.43)
  BOTTOM w0.133: v2(219.72,55.43) 219.92,55.43 220.05,55.3 U2000.G31 ; CON5102.43 32.06,28.45 32.27,28.66 32.42,28.66 32.75,29 32.95,29 v2(33.43,29.48)
PCIE_SATA_RXN1: length 209
  IN4 w0.114: v2(220.33,56.42) 219.9,55.99 219.62,55.99 217.18,53.54 217.18,50.1 214.19,47.11 212.62,47.11 212.48,47.25 210.75,47.25 205.77,42.28 205.77,41.8 199.42,35.45 198.84,35.45 198.07,34.67 198.07,34.27 192.74,28.94 158.83,28.94 158.48,29.29 143.39,29.29 142.75,29.93 133.42,29.93 132.69,30.66 126.7,30.66 126.42,30.39 124.27,30.39 123.57,31.08 118.69,31.08 117.8,31.97 113.61,31.97 110.16,28.52 44.9,28.52 43,30.42 35.22,30.42 34.88,30.08 v2(33.56,30.08)
  BOTTOM w0.133: v2(220.33,56.42) 220.33,56.31 U2000.G29 ; v2(33.56,30.08) 33.56,31.02 33.23,31.35 32.34,31.35 31.74,31.95 CON5102.29
PCIE_SATA_RXN2: length 217
  IN4 w0.114: v2(33.69,27.68) 33.97,27.97 34.55,27.97 34.68,28.09 38.07,28.09 39.2,26.96 68.69,26.96 69.33,26.31 116.12,26.31 118.2,28.38 141.48,28.38 143.29,26.58 162.54,26.58 162.77,26.8 187,26.8 187.07,26.73 189.69,26.73 190.16,27.21 193.17,27.21 198.94,32.98 199.25,32.98 207.55,41.28 207.55,41.9 211.35,45.7 215.55,45.7 218.42,48.57 218.42,52.56 219.59,53.73 220.84,53.73 221.88,54.76 v2(221.88,55.39)
  BOTTOM w0.133: CON5102.17 31.97,34.95 32.06,34.86 33.17,34.86 34.83,33.2 34.83,28.82 v2(33.69,27.68) ; v2(221.88,55.39) 221.88,55.32 U2000.L31
PCIE_SATA_RXN3: length 220.9
  IN4 w0.114: v2(221.14,53.32) 221.29,53.17 221.29,53.04 221.14,52.89 220.2,52.89 220.05,53.04 219.33,53.04 218.66,52.37 218.66,48.2 215.77,45.31 212.06,45.31 208.43,41.68 208.43,39.39 201.59,32.56 199.11,32.56 193.26,26.71 190.46,26.71 190.05,26.3 186.34,26.3 186.25,26.39 163.17,26.39 162.64,25.85 143.23,25.85 141.99,27.08 132.92,27.08 132.42,27.59 128.3,27.59 127.79,27.08 123,27.08 122.45,27.63 118.36,27.63 116.61,25.88 61.92,25.88 61.35,26.45 47.25,26.45 46.01,25.2 36.71,25.2 35.25,26.66 35.25,27.27 v2(35.57,27.59)
  BOTTOM w0.133: v2(221.14,53.32) 220.91,53.55 220.83,53.55 220.59,53.79 220.59,53.92 220.48,54.03 220.37,54.03 U2000.G33 ; CON5102.5 31.96,37.95 32.18,37.74 32.76,37.74 33.55,36.95 33.91,36.95 35.36,35.49 35.36,34.39 35.65,34.1 35.65,28.36 35.37,28.08 35.37,27.79 v2(35.57,27.59)
PCIE_SATA_RXP0: length 207.4
  IN4 w0.114: v2(220.45,55.43) 220.45,54.77 220.15,54.46 219.29,54.46 217.84,53.01 217.84,49.71 216.44,48.32 216.44,48.06 214.84,46.46 211.04,46.46 206.71,42.14 206.71,41.66 198.79,33.74 198.61,33.74 193.05,28.18 158.47,28.18 158.25,28.4 142.55,28.4 141.81,29.14 117.68,29.14 115.63,27.08 70.01,27.08 69.37,27.72 39.88,27.72 37.95,29.66 35.7,29.66 35.07,29.03 34.54,29.03 34.24,28.73 33.47,28.73 v2(32.77,29.42)
  BOTTOM w0.133: U2000.H31 220.81,55.07 v2(220.45,55.43) ; v2(32.77,29.42) 32.3,28.95 CON5102.41
PCIE_SATA_RXP1: length 209
  IN4 w0.114: v2(219.56,56.42) 216.83,53.69 216.83,50.24 214.05,47.45 212.76,47.45 212.62,47.59 210.6,47.59 205.43,42.42 205.43,41.94 199.28,35.79 198.7,35.79 197.73,34.81 197.73,34.42 192.59,29.28 158.97,29.28 158.62,29.64 143.53,29.64 142.9,30.27 133.56,30.27 132.83,31.01 126.56,31.01 126.28,30.73 124.41,30.73 123.71,31.43 118.83,31.43 117.94,32.32 113.47,32.32 110.01,28.86 45.04,28.86 43.14,30.76 35.07,30.76 34.74,30.42 33.9,30.42 33.83,30.49 33.31,30.49 v2(32.87,30.06)
  BOTTOM w0.133: v2(219.56,56.42) 219.72,56.27 219.72,56.16 219.56,56 U2000.E29 ; v2(32.87,30.06) 33.27,30.46 33.27,30.9 33.11,31.06 32.22,31.06 31.84,31.45 CON5102.31
PCIE_SATA_RXP2: length 217.1
  IN4 w0.114: v2(33.13,27.92) 33.37,28.16 33.69,28.16 33.83,28.31 34.41,28.31 34.53,28.43 38.21,28.43 39.34,27.3 68.83,27.3 69.48,26.65 115.98,26.65 118.05,28.72 141.63,28.72 143.43,26.92 162.4,26.92 162.63,27.15 187.14,27.15 187.21,27.07 189.54,27.07 190.02,27.55 193.02,27.55 198.79,33.32 199.1,33.32 207.21,41.42 207.21,42.04 211.21,46.04 215.41,46.04 218.08,48.71 218.08,52.7 219.45,54.07 220.7,54.07 221.54,54.9 221.54,55.05 v2(221.17,55.42)
  BOTTOM w0.133: v2(33.13,27.92) 33.31,28.1 33.71,28.1 34.54,28.94 34.54,33.08 33.05,34.58 32.03,34.58 31.9,34.45 CON5102.19 ; U2000.K31 221.25,54.86 221.17,54.94 v2(221.17,55.42)
PCIE_SATA_RXP3: length 221
  IN4 w0.114: v2(221.78,53.33) 221.63,53.19 221.63,52.9 221.28,52.55 220.06,52.55 219.9,52.7 219.48,52.7 219.01,52.23 219.01,48.06 215.91,44.97 212.2,44.97 208.77,41.54 208.77,39.25 201.73,32.21 199.25,32.21 193.4,26.36 190.6,26.36 190.2,25.96 186.19,25.96 186.11,26.04 163.32,26.04 162.78,25.51 143.08,25.51 141.85,26.74 132.78,26.74 132.27,27.25 128.44,27.25 127.94,26.74 122.85,26.74 122.31,27.29 118.5,27.29 116.75,25.53 61.78,25.53 61.2,26.11 47.39,26.11 46.15,24.86 36.57,24.86 34.91,26.52 v2(34.91,27.59)
  BOTTOM w0.133: v2(221.78,53.33) 221.24,53.87 U2000.H33 ; v2(34.91,27.59) 35.08,27.77 35.08,28.2 35.36,28.48 35.36,33.99 35.08,34.27 35.08,35.37 33.79,36.66 33.43,36.66 32.64,37.45 CON5102.7
PCIE_SATA_TXN0: length 218.6
  IN4 w0.114: v6(27.86,27.41) 27.86,27.68 27.57,27.97 26.22,27.97 24.72,29.47 24.72,30.79 25.01,31.09 25.01,35.86 26.36,37.21 30.57,37.21 31.26,37.89 32.71,37.89 33.84,36.76 38.74,36.76 38.97,36.53 42.42,36.53 43.39,35.57 55.25,35.57 55.68,36 100.49,36 101.67,37.18 109.09,37.18 110.17,38.26 120.22,38.26 121.3,39.34 138.76,39.34 140.94,37.15 146.96,37.15 148.2,35.92 187.48,35.92 187.93,36.37 188.87,36.37 191.5,39 192.1,39 193.74,40.63 194.7,40.63 196.8,42.73 197.19,42.73 199.94,45.48 199.94,46.71 206.48,53.25 207.06,53.25 207.69,53.87 212.74,53.87 212.91,53.7 214,53.7 215.15,54.86 215.67,54.86 215.73,54.92 v2(216.01,54.92)
  BOTTOM w0.089: U2000.C31 218.09,54.89 217.83,55.15 216.62,55.15 216.39,54.92 v2(216.01,54.92)
  BOTTOM w0.133: v6(27.86,27.41) 28.08,27.19 28.38,27.19 C5131.1
PCIE_SATA_TXN0_C: length 1.8
  BOTTOM w0.133: C5131.2 29.75,27.13 29.98,27.13 30.29,27.45 CON5102.47
PCIE_SATA_TXN1: length 212.6
  IN4 w0.114: v2(27.86,30.46) 27.56,30.17 27.25,30.17 26.12,31.3 26.12,35.08 27.01,35.97 30.62,35.97 31.9,34.69 33.27,34.69 33.58,34.37 55.7,34.37 56.17,34.84 101.44,34.84 102.21,35.61 109.37,35.61 110.83,37.07 120.63,37.07 121.6,38.03 138,38.03 140.12,35.91 146.35,35.91 147.45,34.81 187.93,34.81 188.39,35.27 189.33,35.27 191.83,37.76 192.44,37.76 194.19,39.52 195.16,39.52 197.26,41.63 197.65,41.63 201.05,45.03 201.05,46.23 206.8,51.99 207.67,51.99 208.43,52.75 214.01,52.75 214.29,52.47 215.03,52.47 215.44,52.88 215.58,52.88 215.8,53.09 216.19,53.09 216.39,53.3 v2(216.39,53.56)
  BOTTOM w0.089: U2000.C32 218.37,54.32 218.12,54.06 217.68,54.06 217.53,53.91 217.03,53.91 216.99,53.86
  BOTTOM w0.133: v2(216.39,53.56) 216.69,53.86 216.99,53.86 ; C5150.1 28.25,30.21 28.11,30.21 v2(27.86,30.46)
PCIE_SATA_TXN1_C: length 1.7
  BOTTOM w0.133: CON5102.35 30.14,30.45 30,30.31 29.77,30.31 C5150.2
PCIE_SATA_TXN2: length 203.6
  IN4 w0.114: v2(27.95,33.48) 29.38,33.48 29.54,33.64 33,33.64 33.18,33.81 55.73,33.81 56.29,34.37 108.92,34.37 111.13,36.58 120.91,36.58 121.51,37.18 137.87,37.18 139.58,35.47 145.95,35.47 147.03,34.39 188.11,34.39 188.57,34.85 190.93,34.85 194.31,38.23 194.72,38.23 195.37,38.88 195.41,38.93 195.41,39.19 197.43,41.21 197.82,41.21 201.47,44.85 201.47,46 207.01,51.54 208.11,51.54 208.6,52.04 212.13,52.04 212.63,52.53 213.81,52.53 v2(214.59,51.76)
  BOTTOM w0.089: U2000.C33 217.93,53.42 217.24,53.42 216.79,52.98 215.45,52.98 215.43,52.96
  BOTTOM w0.133: v2(214.59,51.76) 214.59,52.12 215.43,52.96 ; C5155.1 28.42,33.3 28.12,33.3 v2(27.95,33.48)
PCIE_SATA_TXN2_C: length 1.7
  BOTTOM w0.133: C5155.2 29.74,33.27 30.04,33.27 30.22,33.45 CON5102.23
PCIE_SATA_TXN3: length 209.2
  IN4 w0.114: v2(215.2,51.99) 215.2,51.79 214.76,51.35 212.15,51.35 211.98,51.18 208.83,51.18 208.39,50.73 208.01,50.73 202.83,45.56 202.83,44.96 198.21,40.34 197.64,40.34 196.18,38.87 196.18,38.61 196.13,38.57 195.04,37.47 194.63,37.47 191.25,34.09 188.98,34.09 188.52,33.63 146.62,33.63 145.78,34.47 139.28,34.47 137.33,36.42 122.24,36.42 121.62,35.8 111.54,35.8 108.62,32.87 30.56,32.87 29.13,31.44 27.76,31.44 27.31,31.88 27.31,33.61 27.68,33.98 28.6,33.98 28.96,34.35 28.96,34.98 28.66,35.29 27.97,35.29 v2(27.77,35.48)
  BOTTOM w0.133: C5158.1 28.09,35.48 v2(27.77,35.48) ; U2000.B35 217.17,52.46 216.24,52.46 215.77,51.99 v2(215.2,51.99)
PCIE_SATA_TXN3_C: length 2.5
  BOTTOM w0.133: CON5102.11 30.3,36.45 29.78,35.92 29.78,35.55 29.71,35.49 29.53,35.49 C5158.2
PCIE_SATA_TXP0: length 218.6
  IN4 w0.114: v6(215.75,54.26) 215.5,54.52 215.3,54.52 214.14,53.36 212.77,53.36 212.6,53.52 207.83,53.52 207.21,52.9 206.62,52.9 200.29,46.57 200.29,45.34 197.33,42.39 196.95,42.39 194.84,40.29 193.88,40.29 192.25,38.65 191.64,38.65 189.02,36.03 188.08,36.03 187.62,35.57 148.06,35.57 146.82,36.81 140.8,36.81 138.61,39 121.45,39 120.37,37.92 110.31,37.92 109.23,36.84 101.81,36.84 100.63,35.66 55.82,35.66 55.39,35.22 43.25,35.22 42.28,36.19 38.83,36.19 38.6,36.42 33.7,36.42 32.57,37.55 31.4,37.55 30.71,36.86 26.5,36.86 25.36,35.72 25.36,30.94 25.06,30.65 25.06,29.61 26.36,28.32 27.71,28.32 28.27,27.75 28.27,27.09 v2(27.89,26.72)
  BOTTOM w0.089: U2000.B31 217.59,54.98 216.7,54.98 215.98,54.26 v6(215.75,54.26)
  BOTTOM w0.133: C5132.1 28.29,26.84 28.02,26.84 v2(27.89,26.72)
