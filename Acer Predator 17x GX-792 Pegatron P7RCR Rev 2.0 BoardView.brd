# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND: length 3370
  TOP w0.102: U5800.4 303.25,131.34 v2(303.27,131.32) ; U5800.9 v2(302.25,136.05) ; U5800.8 302.75,135.93 v2(302.88,136.05)
  TOP w0.127: 295.37,46.31 295.78,46.31 U1101.H1 U1101.H2 296.29,45.31 296.06,45.09 v5(296.06,44.97) 295.37,44.97 ; 295.37,46.31 U1101.K1 U1101.K2 295.37,44.97 ; 295.37,46.31 v5(295.36,46.31) ; v3(150.85,88.62) 150.79,88.57 150.79,88.06 C7222.2 ; D1207.2 314.05,36.23 v2(314.28,36.46) ; v2(314.64,34.09) 314.51,34.22 D1208.2 ; U1101.P2 U1101.P1 v5(293.53,46.31) ; D1201.2 v2(313.49,31.87) ; 295.37,44.97 295.37,44.83 295.41,44.79 295.41,44.15 ; v5(294.45,46.31) U1101.M1 U1101.M2 ; v5(292.61,46.3) 292.61,46.3 U1101.T1 U1101.T2 ; D1202.2 v2(313.47,30.24)
  TOP w0.152: v5(290.31,35.19) U1101.AA23 U1101.AA22 ; v5(293.13,35.16) 293.13,35.19 293.07,35.25 U1101.R23 U1101.R22 ; U1101.J22 U1101.J23 295.83,35.22 v5(295.86,35.19) ; U1101.U22 U1101.U23 292.15,35.25 292.2,35.2 v5(292.2,35.19) ; v5(291.24,35.19) 291.23,35.2 U1101.W23 U1101.W22 ; v5(296.77,35.19) 296.77,35.2 296.75,35.22 U1101.G23 U1101.G22 ; U1101.B20 U1101.A20 300.12,37.07 v5(300.16,37.03) ; v5(294.04,35.19) 294.04,35.2 293.99,35.25 U1101.N23 ; U1101.AB14 U1101.AC14 ; v5(297.68,35.19) 297.67,35.2 U1101.E23 U1101.E22 ; U1101.AB12 U1101.AC12 ; U1101.AB8 U1101.AC8 ; U1101.AB18 U1101.AC18 ; U1101.AB10 U1101.AC10 ; U1101.AB22 U1101.AC22 ; U1101.L22 U1101.L23 ; U1101.AB16 U1101.AC16
  TOP w0.178: v5(288.8,38.64) 288.88,38.64 289.15,38.91 U1101.AC16 ; U3002.27 150.47,36.51 v2(149.95,37.03) ; v2(161.3,37.03) 161.3,36.3 160.86,35.87 U3002.1 ; U3002.49 145.98,27.11 145.7,27.39 v2(145.7,27.52) ; U1101.B16 U1101.A16 v5(300.07,38.91) ; U1101.AC18 288.83,37.99 v5(288.82,37.98) ; v5(288.8,40.72) 288.82,40.72 288.84,40.75 U1101.AC12 ; v5(300.22,37.98) 300.22,37.99 U1101.A18 U1101.B18 ; U1101.AC22 288.86,36.15 v5(288.83,36.11) 288.47,35.76 v2(288.47,35.26) ; U1101.AC8 288.93,42.59 288.86,42.66 v5(288.82,42.66) ; v5(288.82,37.05) 288.84,37.07 U1101.AC20 U1101.AB20 ; v5(288.82,43.6) 288.83,43.6 288.92,43.51 U1101.AC6 U1101.AB6 ; v5(288.78,39.69) 288.82,39.66 289.21,39.66 U1101.AC14 ; U1101.AC10 288.86,41.67 288.84,41.66 v5(288.83,41.66) ; v5(300.07,36) 299.92,36.15 U1101.A22 U1101.B22 ; U1101.A12 300.06,40.75
  TOP w0.191: U3002.91 158.86,18.15 v2(158.98,18.03)
  TOP w0.2: v3(150.88,90.66) 150.88,90.18 C7202.1
  TOP w0.203: U8601.14 120.75,59.63 120.17,59.06 v2(120.02,59.06) ; v2(192.27,36.79) 192.5,37.02 U9100.11 ; v2(89.59,8.03) 89.73,7.89 U9500.14 ; U8300.1 26.09,50.31 v2(25.69,50.71) ; v2(238.99,18.65) U9101.11 U9101.15 ; v2(30.15,50.12) 29.94,49.91 U8300.14 ; v2(25.69,49.51) U8300.3
  TOP w0.229: v2(276.82,99.45) 277.13,99.76 U3300.27 ; U8800.22 278.02,30.81 278.11,30.72 v2(278.34,30.72)
  TOP w0.25: v5(176.8,135.5) 176.62,135.68 v5(176.07,135.68)
  TOP w0.254: U8200.16 225,12.45 v2(225.06,12.4) ; v2(239.68,56.48) 239.85,56.31 241.22,56.31 241.48,56.05 R2487.1 ; 111.89,189.33 111.75,189.19 CON4500.22 111.75,187.43 ; 111.89,189.33 112.25,188.97 CON4500.21 112.25,187.44 ; 111.89,189.33 v2(111.89,189.37) ; 110.75,187.45 CON4500.24 110.75,189.22 110.64,189.33 v2(110.64,189.37) 110.59,189.33 110.45,189.33 110.25,189.13 CON4500.25 110.25,187.46 ; v2(252.48,87.41) 252.76,87.41 253.22,86.95 SR8912.1 ; v2(227,67.74) 226.83,67.92 SR2702.2 ; U1401.18 268.16,46.64 v2(268.28,46.77) ; R2260.2 223.88,47.75 v2(223.58,47.45) ; v2(297.06,55.28) 296.65,55.7 U1201.L1 ; SR2701.2 226.59,65.73 226.77,65.92 v2(227,65.92) ; C7603.2 158.94,133.99 159.29,133.64 160.04,133.64 v5(160.29,133.89) ; 122.25,187.37 CON4500.1 122.25,189.29 v2(122.2,189.34) ; v5(160.3,136.18) 160.06,136.43 159.3,136.43 158.91,136.04 R7612.1 ; 108.25,187.45 CON4500.29 v2(108.25,189.34) ; v2(31.74,50.82) 32.29,50.28 C8318.2 ; CON1600.192 92.37,65.93 ; 120.75,187.39 CON4500.4 v2(120.75,189.39) ; v2(288.46,130.53) 288.11,130.53 v2(286.43,128.85) 286.43,124.38 286.4,124.35 v2(286.4,123.55) 286.4,121.81 v2(286.43,121.77) 286.67,121.54 286.67,119.46 286.23,119.02 v2(285.75,119.02) 285.75,119.45 v2(284.75,120.45) 284.75,124.59 v2(284.57,124.77) ; U1201.A1 291.17,55.38 290.94,55.38 ; R6114.2 v2(218.93,42.32) ; v2(287.72,132.78) 287.72,132.54 v2(286.23,131.05) 285.02,129.84 v2(284.77,129.84) ; v2(117.75,189.34) CON4500.10 117.75,187.39 ; U8200.4 224.51,16.63 v2(224.36,16.77) ; CON4500.13 v2(116.25,189.34) ; v5(168.17,132.43) 167.93,132.67 C7623.2 ; 105.25,187.4 CON4500.35 105.25,188.96 v2(105.57,189.28) 105.75,189.1 CON4500.34 105.75,187.43 ; v2(92.03,61.37) 91.65,61.37 91.34,61.68 91.34,63.42 91.37,63.46 CON1600.188 ; 119.25,187.37 CON4500.7 v2(119.25,189.41) ; C2305.2 v2(238.64,44.35) ; 263.77,93.06 263.28,92.57 263.28,90.47 262.27,89.47 259.81,89.47 259.08,90.2 v2(258.17,90.2) 257.55,90.2 256.43,89.08 255.26,89.08 255.02,88.84 255.02,87.74 255.2,87.56 256.1,87.56 256.91,86.75 259.01,86.75 260.21,87.94 263.16,87.94 265.16,89.95 265.16,91.29 v2(264.98,91.47) 265.12,91.62 265.12,92.78 264.84,93.06 263.77,93.06
  TOP w0.279: v2(38.26,15.25) 38.27,15.25 38.49,15.25 40.06,13.67 U1501.13 U1501.21 U1501.3 ; v2(264.29,49.56) 264.02,49.84 U1401.31 ; U1401.24 268.17,49.64 v2(268.28,49.53) ; v2(306.28,77.78) U5502.3 U5502.8 308.89,77.78 v2(309.2,78.09) ; v2(310.83,53.32) U5500.8 U5500.3 v2(308.64,53.32) ; U1202.14 v2(296.27,73.19) ; U1401.3 v2(262.52,42.8) ; v2(305.09,63.63) 304.99,63.53 U5200.14 303,63.53 U5200.17
  TOP w0.28: v5(144.81,127.38) 144.86,127.33 C7662.2 145.18,126.38 145.62,126.82 v5(145.62,128.53)
  TOP w0.292: v2(175.62,118.14) 175.75,118.27 R7503.1
  TOP w0.3: v5(194.76,102.63) 193.72,102.63 C7837.2 ; C7728.2 186.95,136.24 v5(186.79,136.08)
  TOP w0.305: CON1600.82 62.88,64.8 62.88,66.23 ; v2(106.36,55.33) 106.28,55.25 C1709.2 ; Q8807.4 265.52,30.46 265.17,30.81 v2(264.95,30.81) ; 99.87,66.04 CON1600.222 99.87,63.53 99.52,63.18 99.52,62.08 99.73,61.88 v2(100.08,61.88) ; CON1600.23 48.12,55.29 ; CON1600.56 56.37,66.02 56.38,66.02 ; CON1600.35 51.12,55.64 51.43,55.33 v2(51.52,55.33) ; C7736.2 180.23,125.84 180.23,128.54 180.27,128.58 v5(180.27,128.58) ; R1517.1 47.4,11.31 v2(47.91,10.8) 47.53,10.42 R1516.1 ; CON1600.226 100.87,65.77 v2(101.23,66.12) ; v2(104.13,66.17) 103.87,65.92 CON1600.238 103.87,63.64 v2(104.06,63.46) ; 98.87,66.07 CON1600.218 98.87,62.32 v2(98.82,62.26) ; v2(58.59,54.1) 58.37,53.88 CON1700.64 ; CON1600.19 47.12,55.28 ; CON1600.73 60.62,55.57 60.38,55.33 ; v2(43.6,55.33) 43.62,55.36 CON1600.5 ; v2(234.09,38.92) 234.09,38.97 234.14,39.02 C2311.2 ; v2(107.72,66.14) 107.37,65.8 CON1600.252 ; CON1700.18 46.87,53.76 46.57,54.06 ; CON1700.90 64.87,54.04 ; CON1700.106 68.87,53.74 68.54,54.08 ; CON1700.48 54.37,54.02 ; C5349.2 301.3,96.17 v2(301.45,96.02) ; CON1700.94 65.87,53.91 v2(65.71,54.07) ; CON1600.31 50.12,55.35 ; 46.87,66.05 46.87,66.04 CON1600.18 ; CON1600.60 57.38,64.8 57.38,66.54 ; CON1700.102 67.87,54.03 ; v2(53.07,66.25) 53.37,65.94 CON1600.44 ; U8006.28 53.49,164.67 C80082.1 ; v2(91.98,66.89) 92.74,66.89 93.37,66.26 CON1600.196 ; 67.88,66.23 67.88,66.5 ; 67.21,54.08 66.87,53.74 CON1700.98 ; 105.37,66.19 CON1600.244 105.37,63.39 v2(105.31,63.33) ; CON1201.B1 319.45,35.8 CON1201.A12 317.84,35.8 317.71,35.93 v2(317.3,35.93) ; U8004.28 67.51,169.32 C80025.1 ; v2(317.3,30.17) 317.43,30.3 CON1201.A1 319.45,30.3 CON1201.B12 ; CON1600.40 52.37,66.14 ; CON1600.230 101.87,66.16 ; 67.88,66.2 67.88,64.8 CON1600.102 ; U2401.3 228.82,30.25 228.51,29.93 v2(228.51,29.37) ; 106.53,66.13 106.37,65.98 CON1600.248 ; CON1600.57 56.62,55.41 ; CON1600.22 47.87,66.06 ; CON1600.99 67.12,55.44 ; 88.37,66.23 88.37,66.18 88.37,66.18 CON1600.176 ; v2(57.13,54.05) 57.37,53.81 CON1700.60 ; 301.48,102.72 301.35,102.72 v2(300.84,103.23) ; CON1700.82 62.87,54.21 ; v2(50.15,66.38) 49.87,66.1 CON1600.30 ; CON1600.72 60.37,66.34 ; CON1600.85 63.62,55.31 v2(63.76,55.18) ; CON1600.78 61.87,66.05 ; 96.87,66.19 CON1600.210 96.87,63.04 v2(96.93,62.98) ; CON1600.36 51.37,66.22 ; CON1600.107 69.12,55.51 69.3,55.33 v2(69.49,55.33) ; CON1600.26 48.87,66.25 ; CON1600.180 89.37,65.86 v2(89.72,66.2) ; v2(276.46,47.73) C1109.2 ; CON1600.172 87.37,65.94 ; 88.38,66.26 88.38,66.97 ; 62.62,55.33 CON1600.81 ; CON1600.206 95.87,66.08 ; CON1600.168 86.37,65.72 86.88,66.22 ; 63.88,66.4 63.87,66.4 CON1600.86 ; 53.12,55.39 CON1600.43 ; CON1600.2 42.87,66.23 ; CON1700.40 52.37,53.96 ; CON1600.77 61.62,55.33 ; CON1600.52 55.37,66.02 ; CON1700.44 53.37,54.09 ; v2(58.39,55.34) 58.62,55.57 CON1600.65 ; v2(97.83,66.68) 97.87,66.64 CON1600.214 ; 68.56,66.04 68.88,65.72 68.88,64.8 CON1600.106 ; CON1600.27 v2(49.12,55.35) ; v2(93.94,66.3) 93.99,66.35 94.42,66.35 94.87,65.9 CON1600.202 ; v2(55.28,55.32) 55.12,55.47 CON1600.51 ; CON1600.39 52.12,55.41 ; CON1600.69 59.62,55.25 ; CON1600.234 102.87,66.15 ; CON1600.98 66.87,66.84 ; CON1600.94 65.87,66.16 v2(65.77,66.26) 65.75,66.28 ; 54.37,66.24 CON1600.48 ; CON1600.9 44.62,55.37 ; CON1600.188 91.37,66.09 ; R4610.2 304.14,121.97 303.74,121.57 v2(303.74,121.57) ; CON1700.78 61.87,53.84 v2(61.63,54.08) ; CON1600.61 57.62,55.32 ; 64.87,66.2 CON1600.90 ; CON1600.15 46.12,55.31 ; CON1600.6 43.87,66.12 ; CON1600.103 68.12,55.33 ; CON1600.89 64.62,55.38 ; CON1700.72 60.37,54.04 ; CON1600.184 90.37,66.02
  TOP w0.33: v2(267.47,32.77) 267.26,32.98 267,32.98 266.82,32.8 Q8807.1
  TOP w0.356: U7407.4 142.49,71.06 142.79,70.76 v2(142.79,70.38) ; v2(280.8,84.59) 280.8,84.79 C1321.2 ; v2(237.69,32.77) U6200.4 ; U3102.10 174.12,15.56 v2(174.15,15.54) ; v2(147.51,66.68) U7406.4 ; U3102.19 v2(174.12,14.18) ; v2(233.14,32.8) U6200.11 ; U6200.25 237.69,26.92 v2(237.5,26.73) 236.81,27.41 C6203.2 ; v2(291.2,118.02) 291.2,118 291.12,117.91 R7214.2 ; v2(180.8,39.45) 180.46,39.11 U9201.3 ; v2(284.26,116.99) 284.45,116.81 Q7206.1 ; Q9200.1 174.46,39.9 174.9,39.46 v2(174.9,39.45) 174.9,39.45 175.76,38.6 Q9200.4 ; v2(258.55,67.55) 258.55,67.32 258.82,67.05 Q8106.4 ; v2(21.47,20.45) 21.42,20.45 21.05,20.08 Q3601.4 ; v2(232.44,26.73) 232.98,27.26 C6204.2 232.98,27.76 233.14,27.92 U6200.18 ; U7406.1 148.81,67.69 149.13,67.37 v2(149.54,67.37) ; U7407.1 141.19,68.52 140.85,68.18 v2(140.37,68.18) ; U3102.24 177.37,13.72 v2(176.92,14.18) ; R4801.1 v2(310.11,98.57) ; v2(288.35,120.44) R7213.2 ; U5701.4 v2(206.51,135.04) ; v2(260.76,65.69) 260.82,65.75 Q8106.1 ; U5703.4 127.4,147.34 v2(127.74,147.68) ; U5000.5 v2(296.26,131.21) ; v2(169.07,39.45) 169.07,39.08 168.71,38.72 U9200.3 ; Q7206.4 v2(285.75,119.02) ; U5701.1 v2(206.32,136.34) ; U5703.1 v2(129.95,146.04)
  TOP w0.381: C8303.2 v2(25.57,47.49) ; R30108.2 v2(135.87,15.11) ; v2(299.19,90.41) 299.62,89.97 299.62,89.97 R1331.2 ; v3(76.01,120.47) 75.84,120.47 75.55,120.76 R0723.2 74.96,120.43 74.96,120.35 74.58,119.97 R0709.2 ; v2(238.75,26.7) 238.8,26.65 R9110.2 ; R1009.2 75.72,116.24 v3(76.01,116.53) ; v2(281.92,52.22) 282.39,52.69 R1128.2 ; C7650.2 152.68,138.41 v5(152.52,138.25) ; v2(219.64,28.43) 219.87,28.2 R8403.1 ; v2(304.91,43.63) 304.57,43.29 R1126.2 ; v2(298.46,34.21) 299.29,33.38 v2(299.29,32.66) 299.29,31.28 298.98,30.97 v2(298.98,30.06) 298.98,28.86 v2(299.37,28.47) 299.9,27.93 v2(301.18,27.93) v2(303.24,27.93) 303.71,27.93 304.48,28.7 v2(304.48,29.54) v2(304.48,31.34) 304.48,32.03 303.61,32.89 v2(303.07,32.89) 302.33,33.64 301.74,33.64 v2(301.48,33.9) 301.13,34.25 300.51,34.25 299.88,34.89 v2(299.88,34.92) ; C1003.1 111.33,123.85 v3(111.43,123.85) 111.06,123.48 C1006.1 ; C8100.2 264.16,60.49 v2(264.54,60.1) ; C7638.2 161.92,141.37 v5(161.8,141.25) ; v3(73.55,115.35) 73.72,115.35 74.24,114.83 R1010.1 74.24,114.17 73.68,113.61 v3(73.68,112.83) ; v2(256.74,48.84) 256.79,48.79 R1404.2 ; v2(210.55,102.85) 210.5,102.8 R7513.1 ; R1239.1 277.32,62.62 277.04,62.34 v2(277.04,62.29) 277.04,61.93 277.22,61.75 R1222.2 ; R0702.2 77.28,121.41 77.31,121.38 v3(77.31,121.25) ; v2(142.04,15.12) 141.9,14.98 R30106.2 ; v5(209.02,105.24) 209.51,105.73 C7801.2 ; R8303.2 32.44,47.84 32.16,48.11 v2(31.4,48.11) ; R30102.2 150.81,14.49 v2(150.81,14.73) 150.16,14.73 C3020.2 ; v2(195.46,109.99) 195.34,110.12 C7765.2 ; R3026.2 162.2,36.13 v2(161.3,37.03) ; v2(187.18,141.61) 186.53,142.26 C7711.2 ; C1318.2 295.51,90.23 v2(295.51,90.41) ; R30105.2 144.1,14.79 v2(143.67,15.22) ; v2(158.98,18.03) 158.98,17.63 159.54,17.08 C3023.2 160.22,16.47 v2(160.22,15.75) ; R1310.2 293.43,91.09 293.73,90.79 v2(293.73,90.66) ; v5(148.86,127.87) 148.54,127.55 C7666.2 ; R0725.2 71.79,122.03 72.12,121.7 v3(73.12,121.7) ; C3102.2 209.84,25.35 209.18,26.02 v2(209.02,26.02) ; C8912.2 R8911.1 249.05,87.38 249.46,87.79 v2(249.46,87.92) ; v3(73.67,117.71) 73.67,118.06 R0703.2 73.43,118.29 R0724.2 ; v3(79.47,120.86) 79.21,120.61 R1004.2 R1005.1
  TOP w0.404: C7739.2 187.79,128.41 v5(187.55,128.65) v5(187.55,129.25) ; v5(176.29,127.29) 176.16,127.29 175.38,126.51 C7712.2 ; v5(162.97,140.32) 162.97,140.88 v5(162.6,141.25)
  TOP w0.406: U7414.3 144.65,62.07 v2(144.86,61.86) ; v2(165.14,18.03) 165.14,18.07 165.2,18.12 R30109.2 ; v2(157.36,14.73) 157.19,14.73 156.93,14.99 R3029.2 ; v5(194.96,104.63) 194.94,104.65 v5(194.94,105.34) ; R9113.2 133.48,71.74 134.22,71 v2(135.24,71) ; v2(157.21,39.45) 157.21,39.07 C3015.1 C3009.2 ; v2(166.18,27.57) 166.18,26.98 R3066.1 ; v2(183.29,32.51) 183.29,31.27 183.71,30.86 Q9102.1 ; v2(244.84,56.84) 244.88,56.8 R2349.1 ; C3025.2 167.45,33.53 168.15,32.82 v2(168.15,32.51) ; v2(143.44,64.93) 143.44,65.13 144.11,65.8 U7415.3 ; v2(147.26,70.31) 147.26,70.3 147.25,70.29 R7451.2 ; v5(176.29,127.29) 176.98,127.29 v5(177,127.31) ; v2(155.09,14.73) 155.35,14.99 R3030.2 ; v2(240.39,27.29) 240.77,27.29 240.92,27.14 242.41,27.14 242.69,27.43 Q9104.1 ; R7210.1 v2(143.62,72.36) ; C3002.2 168.23,30.49 v2(168.26,30.46) ; R2482.1 250.5,51.12 v2(250.2,51.43) ; R2424.1 246.59,55.4 v2(247.35,56.16) R2426.2 R2427.2 ; 130.33,73.11 131.08,72.36 Q9106.1 ; v2(62.03,183.7) 62.57,183.17 R8089.2 ; v2(144.41,60.32) 144.67,60.32 145.07,60.71 R7493.2 ; v2(178.29,24.15) 178.29,23.4 Q9103.1 ; v5(194.37,122) v5(195.04,122) ; 130.36,74.68 C9106.2 ; R9108.2 182.1,23.02 182.58,22.54 v2(182.58,22.44) 182.58,22.28 182,21.7 182,21.7 R3142.2
  TOP w0.432: R0510.2 67.29,104.05 v2(66.22,104.05) ; v2(191.66,36.78) 191.47,36.59 C9109.2 ; C80082.1 v2(52.69,164.45) ; R1406.2 263.32,41.5 263.8,41.01 264.01,41.01 C1413.2 264.27,40.74 v2(264.27,40.09) ; R4606.2 v2(298.56,119.51) ; C2308.2 v2(235.91,44.35) ; C7629.2 168.13,135.65 168.15,135.67 168.16,135.67 168.17,135.68 v5(168.17,135.68) ; R1208.2 C1201.1 v2(297.52,76.18) ; C7747.2 200.23,114.19 200.38,114.04 v5(200.38,114.04) ; C2622.2 239.99,54.17 239.91,54.25 v2(239.69,54.25) ; C8909.2 253.14,82.4 v2(253.5,82.4) ; C1712.2 60.69,100.95 v2(60.43,101.2) ; C2403.2 226.98,26.5 227.23,26.25 v2(227.72,26.25) ; C8701.1 132.26,164.27 132.54,164.55 v2(132.54,164.83) ; v2(228.78,21.57) C3705.2 ; C8118.2 262.82,65.13 v4(262.59,64.9) ; C7830.2 196.93,105.89 196.71,105.67 v5(196.51,105.47) ; v2(244.68,68.51) 245.11,68.94 R2478.2 C2402.2 ; v2(201.53,73.24) R7117.2 ; R1246.2 296.58,70.54 v2(296.58,70.09) ; SR1203.1 v2(288.02,52.69) ; v2(250.53,43.92) 250.93,44.33 R2602.2 ; v2(89.8,189.34) R5601.2 ; C9111.2 244.33,19.34 v2(244.71,19.34) ; v5(171.76,114.51) 171.76,115.03 R7500.2 ; C3003.2 144.13,27.31 v2(144.33,27.52) ; v5(148.21,138.94) 148.12,139.03 C7644.2 ; v5(183.52,131.83) 183.52,131.83 183.37,131.99 C7721.2 ; C1319.2 293.67,78.29 v2(293.6,78.22) ; v2(216.26,42.32) 216.19,42.4 R2148.2 ; v2(297.97,95.51) 298.23,95.77 C5302.2 ; v5(167.51,129.17) 167.51,129.21 167.38,129.34 C7631.2 ; v2(227.74,47.48) C2604.2 ; R7913.1 173.45,54.48 v2(172.98,54.95) ; R7506.2 171.2,113.39 v5(171.73,113.39) ; v2(175.34,37.03) 175.76,37.45 C9200.2 ; R2348.1 241.89,42.7 v2(241.89,42.3) ; C7634.2 169.36,141.45 v5(169.43,141.38) ; v2(308.97,84.44) 308.67,84.13 C4810.2 ; C7642.2 146.69,136.68 v5(146.29,137.08) ; R1167.2 R1166.2 288.19,49.08 v2(288.08,49.19) ; v5(207.4,121.4) 207.44,121.45 C7857.2 ; C1205.2 295.45,52.38 C1203.2 ; v2(302.52,119.06) 303.05,119.59 R4608.1 ; C3629.2 8.4,24.58 v2(8.4,24.89) ; v2(133.66,160.38) 133.32,160.73 R8704.1 ; v5(199.73,117.94) 199.75,117.92 199.91,117.76 C7746.2 ; v5(195.83,114.69) 194.15,114.69 C7761.2 ; R2610.2 252.47,49.18 v2(252.52,49.13) ; R7113.2 171.61,134.53 v5(171.35,134.27) ; R8711.1 125.71,165.64 ; U8000.49 57.21,184.38 C8033.1 ; v5(164.92,136.33) 165.03,136.43 C7627.2 ; v2(291.67,76.16) 291.9,75.93 R1206.2 ; C7719.2 180.32,129.93 180.29,129.9 180.29,129.9 v5(180.27,129.88) ; v2(115.5,50.15) 116.04,50.15 C1708.2 ; v2(302.07,52.94) 301.69,53.32 R1234.2 R1233.2 ; R3144.2 R3146.2 R3148.2 ; v2(281.93,46.92) 282.11,46.74 R1129.2 ; C80025.1 67.67,168.78 v2(67.72,168.73) ; v5(198.91,105.47) 198.79,105.6 C7826.2 ; v3(111.44,115.97) 111.33,116.09 C1022.2 C1021.2 ; C1843.2 53.86,54.68 ; C1835.2 92.44,54.7 ; C9713.2 v2(206.71,188.2) ; v2(239.24,47.95) 239.2,47.95 C2603.2 ; v5(205.37,114.89) 205.75,115.27 C7745.2 ; R7494.2 R7454.2 142.96,68.12 v2(143.19,68.35) ; C7625.2 171.67,137.78 v5(171.62,137.73) ; C4605.2 v2(293.58,112) ; R2475.2 242.55,70.38 v2(242.61,70.44) ; v3(144.79,90.4) 144.79,91.3 R7204.1 ; R1507.1 37.78,12.35 v2(37.8,12.38) R1511.1 ; C7704.2 202.9,123.25 203.49,123.83 v2(203.61,123.83) 203.82,123.63 R7712.1 204.37,123.1 C7763.2 204.99,121.49 v5(204.87,121.37) ; C7632.2 165.03,137.55 v5(164.94,137.64) ; v2(140.44,30.69) 140.44,31.17 140.72,31.45 R3006.1 ; v5(156.32,53.52) 156.28,53.47 R7119.2 ; v5(206.64,98.77) 206.75,98.88 C7820.2 ; v3(150.4,86.18) 150.3,86.08 C7234.2 ; C2621.2 230.1,76.08 v2(229.37,75.35) ; C5802.2 v2(305.01,137.75) ; C1707.1 115.85,49.07 115.65,48.88 v2(115.47,48.88) ; v5(201.52,93.92) 201.52,93.42 201.3,93.2 R7813.1 ; v2(224.47,11.82) 224.47,11.79 224.96,11.3 SR8201.1 ; C3100.2 C3101.2 177.78,24.49 177.65,24.37 v2(177.65,24.15) ; v2(197.21,34.48) 197.31,34.59 C9100.2 ; v5(198.83,101.36) 198.83,101.14 198.63,100.95 C7818.2 ; R1311.2 293.53,88.45 v2(293.6,88.37) ; C7741.2 195.1,122.06 v5(195.04,122) ; R2490.2 36.29,25.27 v2(36.76,25.74) ; C8321.2 25.56,44.94 v2(25.91,44.94) ; C7758.2 196.86,122.71 196.86,122.24 v5(196.64,122.02) ; v2(248.01,67.35) 248.22,67.14 R2803.1 ; C8602.2 117.91,61.07 117.75,61.23 v2(117.75,61.61) ; v2(11.18,25.15) 11.72,24.62 C3642.2 C3630.2 ; R4605.1 292.26,105.72 v2(292.08,105.9) ; v2(90.07,10.27) R9506.1 ; 146.23,129.9 145.69,129.9 145.64,129.85 v5(145.62,129.83) ; v2(60,100.77) 59.49,101.28 R1714.2 ; C7755.2 203.41,110.13 v2(203.57,110.29) ; C8611.2 126.27,61.65 v2(125.91,62.01) ; v5(167.52,127.88) 167.52,126.11 167.83,125.81 C7635.2 ; R7114.2 175.34,135.59 C7726.2 176.03,135.64 v5(176.07,135.68) ; R8039.1 61.45,180.7 v2(61.45,181) ; v2(231.63,21.06) 231.55,20.99 C3706.2 ; v2(44.05,15.76) 44.13,15.76 44.76,15.12 C1516.1 ; SR1202.1 302.98,60.25 303.46,59.77 v2(303.46,59.57) ; R7713.1 189.4,133.16 v5(189.4,132.94) ; C8827.2 270.44,38.59 270.82,38.97 v2(271.15,38.97) ; v2(246.84,53.68) 246.84,53.13 R2481.2 ; C2617.2 240.77,62.99 240.26,63.5 v2(240.1,63.5) 239.91,63.3 C2616.2 ; v2(125.89,151.82) 125.87,151.84 R8742.2 ; v2(14.71,39.2) 13.28,39.2 D6703.2 ; C4612.2 293.72,113.66 v2(293.6,113.77) ; R8714.2 123.04,165.62 ; v2(238.11,18.68) 238.11,18.52 237.67,18.09 C9117.2 ; C3001.2 148.77,38.87 148.77,39.43 v2(148.77,39.43) ; C7752.2 197.42,109.87 v2(197.53,109.99) ; v2(205.97,110.29) 206,110.26 C7753.2 ; R1416.2 264.78,52.66 264.75,52.63 v2(264.75,52.61) ; C3628.2 v2(5.82,21.06) ; v2(91.5,185.6) 91.5,185.3 C5600.2 ; C7724.2 176.16,128.86 v5(176.16,128.86) ; R8747.1 133.13,155.94 v2(133.53,155.53) ; R4624.2 v2(293.58,117.18) ; R8102.2 v2(256.34,63.86) ; C7720.2 183.29,129.06 183.46,129.24 183.51,129.24 v5(183.52,129.23) ; C7750.2 194.06,121.47 194.37,121.78 v5(194.37,122) ; v2(96.04,182.79) 95.87,182.79 R9717.1 ; C6202.2 234.51,36.94 v2(234.83,37.26) ; C3004.2 164.22,27.87 163.94,27.59 v2(163.93,27.59) ; R1207.2 297.52,73.39 v2(297.24,73.11) ; v2(239.67,61.26) 239.62,61.31 R2262.2 ; v2(49.09,54.74) 49.13,54.7 C1833.2 ; R3607.2 14.61,22.64 14.22,22.64 v2(14.2,22.65) 14.2,22.92 14.64,23.35 C3618.2 ; v2(191.85,39.45) 190.99,38.59 190.99,38.21 C9108.2 ; v2(43.6,54.7) C1837.2 ; R7201.2 260.92,52.67 v2(260.47,52.22) ; R5206.2 v2(298.05,65.18) ; C8703.2 v2(130.16,165.84) ; R8206.2 222.51,11.67 v2(222.66,11.82) ; v2(242.22,67.21) 242.35,67.09 C2200.2 R2459.2 ; R1125.2 295.1,49 v2(295.64,49) ; R4602.2 R4627.2 296.68,119.44 v2(296.78,119.54) ; C7716.2 180.44,135.92 v5(180.4,135.89) ; C2624.2 239.44,59.11 v2(239.47,59.14) 239.88,59.14 C2625.2 ; v5(206.23,113.39) 206.23,113.39 206.14,113.29 C7743.2 ; C1322.2 294.27,87.71 294.49,87.94 v2(294.49,88.37) ; R1323.2 295.33,78.29 295,77.96 v2(295,77.71) v2(295.64,77.71) 296.2,77.71 R1325.2 R1321.1 C1317.2 299.24,78.29 v2(300.03,79.08) ; R8000.2 C8002.2 51.57,184.56 51.29,184.84 v2(51.29,185.27) ; C4613.2 v2(293.58,115.93) ; v5(204.28,117.29) 204.4,117.17 C7744.2 ; v5(155.28,136.28) 155.28,134.17 154.74,133.64 R7613.1 ; v2(5.57,36.05) 5.57,36.48 C3604.2 ; R3114.2 210.42,36.18 211.44,37.19 v2(211.44,37.45) ; R2111.2 226.8,40.24 R2110.2 226.8,39.68 v2(226.9,39.59) ; v2(274.32,27.81) 274.27,27.81 SR8809.1 ; C7748.2 197.26,117.81 v5(197.13,117.94) ; C8006.1 47.56,182.05 v2(47.4,181.89) ; C1316.2 v2(292.33,78.29) ; C1832.2 54.66,54.7 ; v5(148.22,136.98) 148.08,137.12 C7643.2 ; v3(145.37,86.42) 145.45,86.34 R7221.1 ; v2(201.08,191.24) 201.07,191.23 C9721.2 ; v5(178.97,136.37) 178.98,136.37 179.07,136.28 C7717.2 ; v2(57.46,166.2) 57.82,165.84 C80019.1 ; C5000.1 v2(287.72,132.78) ; C3627.2 6.66,21.27 v2(6.46,21.06) ; v2(59.62,100.29) 59.85,100.06 C1714.2 ; v2(294.65,63.1) 294.72,63.02 R1229.2 ; v5(168.82,138.28) 168.92,138.19 C7633.2 ; v2(260.05,39.63) 260.05,39.81 259.57,40.29 C1414.1 260.22,40.62 C1411.2 ; C2306.2 v2(239.48,42.32) ; v2(30.21,46.97) 30.64,46.54 C8310.2 ; v5(141.48,128.54) 141.19,128.84 C7656.2 ; v5(182.86,138.99) 182.78,139.07 C7715.2 ; v2(239.19,70.28) 239.19,70.66 C2400.2 ; R4604.2 v2(299.19,104.2) ; v5(148.87,131.78) 148.87,131.78 148.71,131.93 C7646.2 ; v2(262.52,42.8) 262.52,42.46 262.03,41.97 R1401.2 ; v2(241.28,42.3) 240.85,42.73 C2307.2 ; R8762.1 127.49,165.64 ; R8106.1 256.27,61.45 256.34,61.53 C8115.2 v2(256.34,62.59) ; v2(247.07,63.77) 246.92,63.77 C2202.2 ; C3626.2 13.04,23.12 13.32,22.84 v2(13.32,22.64) ; C3103.2 207.32,25.59 207.75,26.02 v2(208.01,26.02) ; C7616.2 164.37,129.09 v5(164.28,129.18) ; SR1201.1 303.69,58.25 v2(303.99,58.55) ; C1223.2 v2(304.15,57.36) ; C1204.2 288.47,54.34 v2(287.99,54.34) ; v2(249.56,78.67) 249.15,79.08 R8903.2 ; v3(111.44,119.12) 111.09,119.12 C1020.2 ; C7026.2 v2(134.25,94.8) ; C6200.2 235.91,36.84 v2(235.49,37.26) ; v2(14.71,37.7) 14.58,37.83 C6717.2 ; C9116.2 237.45,19.06 v2(237.45,18.68) ; C3400.2 v2(291.35,154.28) ; v2(232.24,21.04) 232.34,20.94 C3707.2 ; v2(258.17,90.2) 258.17,90.68 C5006.2 ; R8763.1 126.6,165.62 ; C1715.2 v2(61.02,104.38) ; R5802.2 v2(301.1,128.73) ; C3708.2 234.85,20.81 v2(234.63,21.04) ; R7116.2 202.24,106.99 v2(202.62,107.37) ; v2(90.66,3.51) 90.84,3.33 C9503.2 ; v2(118.42,122.44) 118.34,122.51 R0752.1 ; C1839.2 67.96,54.7 ; R4609.2 282.38,114.64 v2(282.07,114.95) ; v2(257.73,58.17) 257.35,57.79 R8107.1 ; v2(149.38,39.42) 149.64,39.16 C3024.2 ; C9711.2 v2(195.4,188.84) ; C7655.2 145.66,132.47 145.63,132.44 145.63,132.44 v5(145.62,132.43) ; v2(117.66,124.06) R0753.1 ; C7718.2 182.78,137.12 v5(182.87,137.04) ; v2(300.03,53.78) R1235.2 ; C8704.2 128.38,165.69 ; v5(205.45,101.24) 205.48,101.21 C7814.2 ; C7661.2 145.15,141.58 v5(144.89,141.33) ; R4625.2 v2(300.34,119.51) ; R8712.1 124.82,165.62 ; R7212.1 144.8,88.41 v3(144.85,88.36) ; v5(180.27,132.48) 180.34,132.54 C7713.2 ; C2304.2 v2(237.8,44.35) ; C1324.2 272.01,85.68 271.66,85.33 v2(271.66,84.84) C1323.2 ; v5(202.08,102.66) 202.16,102.57 C7819.2 ; v2(122.28,151.95) C8713.2 ; v2(303.45,58.9) 303.1,58.9 302.88,59.12 C1224.2 ; v5(171.62,135.33) 171.69,135.26 C7619.2 ; R7112.2 v2(139.99,134.5) ; v2(139.15,15.49) 138.86,15.19 R30107.2 ; v2(236.96,44.35) R2347.1 ; C9103.2 C9105.2 198.96,37.17 199.24,36.89 v2(199.24,36.48) ; C6713.2 0.82,57.26 ; v2(126.57,151.82) 126.76,152.02 R8743.2 ; v2(316.69,31.8) CON1201.1 ; C3324.2 287.31,101.53 v2(287.31,101.02) ; C6707.2 16.77,87.18 v2(16.64,87.05) ; v2(302.04,54.21) R1236.2 ; R5809.1 v2(306.13,136.81) ; v2(230,73.34) 230.04,73.39 C2620.2 ; v5(197.14,114.69) 197.15,114.69 197.26,114.8 C7759.2 ; R4626.2 v2(293.58,118.02) ; C1207.2 299.07,52.41 v2(299.4,52.08) ; C8116.1 v2(258.32,54.03) ; R5210.2 295.08,64.37 v2(295.43,64.73) ; R4611.2 v2(298.3,104.2) ; R4623.2 v2(301.22,119.54) ; v5(196.23,101.36) 196.02,101.15 C7816.2 ; C8322.2 C8319.2 ; C2610.2 240.39,70.38 v2(240.42,70.4) 240.39,70.43 R2476.2 ; C2623.2 248.75,58.14 v2(248.75,58.66) 248.75,59.29 C2630.2 ; v2(299.97,31.56) C1131.2 ; R1713.2 v2(116.31,53.83) ; C9114.2 v2(244.13,18.02) ; C4400.2 v2(143.16,7.86) ; v2(303.38,31.55) C1130.2 ; C3647.1 v2(17.25,30.08) ; v2(40.29,11.36) 40.09,11.56 C1517.1 ; C80066.1 v2(99.68,160) ; R5602.2 v2(88.91,189.34) ; R0511.2 65.13,102.93 v2(65.74,103.54) ; C2602.2 231.35,49.81 v2(231.74,50.2) ; R3106.2 v2(43.75,126.58) ; R9718.2 v2(193.83,191.9) ; C2628.2 230.59,69.9 v2(230.26,70.22) ; v2(302.63,105.65) 302.21,106.06 SR5302.1 ; C5001.2 259.09,85.27 ; R8713.2 123.93,165.62 ; R4601.2 v2(299.45,119.51) ; C1836.2 59.24,54.69 ; v5(194.94,105.34) 195,105.4 C7824.2 ; v2(230.46,26.63) 230.99,27.16 C6205.2 ; R2000.2 v2(228.07,70.26) ; C1320.2 v2(275.93,84.64) ; R1203.2 v2(287.79,72.17) ; v5(206.89,117.28) 206.97,117.2 C7742.2 ; C1617.2 98.07,54.7 ; R2458.2 v2(232.72,65.99) ; R8715.2 122.15,165.67 ; R8716.2 121.27,165.67 ; R7229.2 259.8,53.83 v2(259.71,53.92) 259.71,54.2 R8103.2 ; CON1201.2 316.9,34.3 v2(316.72,34.12) ; v2(247.33,61.55) 247.91,61.55 248.11,61.75 C2203.2 248.75,62.82 Q2801.2 ; v5(164.27,131.78) 164.28,131.78 164.46,131.96 C7630.2 ; R8109.2 v2(265.89,65.64) ; C4809.2 v2(309.2,86.65) ; v5(148.87,129.18) 148.75,129.29 C7645.2 ; R74105.1 v2(186.37,171.28) ; R1712.2 v2(117.2,53.83) ; v2(265.41,39.88) 265.41,40.29 R1411.2 ; C1129.2 v2(273.67,60.28) ; C3602.2 v2(5.82,34.53) ; R1417.2 v2(266.68,39.91) ; R9729.1 v2(195.36,191.88) ; C9504.2 v2(91.04,10.27) ; v5(160.35,126.17) C7622.2 ; R5501.1 v2(302.24,67.24) ; R1226.1 v2(288.02,53.7) ; C4636.1 v2(302.19,117.13) ; C5801.2 v2(304.93,130.21) ; R9725.2 v2(204.96,188.34) ; CON5501.4 313.5,83.85 ; C8003.1 49.97,181.16 v2(49.87,181.26) ; C1202.2 v2(295.97,70.16) ; v2(33.99,11.54) C1504.2
  TOP w0.457: R0701.2 72.86,123.65 v3(72.4,123.65) 72.29,123.77 R1014.2 ; R3306.1 284.13,104.12 C3318.2 284.13,104.68 v2(284.21,104.76) ; R8302.2 31.51,50.82 v2(31.74,50.82) ; R8033.2 50.02,183.39 v2(50.02,183.62) ; v2(144.3,32.81) 144.3,32.47 C5008.2 ; R1139.2 290.24,49.96 v2(290.05,50.15) ; R1012.1 75.26,126.87 v3(75.36,126.76) ; v2(151.45,14.72) 151.45,15.07 SR3014.1 ; R8308.2 26.44,45.18 26.67,44.95 v2(26.67,44.92) ; v2(239.71,65.99) 239.6,65.99 239.6,65.99 C2629.2 ; C3319.2 276.03,102.39 v2(275.6,102.39) ; v2(275.01,95.69) 274.94,95.69 274.61,96.02 274.61,96.73 C3308.1 ; R3063.1 v2(151.49,39.45) ; C1616.2 90.67,54.7 ; C3011.2 155.72,39.44 v2(155.74,39.45) ; R3062.1 153.14,39.02 v2(152.71,39.45) 152.32,39.06 R3064.1 ; C8117.2 v2(256.65,59.42) ; R2477.2 241.13,77.68 v2(240.87,77.93) ; R3140.1 182.43,20.4 v2(182.86,20.84) ; v2(28.35,44.94) 28.35,45.4 C8322.2 ; R6118.2 v2(220.71,39.65) ; v2(183.47,20.84) 183.47,20.61 183.83,20.25 183.83,19.69 183.47,19.34 182.71,19.34 182.53,19.51 R3144.2 ; R8817.1 275.11,38.48 v2(275.58,38.94) ; R2112.2 v2(226.29,42.32) ; R2257.2 v2(217.15,42.32)
  TOP w0.508: v2(315.58,39.3) 315.58,39.99 ; v5(194.7,118.83) 194.11,118.24 C7722.2 ; U3101.4 171.56,32.9 171.16,32.51 v2(170.89,32.51) ; C7639.2 152.69,136.11 v5(152.66,136.08) ; v2(296.02,51.54) 295.94,51.62 295.94,51.63 295.57,52 295.56,52 295.38,52.18 C1203.2 ; CON4601.24 321.62,113.6 ; C7734.2 187.69,140.52 v5(187.21,140.03) ; v5(184.51,141.6) 183.88,142.22 C7740.2 v2(183.29,143.07) ; X1101.2 v2(299.52,30.53) ; v2(314.81,39.3) 314.81,39.86 ; C3000.2 146.59,37.76 v2(146.59,37.68) ; C5803.2 v2(305.26,138.84) ; v2(280.68,51.42) 280.68,52 279.93,52.75 U1103.4 ; R1002.1 77.39,122.75 v3(77.31,122.83) ; C7708.2 175.73,137.35 v5(176.12,137.35) ; C7738.2 175.51,131.26 v5(176.16,131.26) ; X1101.4 v2(303.93,28.93) ; v2(309.35,82.15) 308.37,81.17 v2(306.2,81.17) 305.78,80.75 v2(303.13,80.75) 300.44,80.75 C1313.2 300.01,79.92 v2(300.21,79.71) 300.21,79.26 v2(300.03,79.08) 300.03,77.53 298.86,76.36 v2(298.86,75.22) 298.86,74.87 299.73,74 v2(303.16,74) 304.22,74 305.47,75.24 306.73,75.24 C5505.2 ; D3102.2 v2(206.17,23.6) ; v2(210.55,23.6) D3101.2 ; 100.25,183.94 CON4500.42 100.25,188.31 ; U1102.3 278.88,46.28 v2(279.41,45.75) ; C7612.2 160.59,125.93 160.35,126.17 v5(160.35,126.17) ; C80064.1 v2(65,176) ; R1165.2 v2(296.53,49) ; Q5301.2 296.26,95.46 v2(296.11,95.6) ; v2(310.23,66.66) R5201.2 ; v2(140.09,38.74) 139.8,38.74 139.17,39.36 C5002.2 ; v5(160.41,140.29) 160.22,140.1 C7615.2 ; v2(317.2,87.97) 317.2,88.48 ; v5(176.16,126.46) 176.62,126 C7709.2 ; CON4500.43 118.2,185.38 ; CON4500.43 118.2,182.88 ; CON4500.43 120.01,184.15 ; CON4500.43 116.42,184.15 ; R9107.2 187.05,30.89 v2(187.05,32.51) ; C3631.2 11.99,20.48 v2(11.77,20.48) ; CON4601.16 313.7,121.95 ; C7609.2 v5(171.84,141.44) ; 311.06,132.15 CON4601.21 ; CON4601.21 312.44,133.04 ; CON4601.21 312.44,131.26 ; Q6701.2 11.98,40.31 12.65,40.97 v2(12.65,40.98) ; v2(314.36,90.81) 314.36,90.2 ; U1302.4 279.19,85.14 278.62,85.71 v2(278.62,86.47) ; 313.7,128.95 CON4601.2 313.04,129.61 ; C8008.2 v2(47.48,186.34) ; Q5709.2 18.59,58.79 v2(18.65,58.73) ; v2(317.96,90.79) 317.96,90.35 ; U5501.2 v2(304.27,71.36) ; v2(311.31,87.97) 311.31,88.6 ; C3316.2 285.2,99.65 v2(285.2,99.66) ; v2(267.67,94.6) 267.31,94.6 267.06,94.35 U5002.8 ; v2(316.34,39.3) 316.34,39.99 ; v2(290.29,55.17) 290.73,55.17 290.94,55.38 ; v2(268.13,88.17) 267.06,89.24 U5002.5 ; v2(320.27,39.3) 320.27,39.99 ; C6206.2 v2(227.29,35.35) ; 309.48,48.7 309.48,50.22 v2(309.23,50.48) v2(305.76,50.48) 303.16,50.48 302.65,50.98 v2(302.65,52.69) 303.82,53.86 303.82,55.79 v2(303.88,55.85) 304.53,56.5 305.59,56.5 306.1,55.99 v2(307.27,55.99) v2(310.04,55.99) ; v2(318.75,39.3) 318.75,39.99 ; v2(287.99,54.34) 287.97,54.31 C1208.2 ; Q3107.2 210.32,26.3 v2(210.04,26.02) ; Q7407.2 186.79,169.51 v2(186.37,169.93) ; v5(160.35,127.77) 160.02,127.77 C7614.2 159.92,128.57 v5(160.35,128.57) ; v2(200.51,110.01) 200.71,109.81 C7754.2 v2(200.71,108.26) ; v5(206.6,105.48) 206.49,105.6 C7810.2 ; C3315.2 286.71,100.35 286.95,100.1 v2(286.95,99.76) ; Q5701.2 v2(205.46,139.69) ; v2(195.46,109.99) 195.46,109.57 C7707.2 ; C1206.2 294.62,51.81 v2(294.62,51.67) ; C1412.2 260.21,52.49 v2(260.47,52.22) ; C7728.2 189.64,136.24 v2(189.74,136.14) ; v2(266.55,58.05) 266.48,58.12 C8101.2 ; C7664.2 152.71,126.96 v5(152.61,127.06) ; C7601.2 142,141.58 v5(142.3,141.28) ; v2(316.92,90.79) 316.92,90.33 ; U8000.53 58.15,185.32 C8000.2 ; v2(186.29,162.82) 186.04,163.08 C8722.2 ; v2(193.91,15.55) 193.95,15.59 C8205.2 ; 319.44,109.85 CON4800.22 321,110.81 ; v2(312.22,87.97) 312.22,88.5 ; v3(73.68,112.83) 74.18,112.83 74.68,112.32 R1011.1 ; v2(290.38,52.64) 290.43,52.69 R1218.1 ; CON5500.11 312.9,59.39 ; CON5500.11 312.9,57.81 ; CON5500.11 311.41,58.6 ; CON4800.20 317.36,109.85 ; CON4800.20 315.8,110.81 ; CON4800.20 314.24,109.85 ; U5002.6 266.18,91.29 v2(265.62,91.85) ; C9122.2 257.97,77.43 v2(257.97,77.19) ; v2(174.92,164.52) 174.69,164.28 C8737.2 ; 312.9,85.21 CON5501.11 ; CON5501.11 312.9,86.79 ; CON5501.11 311.41,86 ; CON4800.17 312.77,97.35 ; v2(81.64,9.51) v2(81.64,8.87) v2(81.64,8.24) 81.64,7.02 80.32,5.7 79.74,5.7 ; v2(5.57,54.13) 5.57,55.23 6.17,55.84 IU202.2 ; Q5708.2 21.85,64.85 ; v2(267.47,32.77) 267.72,32.52 Q8806.2 ; C7608.2 153.26,128.04 v5(152.68,128.61) ; v5(141.47,137.3) 141.3,137.47 C7637.2 ; v2(313.32,90.81) 313.32,90.23 ; v2(138.16,64.17) 138.56,64.17 138.96,64.56 Q7405.2 ; v2(284.79,104.99) 285.02,104.76 C3317.2 ; v2(312.4,90.81) 312.4,90.23 ; v2(63.81,187.41) 63.48,187.08 R0902.2 ; v2(122.61,144.79) 122.14,144.32 Q5705.2 ; C7636.2 141.38,131.17 v5(141.46,131.25) ; C3022.2 v2(156.57,39.45) ; 106.8,182.87 CON4500.44 ; CON4500.44 106.8,185.41 ; CON4500.44 108.71,184.15 ; CON4500.44 104.99,184.15 ; v2(9.25,19.41) 9.56,19.72 C3616.2 ; v2(319.92,90.79) 319.92,90.3 ; R8108.2 258.04,64.95 v2(257.82,64.73) ; R5200.2 310.16,65.77 310.23,65.84 v2(310.23,65.87) ; 267.06,92.56 266,92.56 v2(265.86,92.43) ; v2(319,90.79) 319,90.23 ; v2(201.99,108.31) R7115.2 ; C9716.2 v2(98.28,182.39) ; 311.41,73.2 CON5501.10 ; CON5501.10 312.9,73.99 ; CON5501.10 312.9,72.41 ; IU203.2 v2(6.58,52.13) ; v5(171.62,140.13) 171.76,140.27 C7605.2 ; C6201.2 239.2,37.34 v2(239.2,38.39) ; v2(131.91,32.72) 132.06,32.57 JRST5001.2 ; Q5702.2 124.41,135.42 v2(126.27,133.56) ; v2(65.39,187.18) 64.75,186.54 R0903.2 ; Y3300.4 v2(288.21,101.07) ; v2(319.51,39.3) 319.51,39.99 ; 124.75,188.14 CON4500.41 124.75,184.33 ; C8915.2 252.54,90.19 ; C8732.2 161.58,164.28 v2(161.8,164.51) ; 312.74,103.35 CON4800.5 ; CON4601.8 313.7,125.95 ; v2(317.1,39.3) 317.1,39.86 ; Y3300.2 v2(291.24,104.61) ; Q3602.2 v2(21.85,24.62) ; C9719.2 v2(95.48,182.15) ; v5(164.3,127.85) 164.62,127.85 165.22,127.25 C7606.2 ; 312.74,100.35 CON4800.11 ; v2(316.01,90.79) 316.01,90.25 ; C8727.2 146.54,163.76 v2(146.21,163.43) ; C2619.2 v2(231.94,71.8) ; v2(288.02,52.69) 287.79,52.69 287.67,52.81 C1221.2 ; v2(316.16,87.97) 316.16,88.5 ; CON4800.2 314.63,105.64 ; CON4601.23 321.47,134.3 ; v2(317.99,39.3) 317.99,39.86 ; v2(147.3,14.71) 147.3,14.33 147.69,13.94 C3019.2 ; C3325.2 v2(286.1,104.77) ; C8821.2 v2(280.78,30.08) ; v2(275.38,41.19) Q8805.2 ; Q5302.2 v2(293.06,95.61) ; v2(313.26,87.97) 313.26,88.5 ; v2(320.96,90.79) 320.96,90.28 ; v2(83.67,189.59) JP5601.2
  IN1 w0.25: v5(164.56,109.09) 164.57,109.09 v5(165.06,108.6)
  IN1 w0.3: v5(162.88,106.45) 163.07,106.45 163.82,107.2 164.4,107.2 v5(164.42,107.17)
  IN1 w0.381: 313.5,54.86 CON5500.4 313.5,56.49 ; 313.5,82.06 CON5501.4 313.5,84.07
  IN1 w0.457: CON1201.10 322.62,38.45
  IN1 w0.508: 318.64,134.3 CON4601.23 ; CON4601.23 320.02,133.41 ; CON4601.23 321.4,134.3 ; CON5501.7 312,80.43 ; CON5501.7 311.17,79.6 ; CON5501.7 312,78.77 ; CON5501.7 312.83,79.6 ; 311.39,45.8 CON5500.10 ; CON5500.10 312.9,44.99 ; CON5500.10 312.9,46.61 ; CON5500.7 312,53.13 ; CON5500.7 311.07,52.2 ; CON5500.7 312,51.27 ; CON5500.7 312.93,52.2 ; CON4601.24 320.02,114.49 ; CON4601.24 321.4,113.6 ; CON4601.24 318.64,113.6 ; CON4601.24 320.02,112.71 ; 311.39,86 CON5501.11 ; CON5501.11 312.9,86.81 ; CON5501.11 312.9,85.19 ; 311.06,132.15 CON4601.21 ; CON4601.21 312.44,133.04 ; CON4601.21 312.44,131.26 ; 317.3,28.21 CON1201.3 ; CON1201.3 316.4,29.2 ; CON1201.3 317.3,30.2 ; CON5501.13 321.37,87.45 ; CON5501.13 319.5,88.31 ; CON5501.13 317.63,87.45 ; 320.1,29.72 CON1201.7 320.1,27.94 ; CON5500.11 312.9,59.41 ; CON5500.11 311.39,58.6 ; CON5500.11 312.9,57.79 ; 311.06,115.75 CON4601.22 ; CON4601.22 312.44,114.86 ; CON4601.22 312.44,116.64 ; 311.39,73.2 CON5501.10 ; CON5501.10 312.9,74.01 ; CON5501.10 312.9,72.39 ; 314.24,109.85 CON4800.20 ; CON4800.20 317.36,109.85 ; CON4800.20 315.8,110.81 ; 319.5,60.91 CON5500.13 317.63,60.05 ; 318.87,30.88 CON1201.B12 ; CON4800.21 314.34,91.85 ; CON4800.21 317.36,91.85 ; CON4800.21 315.8,90.88 ; CON4601.2 313.76,128.95 ; 319.5,43.49 CON5500.12 317.63,44.35 ; 321,110.81 CON4800.22 319.44,109.85 ; 319.5,70.89 CON5501.12 317.63,71.75 ; v2(286.32,36.96) 285.97,36.96 285.05,37.89 285.05,39.07 ; 320.1,36.38 CON1201.8 320.1,38.16 ; 318.87,35.22 CON1201.B1 ; CON1201.4 316.47,36.89 ; CON1201.4 317.3,37.89 ; CON1201.4 317.3,35.9 ; 321,90.88 CON4800.23 319.54,91.85 ; CON1201.9 322.62,29.36 ; CON4601.16 313.77,121.95 ; CON4601.8 313.76,125.95
  IN2 w0.102: v3(110.44,126.43) 110.3,126.29 110.23,126.22 109.97,125.97 109.45,125.97 109.25,126.17 109.25,126.7 v3(108.87,127.08)
  IN2 w0.381: 313.5,84 CON5501.4 313.5,82.02
  IN2 w0.508: CON4800.21 314.34,91.85 ; CON4800.21 315.8,90.88 ; CON4800.21 317.36,91.85 ; 314.24,109.85 CON4800.20 ; CON4800.20 317.36,109.85 ; CON4800.20 315.8,110.81 ; CON1201.3 317.3,28.25 ; CON1201.3 316.38,29.2 ; CON1201.3 317.3,30.17 v2(317.3,30.17) ; 312.44,131.26 CON4601.21 ; CON4601.21 311.06,132.15 ; CON4601.21 312.44,133.04 ; 317.63,71.75 CON5501.12 319.5,70.89 ; 319.54,91.85 CON4800.23 321,90.88 ; 317.63,87.45 CON5501.13 ; CON5501.13 319.5,88.31 ; CON5501.13 321.37,87.45 ; 320.1,36.51 CON1201.8 ; CON5501.7 312.93,79.6 ; CON5501.7 312,78.67 ; CON5501.7 311.07,79.6 ; CON5501.7 312,80.53 ; CON1201.B12 319.5,30.83 ; 312.44,114.86 CON4601.22 ; CON4601.22 312.44,116.64 ; CON4601.22 311.06,115.75 ; 318.64,134.3 CON4601.23 ; CON4601.23 320.02,133.41 ; CON4601.23 321.4,134.3 ; CON1201.7 320.1,29.62 ; CON5500.11 312.9,59.41 ; CON5501.11 312.9,86.81 ; CON5501.11 311.39,86 ; CON5501.11 312.9,85.19 ; v2(317.3,35.93) 317.3,35.93 CON1201.4 316.59,36.89 ; 322.62,27.74 CON1201.9 322.62,29.36 ; 319.5,43.49 CON5500.12 317.63,44.35 ; CON4601.24 321.4,113.6 ; CON4601.24 318.64,113.6 ; CON4601.24 320.02,112.71 ; CON4601.24 320.02,114.49 ; 319.44,109.85 CON4800.22 321,110.81 ; CON5501.10 312.9,74.01 ; CON5501.10 312.9,72.39 ; CON5501.10 311.39,73.2 ; 319.5,35.27 CON1201.B1 ; 319.5,60.91 CON5500.13 317.63,60.05 ; CON4601.8 313.74,125.95 ; 322.62,38.24 CON1201.10 322.62,36.86 ; CON4601.2 313.74,128.95 ; CON5500.10 312.9,44.87
  IN3 w0.254: 282.62,108.24 282.47,108.09 282.47,104.21 282.96,103.72 282.96,102.83 282.39,102.26 281.79,102.26 U3300.50 U3300.49 U3300.48 281.38,98.84 278.41,95.87 276.39,95.87 275.54,95.02 269.18,95.02 268.76,94.6 v2(267.67,94.6) 267.12,94.05 265.36,94.05 264.36,93.05 263.78,93.05 263.48,92.76 263.48,92.33 264.34,91.47 v2(264.98,91.47) 265.22,91.47 265.6,91.85 v2(265.62,91.85) 265.86,92.09 v2(265.86,92.43) 267.66,92.43 268.3,93.07 269.4,93.07 269.82,93.5 276.17,93.5 277.01,94.34 v2(277.22,94.34) v2(277.86,94.34) 279.06,94.34 282.97,98.25 282.97,100.6 v2(283.32,100.95) 283.47,100.95 v2(283.83,101.3) 284.55,102.02 284.55,104.42 v2(284.21,104.76) 284.05,104.91 v2(284.05,106.46) 284.05,107.19 284.78,107.92 284.78,111.3 v2(285.05,111.56) 285.05,112.03 v2(286.4,113.39) 286.4,117.02 286.87,117.48 v2(286.87,117.48) 287.27,117.88 287.27,120.38 286.34,121.31 286.14,121.31
  IN3 w0.381: 313.5,82.09 CON5501.4 313.5,84.04
  IN3 w0.508: 312.64,103.35 CON4800.5 ; 312.44,114.86 CON4601.22 ; CON4601.22 311.06,115.75 ; CON4601.22 312.44,116.64 ; CON4601.21 312.44,133.04 ; CON4601.21 311.06,132.15 ; CON4601.21 312.44,131.26 ; 320.02,133.41 CON4601.23 ; CON4601.23 318.64,134.3 ; CON4601.23 321.4,134.3 ; 312.24,121.95 CON4601.16 ; 317.63,44.35 CON5500.12 319.5,43.49 ; 318.64,113.6 CON4601.24 ; CON4601.24 320.02,114.49 ; CON4601.24 321.4,113.6 ; CON4601.24 320.02,112.71 ; 310.74,124.45 CON4601.11 312.34,124.45 ; 320.1,27.94 CON1201.7 320.1,29.72 ; 319.5,60.91 CON5500.13 317.63,60.05 ; 321.31,37.55 CON1201.10 ; CON1201.10 322.62,38.36 ; CON1201.10 322.62,36.74 ; 322.62,27.74 CON1201.9 322.62,29.36 ; CON1201.4 317.3,37.89 ; CON1201.4 317.3,35.9 ; CON1201.4 316.49,36.89 ; 312.24,125.95 CON4601.8 ; CON5501.10 312.9,74.01 ; CON5501.10 312.9,72.39 ; CON5501.10 311.39,73.2 ; 313.04,129.75 CON4601.2 312.24,128.95 ; CON5501.7 312,80.53 ; CON5501.7 312,78.77 ; CON5501.7 312.93,79.6 ; CON5501.7 311.17,79.6 ; CON5500.11 312.9,59.41 ; 312.64,100.35 CON4800.11 ; 312.34,127.45 CON4601.5 310.74,127.45 ; CON4800.20 315.8,110.81 ; CON4800.20 314.24,109.85 ; CON4800.20 317.36,109.85 ; 311.54,119.65 CON4601.19 ; CON4601.19 312.34,120.45 ; CON4601.19 310.74,120.45 ; 317.63,87.45 CON5501.13 ; CON5501.13 321.37,87.45 ; CON5501.13 319.5,88.31 ; CON5501.11 312.9,86.81 ; CON5501.11 311.39,86 ; CON5501.11 312.9,85.19 ; CON4800.21 317.36,91.85 ; CON4800.21 315.8,90.88 ; CON4800.21 314.24,91.85 ; CON1201.8 320.1,38.16 ; CON1201.8 321.28,37.27 ; CON1201.8 320.1,36.38 ; 321,90.88 CON4800.23 319.44,91.85 ; 317.63,71.75 CON5501.12 319.5,70.89 ; 317.3,28.21 CON1201.3 316.49,29.2 ; CON4800.2 314.63,105.64 ; 319.44,109.85 CON4800.22 321,110.81 ; CON5500.10 312.9,44.91
  IN4 w0.102: v3(108.87,127.08) 109.25,126.7 109.25,126.17 109.45,125.97 109.97,125.97 110.23,126.22 110.3,126.29 v3(110.44,126.43)
  IN4 w0.381: 313.5,84.06 CON5501.4 313.5,82.08
  IN4 w0.432: 318.94,35.29 CON1201.B1
  IN4 w0.508: CON4601.24 320.02,114.49 ; CON4601.24 320.02,112.71 ; CON4601.24 318.64,113.6 ; CON4601.24 321.4,113.6 ; CON5501.13 319.5,88.31 ; CON5501.13 317.63,87.45 ; CON5501.13 321.37,87.45 ; 315.8,90.88 CON4800.21 ; CON4800.21 317.36,91.85 ; CON4800.21 314.24,91.85 ; 319.5,70.89 CON5501.12 317.63,71.75 ; 312.34,124.45 CON4601.11 310.74,124.45 ; 320.02,133.41 CON4601.23 ; CON4601.23 318.64,134.3 ; CON4601.23 321.4,134.3 ; CON4601.21 312.44,133.04 ; CON4601.21 311.06,132.15 ; CON4601.21 312.44,131.26 ; CON1201.3 317.3,30.2 ; CON1201.3 316.5,29.2 ; CON1201.3 317.3,28.15 ; 312.9,85.19 CON5501.11 ; CON5501.11 311.39,86 ; CON5501.11 312.9,86.81 ; 312.24,121.95 CON4601.16 ; 312.44,114.86 CON4601.22 ; CON4601.22 311.06,115.75 ; CON4601.22 312.44,116.64 ; v2(317.3,35.93) 317.3,35.93 CON1201.4 ; CON1201.4 316.55,36.89 ; CON1201.4 317.3,37.8 ; 312.24,128.95 CON4601.2 313.04,129.75 ; CON1201.10 321.32,37.55 ; CON1201.10 322.62,36.78 ; CON1201.10 322.62,38.33 ; CON5501.10 312.9,74.01 ; CON5501.10 311.39,73.2 ; CON5501.10 312.9,72.39 ; 317.63,44.35 CON5500.12 319.5,43.49 ; 310.74,120.45 CON4601.19 ; CON4601.19 311.54,119.65 ; CON4601.19 312.34,120.45 ; CON5501.7 312,80.53 ; CON5501.7 311.07,79.6 ; CON5501.7 312.93,79.6 ; CON5501.7 312,78.67 ; 314.24,109.85 CON4800.20 ; CON4800.20 315.8,110.81 ; CON4800.20 317.36,109.85 ; 312.24,125.95 CON4601.8 ; 320.1,28.03 CON1201.7 320.1,29.6 ; 318.87,30.88 CON1201.B12 ; 319.44,109.85 CON4800.22 321,110.81 ; CON5500.11 312.9,59.41 ; 319.5,60.91 CON5500.13 317.63,60.05 ; CON1201.8 321.28,37.27 ; CON1201.8 320.1,38.05 ; CON1201.8 320.1,36.5 ; 312.34,127.45 CON4601.5 310.74,127.45 ; 321,90.88 CON4800.23 319.44,91.85 ; 322.62,27.63 CON1201.9 322.62,29.34 ; CON5500.10 312.9,44.9
  BOTTOM w0.102: U7000.P51 170.35,111.25 170.68,111.58 170.68,112.01 170.56,112.13 170.56,112.73 v5(169.99,113.29) ; U7000.W8 166.83,80.93 v5(166.83,80.27) ; v5(144.97,131.78) v5(144.97,131.13) v5(144.32,131.13) ; v5(143.67,136.33) 144.32,136.33 v5(144.32,136.33) v5(144.32,136.98) ; v5(149.52,136.33) v5(150.17,136.33) ; v5(149.52,136.33) 148.87,136.33 v5(148.87,136.33) ; v5(149.52,136.33) v5(149.52,136.98) ; v5(183.46,56.67) v5(183.46,57.32) ; v5(183.46,57.32) v5(184.11,57.32) ; v5(183.46,57.32) v5(183.46,57.97) v5(182.81,57.97) ; v5(205.33,103.31) v5(205.33,102.66) v5(205.98,102.66) ; v5(184.82,136.37) 184.82,136.38 v5(184.17,136.38) ; v5(181.85,93.6) 182.24,93.99 183.34,93.99 v5(183.7,93.63) ; v5(169.48,138.28) v5(168.82,138.28) ; v5(178.97,136.37) 178.97,136.38 v5(178.32,136.38) ; v5(176.3,110.7) v5(176.3,110) 176.3,109.3 v5(176.3,109.29) ; U7000.G49 175.22,109.62 175.22,108.95 v5(175.23,108.94) 175.25,108.92 U7000.G47 ; U7000.AE8 v5(162.65,80.23) ; v5(204.03,97.46) v5(204.68,97.46) ; v5(204.03,97.46) v5(204.03,98.11) ; v5(204.03,97.46) v5(204.03,96.81) ; v5(177.61,51.47) v5(178.26,51.47) ; v5(178.26,51.47) v5(178.26,50.82) ; v5(178.26,51.47) v5(178.91,51.47) ; v5(206.63,96.81) v5(206.63,97.46) ; v5(206.63,97.46) v5(207.28,97.46) ; v5(206.63,97.46) v5(205.98,97.46) ; v5(206.63,97.46) v5(206.63,98.11) ; v5(205.98,78.33) v5(205.98,77.68) ; v5(197.13,114.04) v5(197.13,113.39) v5(196.48,113.39) ; v5(184.11,50.17) v5(183.46,50.17) v5(183.46,49.52) ; U7000.AL8 158.43,80.97 v5(158.43,81.61) ; v5(160.55,78.87) 160.55,78.86 U7000.AH4 ; v5(184.17,136.38) v5(184.17,137.03) ; v5(184.17,136.38) 183.52,136.38 v5(183.52,136.38) ; v5(179.62,129.88) v5(178.97,129.88) ; v5(176.63,88.64) 176.64,88.65 U7000.D19 ; v5(183.46,51.47) 183.46,51.47 v5(184.11,51.47) ; v5(178.26,56.02) 178.91,56.02 v5(178.91,56.02) ; U7000.F31 175.91,97.09 175.28,97.09 v5(175.24,97.05) ; v5(149.52,131.78) 149.52,131.78 148.87,131.78 v5(148.87,131.78) ; v5(173.17,78.85) 173.15,78.83 U7000.K4 ; 161.69,72.94 161.37,72.62 161.37,72.41 v5(161.94,71.84) 161.47,71.37 161.47,71.13 v5(161.89,70.72) ; v5(206.23,113.39) v5(206.23,112.74) ; v5(197.53,102.01) v5(197.53,102.66) v5(198.18,102.66) v5(198.83,102.66) ; v5(144.32,129.83) v5(144.97,129.83) ; v5(178.32,137.68) v5(178.97,137.68) v5(178.97,138.33) ; v5(181.63,81.49) 181.52,81.38 180.77,81.38 v5(180.65,81.5) ; v5(177.71,110.71) 177.68,110.68 v5(177.68,109.98) ; v5(204.03,103.31) v5(204.03,102.66) ; v5(169.47,129.18) v5(168.82,129.18)
  BOTTOM w0.12: v5(146.63,138.61) 146.6,138.64 145.33,138.64 U7601.U5
  BOTTOM w0.125: v5(176.97,111.38) 176.99,111.4 176.99,112.59 177.67,113.27 177.67,116.15
  BOTTOM w0.127: D1203.2 v2(315.63,30.13) ; v2(315.53,31.75) 315.58,31.8 D1204.2 ; v2(215.12,67.12) 215.54,67.54 216.53,67.54 v2(216.95,67.12) 217.62,67.12 ; D1206.2 315.6,35.87 v2(315.42,36.05) ; v2(315.65,34.09) 315.76,34.2 D1205.2
  BOTTOM w0.13: U7000.AU47 v5(154.25,107.58)
  BOTTOM w0.14: v2(175.62,118.14) 175.67,118.14 177.67,116.15
  BOTTOM w0.15: 171.05,104.8 171.05,104.8 ; 171.05,104.8 171.05,104.8 ; 171.05,104.8 U7000.N43 ; 171.05,104.8 v5(171.05,104.75) 171.05,104.75 171.05,104.8 ; 171.05,104.8 171.05,104.8 ; U7000.H1 174.55,75.15 v5(175.36,74.35) ; v5(172.45,103.35) U7000.K40 ; U7000.G2 175.15,76.85 175.15,77.21 v5(175.04,77.32) ; v5(166.85,104.75) U7000.W43 ; U7000.AH47 160.55,108.91 v5(160.56,108.92) ; v5(166.85,78.87) 166.85,78.86 U7000.W4 ; U7000.AL51 158.45,110.95 ; 158.45,110.95 158.45,110.91 158.71,110.64 v5(158.71,110.49) 158.48,110.26 ; 158.45,110.95 158.19,110.69 v5(158.19,110.54) 158.21,110.54 158.48,110.26 ; U7000.AH2 160.67,76.63 160.67,73.96 161.69,72.94 v5(161.94,72.94) ; U7000.H37 174.54,101.26 v5(173.86,101.26) ; U7000.W47 166.85,107.58 v5(166.86,107.57) ; v5(156.33,106.16) 156.33,106.21 156.35,106.23 U7000.AP45 ; U7000.C5 178.11,78.91 178.69,78.91 U7000.B5 ; U7000.F16 v5(175.26,86.55) ; v5(158.47,106.16) 158.47,106.22 158.45,106.25 U7000.AL45 ; v5(175.28,84.46) 175.29,84.45 U7000.F13 ; U7000.H19 173.85,88.65 v5(173.85,88.66) ; v5(156.36,108.94) 156.34,108.96 156.34,109.64 U7000.AP49 ; U7000.D7 177.34,80.24 176.64,80.24 v5(176.64,80.25) ; 174.55,103.39 U7000.H40 175.21,103.35 175.24,103.37 v5(175.24,103.37) ; v5(164.56,109.09) 164.56,109.26 164.75,109.45 U7000.AB49 ; v5(176.66,107.55) 176.67,107.55 176.68,107.54 177.34,107.54 U7000.D46 ; U7000.AE43 v5(162.65,104.75) ; U7000.D37 176.67,101.25 v5(176.65,101.27) ; U7000.T8 v5(168.95,81.61) ; v5(172.45,101.25) U7000.K37 ; U7000.AB47 164.75,107.58 v5(164.76,107.57) ; v5(168.95,104.75) 168.95,104.75 168.95,105.45 U7000.T43 v5(168.95,106.15) U7000.T45 ; U7000.AB45 164.75,106.18 v5(164.72,106.15) ; U7000.D22 176.63,90.75 v5(176.62,90.75) ; v5(172.45,97.05) 172.46,97.06 173.14,97.06 U7000.K31 173.84,97.05 173.86,97.03 v5(173.86,97.03) ; U7000.AB4 164.75,78.15 v5(164.75,78.87) ; v5(156.35,104.75) U7000.AP43 ; 160.58,105.45 U7000.AH43 v5(160.55,104.75) ; v5(158.25,109.1) 158.45,108.89 158.45,108.25 U7000.AL47 ; v5(162.64,107.53) 162.65,107.54 U7000.AE47 ; U7000.AP47 156.35,107.61 156.38,107.59 v5(156.38,107.55) ; U7000.D40 176.67,103.35 v5(176.66,103.36) ; U7000.H28 v5(175.24,94.95) ; U7000.N10 v5(171.05,83.05) ; U7000.AE6 162.65,79.54 v5(162.65,78.87) ; v5(173.15,80.27) U7000.K8 ; U7000.AB10 v5(164.75,83.05) ; v5(175.26,92.85) U7000.F25 ; U7000.N49 171.06,109.64 171.06,108.98 v5(171.05,108.97) ; v5(158.95,71.7) 159.32,71.7 160.03,72.41 160.03,75.6 160.2,75.77 160.2,76.19 160.17,76.22 160.17,76.23 159.85,76.55 U7000.AJ2 ; v5(172.45,94.95) 172.47,94.97 173.13,94.97 U7000.K28 173.16,94.96 v5(173.86,94.96) ; U7000.H16 174.54,86.56 173.87,86.56 v5(173.86,86.57) ; v5(176.31,115.29) 176.35,115.25 v5(176.35,114.57) 176.11,114.33 176.11,112.56 v5(175.95,112.4) ; U7000.W10 v5(166.85,83.05) ; U7000.AU49 154.24,109.64 v5(154.24,108.94) ; 158.48,110.26 158.47,110.26 158.47,109.67 U7000.AL49 ; U7000.F10 176.63,82.35 v5(176.65,82.33) ; v5(162.66,81.66) 162.65,81.67 U7000.AE10 v5(162.65,83.05) ; U7000.N47 171.05,107.58 v5(171.07,107.56) ; v5(160.55,83.05) 160.56,83.04 160.56,82.36 U7000.AH10 ; v5(158.45,104.75) U7000.AL43 ; v5(176.35,86.88) 176.45,86.88 176.9,86.42 v5(176.9,86.38) ; U7000.AB43 v5(164.75,104.75) ; U7000.AH45 160.54,106.84 160.54,106.18 v5(160.57,106.15) ; v5(172.47,99.15) U7000.K34 ; v5(181.39,49.49) 181.64,49.49 181.99,49.14 182.43,49.14 U7901.U5 ; U7000.D43 176.64,105.45 v5(176.63,105.46) ; v5(168.95,83.05) U7000.T10 ; U7000.T4 168.95,78.86 v5(168.95,78.87)
  BOTTOM w0.151: U7000.H31 v5(175.24,97.05)
  BOTTOM w0.152: U2000.A18 217.26,61.36 216.45,61.36 216.13,61.68 v2(215.55,61.68) ; 114.44,106.52 114.53,106.59 114.82,106.79 U0300.A6 ; U0300.C37 114.06,129.74 114.06,130.27 ; U2000.A37 217.46,52.04 U2000.B37 U2000.C37
  BOTTOM w0.17: v5(172.99,110.58) 173.46,110.11 v5(173.46,110.04) ; U7000.T47 168.96,108.24 168.96,107.55 v5(168.96,107.55) ; v5(173.87,90.74) 173.87,90.73 174.54,90.73 U7000.H22 ; v5(179.81,111.53) 180,111.35 180,110.77 v5(179.92,110.69)
  BOTTOM w0.178: v5(162.62,108.95) 162.65,108.98 U7000.AE49 ; v2(240.1,63.5) U2000.BE14 ; U2000.BB30 236.85,55.64 236.45,55.23 235.85,55.23 U2000.AV31 ; v2(230.26,70.22) 230.26,69.99 U2000.AH1 ; U2000.BE23 239.21,59.14 v2(239.47,59.14) ; v2(225.84,47.43) 225.92,47.5 U2000.V45 ; v5(158.43,81.61) 158.45,81.63 U7000.AL10 v5(158.45,83.05) ; U7000.AH8 160.55,80.26 v5(160.53,80.24) ; v5(166.85,81.62) U7000.W8 ; U2000.BB21 237.13,60.18 236.59,60.73 U2000.AW19 ; v2(239.71,65.99) 239.52,65.8 U2000.BE9 ; v2(239.83,51.95) 239.67,52.11 U2000.BE37 ; U0300.BM35 76.6,128.33 75.4,128.33 ; v2(228.07,70.26) 228.07,69.91 U2000.AC1 ; U2000.A37 217.02,52.12 216.94,52.04 v2(216.41,52.04) ; v2(216.9,54.53) 217.02,54.42 U2000.A32
  BOTTOM w0.2: v5(177.7,86.92) 177.81,86.92 177.88,86.85 178.12,86.85 v5(178.29,86.69) 178.42,86.55 U7000.B16 ; v5(165.23,134.29) 165.16,134.21 v5(165.16,133.72) ; U7000.F19 175.28,88.65 v5(175.27,88.66) ; U7000.BJ27 U7000.BH27 ; v5(154.49,105.91) v5(153.95,106.45) 153.95,106.55 U7000.AU45 154.55,106.55 v5(154.55,106.46) ; U7000.BH39 U7000.BJ39 ; U7601.K3 144.32,134.38 v5(144.32,134.38) 144.32,134.38 U7601.L3 ; U7000.AR4 155.71,78.09 156.29,78.09 U7000.AP4 ; v5(168.75,109.1) 168.8,109.1 v5(169.25,108.65) ; U7000.AP45 156.35,106.85 v5(155.98,107.21) ; U7000.H37 174.91,101.61 v5(174.91,101.62) ; v5(148.34,140.41) 148.55,140.21 U7601.W10 ; v5(169.32,109.98) 169.05,110.25 v5(169.05,110.55) ; U7000.F37 175.62,101.58 v5(175.62,101.63) ; U7000.AL6 158.4,79.5 158.4,78.9 v5(158.8,78.5) ; v5(206.47,100.31) 206.38,100.4 206.38,101.61 U7801.U5 ; U7000.AN5 U7000.AN4 U7000.AM4 ; U7000.K51 173.15,110.9 172.99,110.74 v5(172.99,110.58) ; U7701.U5 180.02,138.73 180.48,138.73 180.56,138.64 181.08,138.64 v5(181.12,138.68) ; v5(186.19,135.8) U7701.M14 ; U7000.BH36 U7000.BJ36 ; U7000.AL49 158.45,109.64 ; U7000.B5 v5(179.11,78.49) ; U7701.T14 186.09,138.3 v5(186.18,138.3) ; U7000.BH30 U7000.BJ30
  BOTTOM w0.203: U2000.P45 223.65,47.62 223.58,47.55 v2(223.58,47.45) ; v2(239.67,61.26) 239.64,61.22 U2000.BE18 ; U2000.AU1 235.29,70.01 v2(235.29,70.9) ; v2(235.97,60.1) 235.97,60.33 U2000.AW19 ; v2(230.61,47.56) 230.47,47.7 U2000.AH45 ; v3(115.65,110.87) 115.64,110.85 U0300.A12 ; U0300.A20 115.59,117.15 v3(115.65,117.21) ; v2(239.69,54.25) 239.54,54.4 U2000.BE32 ; U0300.BJ32 78.48,126.11 v3(78.16,126.43) ; U0300.A10 115.88,109.28 v3(115.93,109.23) ; v2(229.34,50.22) 229.43,50.14 U2000.AE42 ; U0300.A26 115.15,121.88 v3(115.55,122.28) ; U2000.BE40 239.04,50.48 239.73,50.48 v2(239.81,50.4) ; U9600.14 116.73,148.99 116.44,149.28 v2(116.11,149.28) ; v2(232.54,47.61) 232.54,47.95 U2000.AM45 ; U2000.BE28 239.21,56.48 v2(239.68,56.48) ; U0300.D20 112.68,116.77 112.21,116.77 112.03,116.59 ; U0300.L30 U0300.L29 108.47,123.77 v3(108.28,123.57) ; U0300.A30 v3(115.67,125.23) ; U0300.A18 v3(115.65,115.58) ; U0300.L34 108.54,127.41 v3(108.87,127.08) 108.55,126.76 U0300.L33 ; v3(115.82,118.9) 115.64,118.73 U0300.A22 ; U2000.AC45 227.74,47.69 v2(227.74,47.48) ; U0300.D22 113.31,118.48 113.31,118.34 U0300.C21 113.71,117.87 v3(114.04,117.55) ; U2000.AY45 237.53,47.28 237.83,47.28 v2(238.18,46.92) ; v3(115.65,120.3) U0300.A24 ; U0300.A28 v3(116.1,123.45) ; U2000.AU45 235.11,48.07 235.11,46.64 v2(235.13,46.62)
  BOTTOM w0.227: v5(164.42,107.17) U7000.AB45 ; v5(165.1,105.81) 165.1,105.8 U7000.AB43
  BOTTOM w0.249: U7000.V49 167.54,109.65 v5(167.19,109.99)
  BOTTOM w0.25: U7800.M1 200.45,76.3 v5(200.39,76.24) ; U7000.J17 173.58,86.98 173.55,86.98 v5(173.46,86.89) ; v5(176.28,105.83) 176.28,105.81 v5(176.63,105.46) ; v5(176.28,105.83) 176.27,105.83 ; v5(176.28,105.83) 175.95,106.15 U7000.F44 175.65,105.85 v5(175.6,105.85) ; v5(164.83,110.49) 164.83,110.37 165.11,110.09 v5(165.11,109.99) ; U7900.H14 165.98,52.12 v5(166.16,52.12) ; v3(156.7,80.6) 156.7,80.6 U7000.AP8 156.7,81.3 v3(156.7,81.3) U7000.AN8 U7000.AM9 157.75,81.68 v5(158.06,81.99) ; v5(194.93,76.43) 194.77,76.43 194.29,76.91 v5(194.29,77.02) ; U7000.BL7 144.73,80.25 v3(144.93,80.05) ; v5(176.31,108.61) U7000.E48 176.3,109.29 v5(176.3,109.29) ; v5(180.36,140.39) 180.31,140.34 180.31,140.31 U7701.W5 ; U7800.R10 198.5,82.56 v5(198.18,82.88) 197.85,83.2 U7800.T11 v5(197.53,83.53) ; U7000.D46 177.49,107.69 v5(177.83,107.69) 178.09,107.69 v5(178.3,107.47) 178.37,107.55 U7000.B46 ; v5(167.41,137.1) 167.61,137.3 167.85,137.3 U7600.E5 ; v5(196.23,101.36) 196.22,101.37 196.22,101.37 195.9,101.68 U7801.A5 ; v5(173.86,86.57) 173.54,86.89 v5(173.46,86.89) ; v5(175.24,94.95) 175.6,95.31 v5(175.62,95.31) 175.95,94.98 U7000.F28 175.98,94.95 v5(176.31,94.62) 176.4,94.62 176.89,95.11 v5(176.89,95.12) 177.18,95.12 U7000.D28 177.44,94.95 177.62,95.13 v5(178.24,95.13) ; v5(184.17,129.88) U7701.D11 v5(183.52,130.53) U7701.E10 ; U7800.W10 v5(195.58,82.88) 195.58,82.87 195.55,82.85 v5(194.96,82.85) ; U7600.N10 164.28,131.78 v5(164.27,131.78) ; v5(173.33,107.33) 173.45,107.45 v5(173.45,107.85) 173.45,107.95 U7000.K47 ; v5(173.33,107.33) 173.31,107.31 ; v5(173.33,107.33) 172.85,107.81 v5(172.85,107.88) 172.85,107.95 U7000.K47 ; v5(173.33,107.33) 173.33,107.03 U7000.K45 ; U7700.U5 197.14,114.68 197.14,114.68 v5(197.14,114.69) ; U7700.U5 v5(197.78,114.04) ; U7700.U5 v5(197.13,114.04) ; v5(155.62,112.89) 155.65,112.86 U7000.AR52 ; v3(144.92,84.27) 144.73,84.45 U7000.BL13 ; U7601.K1 142.51,134.05 142.43,133.97 v5(142.07,133.97) ; U7000.AL2 158.45,77.09 v5(158.66,77.3) 158.64,77.32 158.63,77.32 158.27,77.68 158.27,77.94 158.45,78.12 U7000.AL4 v5(158.8,78.5) ; v5(162.97,133.08) U7600.L12 ; v5(162.71,47.5) 163.06,47.84 U7900.A10 163.38,48.22 v5(163.38,48.22) ; U7701.F2 v5(177.67,131.18) U7701.F1 ; v5(178.32,133.13) U7701.J3 ; v5(145.62,128.53) 145.61,128.53 145.29,128.21 U7601.A5 ; v5(156.51,56.67) 156.88,56.67 U7900.P1 v5(157.53,56.02) ; v5(205.98,103.96) 205.65,103.64 U7801.T2 ; v5(205.98,103.96) 205.98,103.96 U7801.T1 205.65,104.66 v5(205.8,104.81) ; v5(205.98,103.96) 205.98,103.96 ; U7000.BH42 146.3,105 v3(146.27,105.15) ; v5(197.53,97.46) U7801.D11 v5(198.18,98.11) 198.18,98.11 U7801.E10 ; U7800.B13 207.28,84.83 v5(207.28,84.83) U7800.B14 207.2,85.41 v5(207.2,85.56) 207.2,86.22 v5(207.23,86.25) ; U7000.N43 v5(171.39,105.79) 171.39,105.81 v5(171.04,106.16) 171.4,106.52 v5(171.41,106.52) 171.08,106.85 U7000.N45 v5(170.71,107.19) 171.07,107.55 v5(171.07,107.56) ; v5(204.68,77.68) 204.66,77.66 204.65,77.66 U7800.F2 ; U7700.D11 v5(206.23,117.94) U7700.C10 v5(206.89,117.28) ; U7000.AK1 v5(159.15,75.48) ; U7000.K45 173.2,106.8 ; U7000.K45 173.2,106.8 ; 173.2,106.8 173.23,106.77 ; 173.2,106.8 173.23,106.76 ; v5(148.87,131.78) 148.87,131.78 U7601.G10 ; U7000.K40 173.22,103.35 v5(173.51,103.64) 174.19,103.64 v5(174.25,103.7) 174.55,103.39 ; 173.23,106.76 173.23,106.28 172.99,106.04 172.53,106.04 v5(172.47,106.1) ; U7000.G6 175.08,79.38 v5(175.08,79.06) ; v5(186.79,136.08) 186.51,135.8 v5(186.19,135.8) ; v5(175.62,99.52) 175.6,99.5 175.6,99.47 175.29,99.17 v5(175.24,99.17) 175.23,99.17 v5(174.87,99.53) 174.55,99.2 U7000.H34 174.44,99.26 173.97,99.26 v5(173.91,99.2) 173.81,99.2 173.5,99.51 v5(173.49,99.51) 173.15,99.18 U7000.K34 ; v5(175.62,99.52) 175.94,99.85 U7000.F35 ; v5(175.62,99.52) 175.95,99.19 U7000.F34 175.95,99.12 v5(176.28,98.79) 176.29,98.79 v5(176.65,99.15) 177,99.5 v5(177,99.52) 177.35,99.17 U7000.D34 177.67,99.47 v5(177.67,99.49) 177.79,99.37 v5(178.16,99.37) 178.16,99.09 v5(178.36,98.89) ; v5(184.11,50.17) U7901.T2 v5(184.76,49.52) ; v5(145.74,137.75) 146.29,137.2 v5(146.29,137.08) ; v5(145.74,137.75) U7601.R5 ; v5(145.74,137.75) 146.6,138.61 v5(146.63,138.61) ; v5(175.26,86.55) 174.91,86.89 v5(174.91,86.93) 174.55,86.56 U7000.H16 ; v5(167.52,127.88) 167.85,128.2 U7600.W5 v5(168.17,128.53) ; U7800.P13 v5(198.83,84.83) 198.87,84.88 U7800.P14 ; v5(176.23,53.5) 176.25,53.48 176.37,53.48 U7901.K14 ; v5(180.88,98.69) 181.06,98.52 v5(181.66,98.52) ; U7700.N10 v5(199.73,117.94) ; v3(154.37,77.4) 154.37,77.6 154.25,77.72 U7000.AU4 ; U7000.N47 171.07,108.25 v5(171.42,108.6) 171.05,108.97 v5(171.05,108.97) ; U7801.L12 v5(202.08,97.46) ; U7801.V14 207.13,95.65 207.3,95.49 v5(207.3,95.33) ; U7000.M52 v5(171.75,112.31) ; U7000.AE45 162.6,106.85 162.32,107.13 162.32,107.13 v5(162.3,107.15) ; U7000.AE45 162.69,106.81 162.69,106.65 v5(162.88,106.45) 162.84,106.41 162.84,106.01 v5(163.02,105.82) U7000.AE43 162.35,105.75 v5(162.35,105.82) ; U7000.AE45 162.95,107.15 v5(163,107.15) 163,107.17 v5(162.64,107.53) 162.64,107.5 162.3,107.16 v5(162.3,107.15) ; U7701.C10 183.52,129.23 v5(183.52,129.23) ; v5(169.47,129.18) 169.8,128.85 U7600.V2 170.12,128.53 v5(170.12,128.53) U7600.V1 v5(170.8,128.5) ; U7800.H14 203.3,85.41 v5(203.3,85.69) ; v3(147.6,99.5) U7000.BG34 ; v5(207.85,75.63) 207.85,75.71 v5(207.28,76.28) 207.28,76.38 U7800.B1 207.28,77.03 v5(207.28,77.03) U7800.B2 ; v5(179.21,75.6) 178.76,76.05 U7000.B1 ; U7800.K1 201.79,76.67 201.79,76.03 v5(201.98,75.84) ; U7801.P1 204.35,104.69 204.36,104.7 v5(204.36,104.74) ; v5(176.28,105.09) 176.28,105.12 U7000.F43 175.95,105.5 v5(175.6,105.85) ; v5(173.86,97.03) 173.87,97.03 174.19,97.35 v5(174.19,97.43) 174.55,97.07 U7000.H31 ; v5(162.27,78.52) U7000.AE4 162.91,77.89 v5(162.91,77.76) 162.91,77.7 v5(162.52,77.31) 162.65,77.18 U7000.AE2 ; v5(162.27,78.52) U7000.AF5 ; v5(162.27,78.52) 162.62,78.87 v5(162.65,78.87) ; 176.27,107.22 175.95,107.55 U7000.F46 175.65,107.85 v5(175.52,107.85) ; 176.27,107.22 176.31,107.22 176.63,107.55 v5(176.66,107.55) ; 176.27,107.22 v5(176.27,107.17) ; U7000.AP51 156.35,110.62 v5(156.3,110.57) 156.1,110.37 v5(156.1,110.04) 156.1,109.9 U7000.AP49 ; v5(179.62,131.83) U7701.G5 v5(180.27,132.48) ; v5(152.55,139.98) 152.07,139.5 151.55,139.5 v5(151.47,139.58) U7601.V14 150.82,139.58 v5(150.82,139.58) 150.5,139.26 U7601.V13 150.49,139.25 v5(150.17,138.93) ; v5(176.96,50.82) U7901.P13 v5(177.61,51.47) ; U7901.F13 176.96,56.02 v5(176.96,56.02) U7901.F14 176.54,56.45 v5(176.18,56.45) ; v5(176.31,52.12) U7901.M14 ; U7900.K3 158.5,53.75 v5(158.18,53.42) 158.18,53.42 U7900.J3 158.83,53.42 v5(158.83,53.42) 158.51,53.75 U7900.K3 ; U7900.K3 158.83,54.07 v5(158.83,54.07) U7900.L3 ; v5(179.1,112.22) 178.83,112.5 v5(178.26,112.5) ; v5(179.1,112.22) 179.1,112.1 U7000.B52 U7000.C52 ; v5(179.1,112.22) 179.12,112.2 179.52,112.2 v5(179.65,112.07) ; v5(166.51,53.83) 166.02,53.83 165.94,53.75 U7900.K14 ; v5(166.85,81.62) 166.49,81.98 v5(166.49,81.99) ; v5(196.88,82.88) U7800.U10 ; U7701.T11 v5(184.17,138.33) ; U7601.N5 145.51,135.79 v5(145.7,135.79) ; v5(197.78,120.54) U7700.T14 198.22,120.1 198.22,119.67 U7700.T13 ; v5(206.65,82.21) U7800.C10 v5(205.98,82.88) U7800.D11 ; U7601.F13 v5(150.82,131.78) U7601.F14 151.25,131.35 v5(151.65,131.35) 152.51,131.35 152.56,131.4 v5(152.57,131.4) ; U7701.J12 184.17,133.78 v5(184.17,133.78) ; U7000.AB8 164.45,81.25 v5(164.45,81.35) 164.45,81.97 v5(164.42,82) 164.42,82.02 U7000.AB10 ; U7000.AB8 v5(165.08,81.28) 165.11,81.28 U7000.AA8 ; U7000.AB8 164.43,80.63 v5(164.4,80.63) 164.73,80.29 v5(164.73,80.24) 164.73,80.21 165.05,79.89 v5(165.12,79.89) 165.09,79.89 U7000.AB6 164.71,79.55 164.38,79.22 164.38,79.21 ; U7600.T13 162.65,130.16 v5(162.97,130.48) ; v5(177.7,92.49) 177.35,92.84 U7000.D25 177.24,92.85 177.17,92.92 v5(176.69,92.92) 176.64,92.92 176.32,92.6 v5(176.32,92.48) ; v5(177.7,92.49) 177.78,92.56 178.06,92.56 v5(178.2,92.7) ; v5(177.7,92.49) 177.69,92.49 U7000.D24 ; U7700.H1 203.31,111.31 v5(203.28,111.28) 203.28,110.57 v2(203.57,110.29) ; v5(198.18,103.31) U7801.D2 197.54,103.95 v5(197.53,103.96) U7801.D1 v5(197.49,104.65) ; 207.53,119.89 U7700.B13 ; 207.53,119.89 v5(207.54,119.89) ; 207.53,119.89 U7700.B14 207.53,120.54 v5(207.54,120.54) 207.4,120.67 v5(207.4,121.4) ; v5(163.62,129.83) 163.63,129.83 163.95,130.15 U7600.T11 164.27,130.48 v5(164.28,130.48) 164.28,130.48 U7600.R10 ; U7000.BL25 144.98,92.85 v3(145.14,92.69) 145.39,92.69 ; v5(171.44,79.89) 171.42,79.89 v5(171.07,80.24) 171.4,80.57 v5(171.4,80.63) 171.37,80.63 U7000.N8 v5(171.4,81.3) 171.35,81.3 171.02,81.63 v5(171.02,81.66) 171.02,81.74 v5(170.7,82.05) 170.76,82.05 U7000.N10 ; v5(171.44,79.89) 171.1,79.55 U7000.N6 170.77,79.27 v5(170.77,79.15) 171.2,78.72 v5(171.2,78.68) 171.2,78.3 U7000.N4 ; v5(171.44,79.89) 171.75,79.59 U7000.M6 ; v5(176.16,128.86) 176.71,128.86 v5(177,128.58) 177.02,128.58 177.35,128.9 U7701.B1 177.67,128.58 v5(177.67,128.58) 177.68,128.58 U7701.B2 v5(178.32,129.23) ; v5(177.7,84.14) 177.7,84.1 U7000.D12 ; v5(177.7,84.14) 177.39,84.45 U7000.D13 177.2,84.6 176.92,84.6 v5(176.91,84.61) 176.5,84.21 v5(176.34,84.21) 176.19,84.21 U7000.F13 ; v5(177.7,84.14) 177.74,84.14 177.82,84.22 178.25,84.22 v5(178.29,84.26) ; U7700.D13 v5(206.23,119.89) U7700.D14 ; v5(182.86,137.69) U7701.R10 183.18,137.35 v5(182.87,137.04) ; v5(198.91,105.47) 198.94,105.45 v5(198.94,104.81) 199.15,104.59 U7801.F1 v5(198.83,103.96) U7801.F2 ; v5(203.58,100.86) 203.66,100.94 203.66,101.64 U7801.N5 ; v3(148.99,90.39) U7000.BE21 v3(148.28,90.42) 148.22,90.48 148.22,90.5 147.62,91.1 v3(147.6,91.1) ; U7700.D14 205.91,120.21 v5(206.23,120.54) ; U7700.D14 205.65,120.47 v5(205.65,120.6) 205.77,120.72 v5(205.77,121.44) ; v5(160.56,108.92) 160.91,109.27 v5(160.91,109.33) 160.59,109.65 U7000.AH49 160.29,109.91 v5(160.29,110.06) 160.29,110.09 160.52,110.32 v5(160.52,110.58) 160.52,111.02 U7000.AH51 ; v5(208.86,97.21) 208.55,96.91 v5(208.02,96.91) 207.83,96.91 U7801.W12 ; v5(164.92,136.33) U7600.G10 v5(164.27,135.68) ; v5(148.87,129.18) 148.87,129.18 U7601.C10 ; v5(175.59,82) 175.6,82 U7000.F10 v5(175.61,82.69) ; U7000.V52 167.55,112.27 v5(167.52,112.31) ; U7000.G51 v5(175.59,111.39) U7000.F52 v5(175.95,112.4) ; 154.55,108.55 v5(154.6,108.55) ; v5(154.6,108.55) 154.6,108.58 v5(154.24,108.94) 154.22,108.94 v5(153.87,108.58) 154.2,108.25 U7000.AU47 154.3,108.25 v5(154.6,108.55) ; v5(207.93,82.23) U7800.A10 v5(207.28,82.88) ; 160.17,81.99 v5(160.17,82) 159.85,81.68 U7000.AJ9 ; 160.17,81.99 160.53,82.35 U7000.AH10 160.86,82.04 v5(160.89,82.04) 160.89,81.99 v5(160.53,81.63) ; 160.17,81.99 160.53,81.63 v5(160.53,81.63) ; v5(169.48,138.28) 169.8,137.96 U7600.D2 v5(170.12,137.63) 170.45,137.95 U7600.D1 170.86,137.95 170.89,137.98 v5(170.92,137.98) 171.37,137.98 v5(171.62,137.73) ; U7801.H1 200.43,104.31 200.43,105.1 v5(200.46,105.14) 200.84,105.52 v5(200.84,105.54) ; U7600.F14 162.32,136.98 v5(162.32,136.98) U7600.F13 ; U7000.BL22 144.79,90.41 v3(144.79,90.4) 144.81,90.4 145.04,90.63 v3(145.38,90.63) 145.73,90.63 U7000.BJ22 ; v5(207.53,117.94) 207.54,117.93 U7700.A10 207.86,117.6 v5(208.19,117.26) ; U7000.AN4 156.63,77.73 156.61,77.73 v3(156.54,77.67) ; U7000.BJ36 145.6,100.8 145.52,100.8 v7(145.19,101.13) 145.07,101.25 U7000.BL37 ; v5(178.37,75.58) 178.37,75.67 U7000.B1 ; v5(178.37,75.58) 178.51,75.58 178.88,75.21 178.88,74.09 v5(178.36,73.58) ; v5(178.37,75.58) 178.05,75.9 U7000.C1 ; v5(176.3,90.35) 176.62,90.67 v5(176.62,90.75) ; v5(176.3,90.35) 176.3,90.4 U7000.F22 175.95,90.78 v5(175.64,91.09) 175.29,90.74 v5(175.27,90.74) 174.9,90.37 ; v5(176.3,90.35) 176.25,90.35 U7000.F21 ; 160.58,105.45 160.89,105.76 ; 160.89,105.76 160.92,105.76 160.97,105.81 160.99,105.81 161.25,106.07 U7000.AG44 161.34,106.15 161.56,106.37 161.56,106.46 U7000.AF45 162.25,107.15 v5(162.3,107.15) ; 160.89,105.76 160.89,105.83 v5(160.57,106.15) ; v5(182.81,57.97) U7901.C5 v5(182.16,57.97) ; v5(163.38,52.12) U7900.G10 v5(162.73,51.47) ; v5(165.11,109.99) 164.77,109.65 U7000.AB49 ; v5(165.11,109.99) 165.45,109.65 U7000.AA49 ; U7000.AP47 156.65,108.55 v5(156.7,108.55) 156.36,108.89 v5(156.36,108.94) ; v5(175.6,105.85) 175.3,105.55 175.3,105.48 175.28,105.46 v5(175.26,105.46) 175.26,105.48 174.94,105.8 v5(174.88,105.8) 174.88,105.78 U7000.H43 ; U7900.K1 157.18,53.72 156.52,53.72 v5(156.32,53.52) ; v5(184.11,57.32) U7901.D2 184.76,57.97 v5(184.76,57.97) 184.76,57.97 U7901.D1 185.43,57.99 v5(185.53,57.99) ; v5(141.46,131.25) 141.47,131.26 v5(142.09,131.26) 142.28,131.26 142.47,131.45 U7601.F1 v5(143.02,131.13) U7601.F2 ; v5(168.75,109.1) 168.75,109.24 168.9,109.39 168.9,109.6 U7000.T49 169,109.65 v5(169.32,109.98) U7000.R49 ; U7700.E5 205.28,114.38 205.28,114.8 v5(205.37,114.89) ; v5(180.01,97.73) 179.99,97.75 U7000.A32 ; v5(175.52,107.85) 175.18,107.51 v5(175.18,107.4) ; v5(175.52,107.85) 175.25,108.12 U7000.G47 ; U7700.M1 200.71,111.48 v5(200.54,111.31) ; v5(180.4,135.89) 180.23,136.05 U7701.N5 ; U7601.T14 151.46,138.26 v5(151.5,138.26) 151.52,138.25 v5(152.52,138.25) ; v5(144.97,129.83) U7601.C5 145.29,129.51 145.62,129.83 v5(145.62,129.83) ; v5(179.57,48.86) U7901.U10 v5(178.91,48.87) ; v5(170.84,129.89) 170.71,129.89 U7600.T1 v5(170.12,130.48) U7600.T2 ; v5(156.51,57.97) 156.88,57.97 U7900.T1 v5(157.53,57.32) U7900.T2 ; v5(163.38,56.02) U7900.N10 ; v5(156.38,107.55) 156.32,107.55 v5(155.98,107.21) ; v5(150.17,136.33) U7601.P13 150.82,136.98 v5(150.82,136.98) 151.14,136.66 U7601.P14 ; v5(166.83,138.93) 167.52,138.93 U7600.C5 168.17,138.93 v5(168.17,138.93) ; v5(160.13,59.92) U7900.W5 v5(159.48,59.92) ; v5(184.11,54.72) 183.94,54.55 183.94,54.55 U7901.J3 ; U7000.K2 v5(173.15,77.31) 173.15,77.41 173.46,77.72 v5(173.46,77.72) 173.46,77.84 U7000.K4 ; v5(184.11,48.87) 184.33,48.65 U7901.V2 v5(184.76,48.22) U7901.V1 v5(185.44,48.2) ; U7800.V13 v5(196.23,84.83) U7800.V14 196.22,85.49 v5(196.22,85.53) ; v5(198.18,84.18) U7800.T13 197.96,84.62 197.96,85.05 U7800.T14 v5(197.53,85.48) ; v5(176.12,137.35) 176.29,137.35 v5(176.87,136.77) 176.94,136.7 U7701.P1 ; v5(149.44,112.3) 149.35,112.21 U7000.BD52 ; 173.47,91.07 U7000.K22 ; 173.47,91.07 173.8,90.74 v5(173.87,90.74) ; 173.47,91.07 v5(173.47,91.08) ; v5(158.47,106.16) 158.62,106.01 158.69,106.01 158.85,105.85 U7000.AL43 ; v5(199.05,95.38) 199.05,95.73 U7801.F14 v5(199.48,96.16) U7801.F13 ; U7801.M1 203.05,104.73 v5(203.16,104.83) ; v5(154.25,110.59) 154.11,110.45 v5(154.11,110.1) 154.11,109.78 154.12,109.78 U7000.AU49 ; v5(164.27,136.98) U7600.E10 v5(164.94,137.64) ; v5(177.02,131.18) 176.24,131.18 v5(176.16,131.26) ; U7700.D1 205.76,111.91 v5(205.58,112.09) U7700.D2 v5(206.23,112.74) ; U7800.K14 201.75,85.87 v5(201.29,86.33) ; U7701.T13 v5(185.47,138.33) U7701.T14 ; v5(197.79,118.59) 197.79,118.58 U7700.T11 198.43,117.94 v5(198.44,117.94) 198.44,117.93 U7700.R10 ; v5(164.42,107.17) 164.42,107.23 v5(164.76,107.57) ; U7000.J38 173.8,101.95 v5(173.45,101.6) 173.53,101.6 173.86,101.27 v5(173.86,101.26) ; v5(198.83,101.36) 198.5,101.68 U7801.E5 ; U7801.P2 v5(204.03,103.31) ; v5(205.34,82.22) U7800.E10 v5(204.68,82.88) ; 174.2,95.27 174.2,95.25 173.91,94.96 v5(173.86,94.96) ; v5(170.94,136.65) U7600.F1 ; v5(160.81,48.87) 160.13,48.87 U7900.C5 159.48,48.87 v5(159.48,48.87) ; v5(178.26,48.22) U7901.W12 177.63,47.59 v5(177.63,47.42) ; v5(164.3,127.85) 164.6,128.15 U7600.W10 ; U7600.D11 v5(164.28,138.28) U7600.C10 v5(164.95,138.96) ; v5(206.63,103.31) 206.63,103.31 206.95,103.63 U7801.V2 v5(207.28,103.96) U7801.V1 207.09,104.42 207.1,104.42 v5(207.3,104.63) ; v5(158.11,107.19) 158.19,107.19 158.48,107.48 v5(158.48,107.55) 158.68,107.75 158.71,107.75 158.85,107.89 v5(158.85,107.9) ; v5(166.49,81.99) U7000.Y9 ; v5(166.49,81.99) U7000.W10 ; v5(160.55,78.87) 160.48,78.87 v5(160.16,79.19) 160.2,79.19 U7000.AH6 160.89,79.89 v5(160.92,79.89) 160.87,79.89 v5(160.53,80.24) ; v5(208.25,114.77) 208.25,114.75 U7700.A5 ; v5(171.62,140.13) 171.35,140.13 v5(170.8,139.58) 170.77,139.58 U7600.B1 v5(170.12,139.58) 169.8,139.26 U7600.B2 ; v5(182.09,47.36) 182.09,47.48 182.13,47.51 182.13,47.54 U7901.W5 ; v5(203.77,94.16) 203.71,94.22 v5(203.71,94.8) 203.05,95.46 U7801.M14 ; U7000.BE24 148.26,92.54 147.63,92.54 v3(147.6,92.5) ; v5(182.16,59.27) 182.16,59.27 U7901.A5 ; U7000.H10 174.86,82.66 v5(174.86,82.71) ; v5(178.24,95.13) 178.57,95.13 U7000.B28 ; v5(178.24,95.13) 178.24,95.46 U7000.C29 ; v3(146.77,96.83) 146.79,96.86 147.06,96.86 U7000.BG31 ; U7600.M1 170.82,132.75 170.91,132.67 v5(170.91,132.63) ; U7700.R5 199.08,114.69 v5(199.09,114.69) ; U7900.A5 159.8,47.56 v5(160.07,47.3) ; U7601.M14 v5(151.47,135.68) ; v5(160.13,58.62) U7900.U5 159.48,57.97 v5(159.48,57.97) ; U7700.L3 v5(201.68,113.39) U7700.K3 ; v3(147.66,101.53) 147.53,101.53 U7000.BG37 ; v5(165.06,108.6) 164.75,108.28 U7000.AB47 ; U7601.T11 149.52,138.28 v5(149.52,138.28) ; v5(176.64,80.25) 176.64,80.3 v5(176.29,80.64) ; v5(196.91,79.66) 196.9,79.65 196.9,79.61 U7800.U5 v5(197.53,78.98) ; v5(156.85,48.22) 156.88,48.22 157.08,48.42 U7900.B1 v5(157.53,48.22) U7900.B2 ; U7700.K14 201.97,120.25 201.97,121.08 202.15,121.26 v5(202.15,121.34) ; U7000.BJ33 145.58,98.72 v3(145.27,99.03) 145.15,99.15 U7000.BL34 ; U7901.R5 182.36,50.37 182.36,50.37 v5(182.16,50.17) ; U7000.F17 175.98,87.25 v5(176.35,86.88) 176.28,86.88 U7000.F16 ; 157.53,59.27 U7900.V1 156.85,59.3 v5(156.48,59.3) ; 157.53,59.27 U7900.V2 ; 157.53,59.27 v5(157.53,59.27) ; U7801.J3 v5(200.78,103.31) ; v3(151.8,79.9) 151.81,79.9 152.45,80.53 152.45,80.55 v3(152.48,80.58) ; v5(173.17,78.85) 173.2,78.85 v5(173.55,79.2) 173.2,79.55 U7000.K6 173.11,79.55 v5(172.78,79.88) 173.15,80.26 v5(173.15,80.27) ; v5(164.24,140.32) 164.24,140.26 U7600.A10 ; v5(205.98,94.64) v5(205.98,95.51) U7801.T14 v5(205.98,96.16) U7801.T13 ; U7901.L3 v5(183.46,53.42) 183.5,53.46 U7901.K3 ; U7000.AL47 158.52,108.25 158.85,107.92 v5(158.85,107.9) ; v5(177.71,110.71) U7000.C51 178.16,111.16 178.16,111.64 U7000.C52 ; v5(199.48,102.01) U7801.G5 199.8,101.68 v5(200.13,101.36) ; U7000.W43 166.85,105.53 167.13,105.81 v5(167.13,105.89) 166.96,106.05 166.96,106.31 v5(167.19,106.54) 166.88,106.85 U7000.W45 v5(166.5,107.2) 166.5,107.21 v5(166.86,107.57) ; v5(178.36,98.89) 178.49,98.89 U7000.B34 ; v5(178.36,98.89) 178.36,98.76 U7000.C33 ; v5(166.04,56.69) 166,56.69 U7900.P14 165.33,56.67 v5(165.33,56.67) U7900.P13 ; U7000.A29 179.87,95.65 v5(179.99,95.53) ; v5(173.59,81.13) 173.33,81.13 U7000.K8 v5(172.82,81.28) 172.91,81.28 v5(173.24,81.61) ; v5(161.67,132.43) U7600.M14 ; v5(165.98,55.37) U7900.M14 ; U7800.F14 v5(204.68,84.83) U7800.F13 ; U7900.N5 159.51,55.4 159.5,55.4 v5(159.48,55.37) ; v5(198.18,96.81) U7801.D13 197.74,96.37 197.74,95.95 U7801.D14 197.84,95.82 v5(197.84,95.38) ; U7600.R5 v5(167.51,131.14) ; U7000.T45 168.63,107.17 v5(168.61,107.17) 168.96,107.52 v5(168.96,107.55) ; v5(205.98,77.68) U7800.D2 v5(205.33,77.03) U7800.D1 205.65,76.29 205.68,76.27 v5(205.68,76.19) v5(205.68,75.59) ; U7000.D40 177.47,103.47 v5(177.79,103.47) 177.93,103.47 178.21,103.19 v5(178.21,103.18) 178.38,103.35 U7000.B40 ; U7000.K19 173.38,88.88 173.38,88.91 v5(173.46,88.99) 173.79,88.66 v5(173.85,88.66) ; v5(202.33,113.39) 202.33,113.39 ; 202.33,113.39 U7700.K3 ; 202.33,113.39 202.37,113.35 202.38,113.35 U7700.J3 202.33,112.74 v5(202.33,112.74) 202.33,112.74 U7700.K3 ; v5(159.48,52.12) 159.48,52.12 U7900.G5 159.88,51.87 160.37,51.87 160.73,51.51 v5(160.73,51.45) ; v5(168.58,81.98) U7000.T10 ; v5(168.58,81.98) U7000.U9 ; v5(168.58,81.98) 168.58,81.98 168.95,81.61 v5(168.95,81.61) ; 174.9,90.37 174.9,90.4 U7000.H22 ; 174.9,90.37 v5(174.9,90.35) ; v5(164.72,106.15) 164.76,106.15 v5(165.1,105.81) ; U7000.AP6 v3(156.01,79.89) ; U7000.BJ40 145.15,103.35 v7(145.07,103.27) 144.99,103.35 U7000.BL40 ; U7000.J49 v5(173.46,110.04) 173.42,110 173.42,109.92 U7000.K49 173.15,109.49 172.95,109.29 v5(172.95,109.15) 172.96,109.15 v5(173.4,108.71) 173.4,108.5 U7000.K47 ; U7700.W5 v5(195.83,114.69) ; U7900.F13 v5(165.33,50.82) 165.65,51.15 U7900.F14 ; v5(158.85,107.9) 159.15,108.21 U7000.AK47 ; v5(183.53,127.93) 183.2,128.25 U7701.A10 ; U7800.M14 v5(200.13,85.48) ; U7901.M1 185.53,52.45 v5(185.63,52.34) ; v5(176.63,88.64) 176.61,88.64 v5(176.26,88.29) 175.95,88.6 U7000.F19 ; U7000.B31 v5(178.28,97.05) 178.2,97.05 177.86,96.7 v5(177.7,96.7) ; v5(167.02,110.54) 167.02,110.39 167.19,110.21 v5(167.19,109.99) U7000.W49 166.85,109.5 166.68,109.33 v5(166.68,109.13) 167.19,108.62 v5(167.19,108.59) U7000.W47 ; v5(185.78,53.82) 185.71,53.75 U7901.K1 ; v5(148.2,137.65) U7601.R10 v5(148.22,136.98) ; v5(177.7,96.7) 177.69,96.7 U7000.D31 177.26,97.14 176.72,97.14 v5(176.66,97.08) 176.66,97.06 v5(176.28,96.68) 175.95,97.01 U7000.F31 ; v5(177.7,96.7) 177.7,96.7 U7000.D30 ; U7000.BC37 149.69,101.61 v3(149.69,101.61) 149.69,101.61 U7000.BD38 ; U7801.B13 v5(196.23,96.16) 196.23,96.15 U7801.B14 196.22,95.5 196.22,95.5 v5(196.19,95.47) ; v5(152.68,128.61) 152.57,128.49 v5(151.66,128.49) 151.59,128.49 151.22,128.85 U7601.B14 150.82,128.53 v5(150.82,128.53) U7601.B13 ; U7701.K1 176.73,134.1 v5(176.66,134.03) ; U7000.AE49 162.47,109.83 v5(162.47,110.09) 162.47,110.4 v5(162.66,110.59) ; U7000.J52 173.85,112.23 v5(173.78,112.3) 174.07,112.6 v5(174.07,112.73) ; U7000.AR9 v3(156,82) U7000.AP10 ; U7900.L12 164.47,54.51 v5(164.68,54.72) ; v5(179.12,76.37) 179.08,76.37 U7000.B1 ; v5(179.12,76.38) U7000.B2 ; v5(179.12,76.38) 179.12,76.42 U7000.A2 ; U7900.D13 v5(165.33,49.52) 165.65,49.85 U7900.D14 165.88,50.08 v5(166.15,50.08) 166.94,50.08 v5(167.02,50) v5(167.02,50.8) ; v5(141.83,132.92) 142.09,132.66 142.12,132.64 142.58,132.64 U7601.H1 ; v5(148.4,141.16) 148.34,141.1 v5(148.34,140.41) ; 164.38,79.21 164.72,78.87 v5(164.75,78.87) ; 164.38,79.21 v5(164.37,79.21) ; v5(179.92,110.69) 179.82,110.69 179.48,110.35 U7000.A50 ; v5(176.65,82.33) 177.01,81.97 v5(177.02,81.97) 177.02,82.02 U7000.D10 177.69,82.69 v5(177.69,82.71) 178.02,82.38 178.72,82.38 U7000.B10 ; U7600.U10 164.6,129.5 v5(164.28,129.18) ; v5(143.67,136.33) 143.35,136.65 U7601.P2 v5(143.02,136.98) U7601.P1 142.26,136.65 v5(142.23,136.68) 141.61,137.3 v5(141.47,137.3) ; U7000.AE6 162.7,79.55 v5(163,79.85) 162.65,80.2 v5(162.65,80.23) ; U7901.A10 179.04,59.79 v5(179.04,60.04) ; v5(161.95,75.49) 161.95,75.62 U7000.AF1 ; U7901.P2 v5(184.11,51.47) ; v5(150.17,137.63) U7601.T13 v5(150.82,138.28) ; v5(178.32,136.38) U7701.P2 ; U7801.N10 v5(204.03,98.11) ; v5(163.36,59.94) 163.36,59.9 U7900.W10 ; v5(141.48,127.87) 141.49,127.88 141.49,128.54 v5(141.48,128.54) 141.49,128.54 141.51,128.53 v5(142.22,128.53) 142.32,128.53 142.65,128.85 ; v5(168.17,135.68) 167.85,136 U7600.G5 ; v5(179.59,50.85) U7901.R10 v5(179.6,50.13) ; v3(149,96.7) 148.8,96.5 U7000.BE30 ; U7900.M1 157.2,55.05 156.92,55.05 v5(156.75,55.22) ; U7000.C52 177.73,112.07 v5(177.73,112.21) ; U7000.AP2 156.68,77.08 v3(156.68,77.12) 156.54,77.26 v3(156.54,77.67) ; v5(173.46,86.89) 173.38,86.81 173.38,86.78 U7000.K16 ; v5(180.01,93.6) 179.96,93.55 U7000.A26 ; v5(150.38,110.04) 150.38,110.02 U7000.BB49 v3(150.38,109.28) ; v3(144.94,97.01) 144.98,97.05 U7000.BJ31 ; U7000.D43 177.46,105.56 v5(177.83,105.56) 177.98,105.56 178.23,105.31 v5(178.23,105.22) 178.46,105.45 U7000.B43 ; v5(182.16,56.67) 182.16,56.67 182.48,57 U7901.E5 ; v3(146.9,79.2) U7000.BH5 ; U7901.H1 185.41,55.37 185.77,55.37 v5(185.81,55.33) ; v5(196.38,111.33) U7700.V1 v5(196.48,112.09) U7700.V2 ; U7700.M14 v5(200.38,120.54) ; v5(167.51,129.17) U7600.U5 v5(168.18,129.83) ; v5(151.66,130.14) 151.16,130.14 U7601.D14 151.03,130.04 150.61,130.04 U7601.D13 150.2,130.44 150.17,130.47 v5(150.17,130.48) ; v5(169.05,110.55) 168.95,110.65 U7000.T51 ; v5(152.15,111.72) 152.15,111.82 152.45,112.13 v5(152.45,112.17) 152.85,111.78 U7000.AW52 ; v5(179.74,79.98) 179.42,80.3 178.8,80.3 U7000.B7 v5(178.4,79.9) 178.38,79.9 v5(178.02,80.25) 178.02,80.25 v5(177.67,80.61) 177.35,80.29 U7000.D7 ; 185.8,128.9 186.13,128.57 186.13,128.57 v5(186.16,128.54) ; 185.8,128.9 U7701.B14 ; 185.8,128.9 v5(185.47,128.58) U7701.B13 ; U7901.G10 178.91,56.02 v5(178.91,56.02) ; U7800.K3 v5(201.43,78.33) 201.43,78.33 U7800.L3 ; U7800.K3 v5(202.08,78.33) U7800.J3 v5(202.08,77.68) U7800.K3 ; v5(176.66,103.36) 176.3,103 v5(176.28,103) 175.95,103.32 U7000.F40 175.77,103.53 175.77,103.56 v5(175.59,103.74) 175.24,103.39 v5(175.24,103.37) ; v5(185.41,56.67) U7901.F1 v5(184.76,56.67) U7901.F2 ; U7700.T2 198.43,112.09 v5(198.43,112.09) U7700.T1 197.94,111.59 197.94,111.38 v5(197.9,111.34) ; v5(177.61,48.87) 177.59,48.85 U7901.V13 177.28,48.55 176.96,48.22 v5(176.96,48.22) 176.96,48.22 U7901.V14 176.63,48.55 v5(176.31,48.22) ; v5(204.28,117.29) U7700.G10 v5(203.63,117.94) ; v5(175.27,101.26) 175.27,101.28 v5(175.62,101.63) 175.3,101.95 U7000.G38 175.22,101.95 174.91,101.64 v5(174.91,101.62) ; v5(160.89,77.81) 160.89,77.77 v5(160.42,77.3) 160.46,77.26 160.46,76.84 U7000.AH2 160.56,76.75 v5(160.91,77.1) 161.25,77.44 U7000.AG3 v5(160.89,77.81) ; v5(160.89,77.81) U7000.AH4 ; U7600.K1 170.52,134.12 171.16,134.12 171.31,134.27 v5(171.35,134.27) ; v5(150.19,140.34) 150.19,140.23 149.87,139.9 U7601.W12 149.52,139.58 v5(149.52,139.58) ; U7000.BL43 v3(144.94,105.45) ; v3(149.08,84.16) 149.48,84.56 149.94,84.56 U7000.BC13 ; U7701.W10 v5(182.85,140.3) ; v5(207.94,102.02) U7801.W5 207.99,101.3 v5(208.01,101.3) ; v5(200.38,114.04) 200.38,114.04 U7700.N5 ; U7700.P13 v5(199.08,119.89) U7700.P14 v5(199.08,120.54) ; U7000.K25 173.49,92.51 v5(173.49,92.49) 173.53,92.53 174.2,92.53 v5(174.23,92.5) 174.23,92.53 U7000.H25 174.55,92.88 v5(174.88,93.21) 174.9,93.21 v5(175.26,92.85) ; v5(179.55,47.46) 179.24,47.77 U7901.W10 ; v5(204.27,115.27) 203.88,114.89 203.88,114.44 U7700.G5 203.63,114.04 v5(203.63,114.04) ; v5(162.72,50.16) 163.05,50.5 U7900.E10 v5(163.38,50.82) ; U7701.N10 183.2,136.05 v5(183.52,136.38) ; U7000.AH8 160.82,81.22 160.85,81.22 v5(160.89,81.26) 160.89,81.28 v5(160.53,81.63) ; U7000.AP4 156.54,77.96 v3(156.54,77.67) ; v5(202.27,110.86) 202.06,111.07 202.06,111.71 U7700.K1 ; v5(160.34,130.95) 160.52,131.13 v5(161.67,131.13) U7600.P14 162,131.45 v5(162.32,131.13) U7600.P13 ; v5(148.21,138.94) U7601.U10 v5(148.87,138.93) ; v5(160.35,128.57) 160.37,128.56 v5(161.62,128.56) 161.7,128.56 U7600.V14 162,128.85 v5(162.32,128.53) U7600.V13 ; v5(168.61,80.61) U7000.T8 ; v5(168.61,80.61) U7000.U7 ; v5(168.61,80.61) 168.96,80.26 v5(168.96,80.25) 169.32,79.89 v5(169.32,79.88) 169.28,79.88 U7000.T6 168.65,79.25 v5(168.6,79.25) 168.95,78.89 v5(168.95,78.87) ; v5(206.64,80.25) 206.59,80.21 206.59,79.6 U7800.C5 v5(206.63,78.98) ; U7800.V1 v5(196.19,76.34) ; U7800.V1 v5(196.88,77.03) U7800.V2 v5(196.23,77.03) U7800.V1 ; U7000.BM2 143.42,76.42 143.42,76.26 v3(143.14,75.98) ; v5(208.02,79.58) 207.76,79.31 U7800.A5 ; v5(196.47,120.55) U7700.V14 v5(196.48,119.89) U7700.V13 ; U7601.J3 v5(143.67,133.08) ; v5(151.79,108.61) U7000.AY47 ; U7000.AY47 v5(152.49,107.91) U7000.AW46 U7000.AV45 ; U7000.AY47 v5(152.47,108.57) 152.04,109.01 152.04,109.54 U7000.AY49 152.15,109.69 v5(152.47,110) 152.34,110.12 v5(151.87,110.12) ; U7801.U10 v5(206.63,98.11) ; U7600.K14 161.96,134.02 160.42,134.02 v5(160.29,133.89) ; v5(161.67,129.83) U7600.T14 ; U7600.F2 169.48,136.98 v5(169.48,136.98) ; v5(178.2,90.6) 177.86,90.94 v5(177.77,90.94) 177.75,90.96 177.57,90.96 U7000.D22 ; v5(179.12,111.43) 179.45,111.11 U7000.A51 179.81,111.41 v5(179.81,111.53) ; U7700.F13 v5(204.93,119.89) U7700.F14 ; v5(206.78,114.78) 206.78,114.63 206.56,114.41 U7700.C5 206.88,114.04 v5(206.88,114.04) ; v5(176.97,111.38) 176.65,111.06 U7000.E51 v5(176.3,110.7) ; U7900.F2 v5(157.53,50.82) 157.21,51.15 U7900.F1 156.81,51.15 v5(156.74,51.22) ; U7700.U10 v5(197.13,117.94) ; v3(144.09,78.49) U7000.BL5 ; U7600.A5 167.85,140.35 v5(167.59,140.6) ; v5(176.29,80.64) 175.95,80.3 U7000.F7 v5(175.6,79.9) ; v5(176.29,80.64) 176.6,80.95 U7000.E8 ; U7000.BL19 144.56,88.65 v3(144.85,88.36) 144.89,88.36 144.96,88.45 v3(145.41,88.45) 145.61,88.65 U7000.BJ19 ; v5(201.68,104.97) 201.68,104.97 201.75,104.9 U7801.K1 ; v5(166.04,57.99) 166,57.99 U7900.T14 165.55,57.54 165.11,57.54 U7900.T13 165,57.65 v5(164.68,57.32) ; v5(176.65,101.27) 176.62,101.27 176.26,100.91 v5(176.26,100.91) 175.95,101.22 U7000.F37 ; U7900.D11 163.7,49.85 v5(163.38,49.52) U7900.C10 v5(162.71,48.85) ; U7000.G49 174.96,109.94 v5(174.96,110.05) 174.96,110.09 v5(175.54,110.67) ; v5(177.61,50.17) U7901.T13 v5(176.96,49.52) U7901.T14 v5(176.31,49.52) ; U7600.K3 v5(168.83,133.73) 168.83,133.73 U7600.L3 ; U7600.K3 v5(168.82,134.38) U7600.J3 169.47,134.38 v5(169.48,134.38) 169.15,134.05 U7600.K3 ; v5(180.27,129.88) 180.27,129.88 U7701.C5 v5(179.62,129.88) ; U7000.BE39 v3(149,103) ; v5(204.03,82.23) U7800.G10 v5(203.38,82.88) ; U7601.D2 143.02,129.83 v5(143.02,129.83) 143.02,129.83 U7601.D1 v5(142.35,129.81) ; v5(182.03,51.94) 182.18,51.8 U7901.N5 ; v5(176.9,86.38) 177.18,86.38 U7000.D16 177.35,86.57 v5(177.7,86.92) ; v5(197.52,76.38) U7800.T1 v5(198.18,77.03) 197.85,77.36 U7800.T2 ; v5(186.28,130.19) 186.27,130.2 U7701.D14 185.68,130.09 185.27,130.09 U7701.D13 v5(184.82,130.53) ; v5(176.8,135.5) 176.54,135.5 176.36,135.68 v5(176.07,135.68) ; v5(141.47,138.1) 142.21,138.1 v5(142.25,138.06) 142.36,137.95 U7601.T1 142.7,137.95 143.02,138.28 v5(143.02,138.28) U7601.T2 143.35,137.95 v5(143.67,137.63) ; U7801.T2 205.33,103.31 v5(205.33,103.31) ; U7801.T2 205.65,103.63 ; v5(144.97,131.13) U7601.E5 ; U7800.H1 203.05,76.25 v5(203.03,76.22) ; U7800.E5 205.27,79.58 205.31,79.61 v5(205.31,79.66) ; v5(182.86,138.99) U7701.U10 183.2,138.66 v5(183.52,138.98) ; v5(198.83,77.68) U7800.P2 v5(199.48,77.03) U7800.P1 198.91,76.46 v5(198.91,76.24) ; v5(204.03,96.81) U7801.P13 ; v5(197.53,101.36) 197.2,101.68 U7801.C5 v5(197.53,102.01) ; U7700.F1 v5(204.61,111.28) ; U7800.N5 v5(200.13,78.98) ; v5(195.82,117.95) 195.82,117.95 U7700.W10 ; v5(167.02,48.4) 166.85,48.22 v5(165.98,48.22) U7900.B14 v5(165.33,48.22) U7900.B13 ; v5(176.24,132.69) 176.28,132.73 v5(176.87,132.73) 177.28,132.73 U7701.H1 ; v5(196.23,78.98) U7800.W5 v5(195.58,79.63) ; U7000.AH45 160.5,106.85 v5(160.2,107.15) 160.26,107.15 160.54,107.43 v5(160.54,107.55) v5(160.9,107.91) 160.56,108.25 U7000.AH47 ; v5(169.98,112.17) 169.65,111.84 U7000.R52 ; v5(171.76,114.51) 171.69,114.44 v5(169.99,114.44) ; v5(204.93,112.74) U7700.F2 ; U7000.AR4 U7000.AT4 ; v5(203.38,78.98) U7800.G5 ; U7000.AY2 152.15,77.06 152.18,77.09 v3(152.18,77.3) ; U7600.J12 163.3,134.7 163.47,134.54 v5(163.62,134.38) ; v5(148.86,127.87) 148.86,127.89 U7601.A10 ; v5(176.13,57.66) 176.62,57.66 U7901.D14 176.75,57.76 177.17,57.76 U7901.D13 v5(177.61,57.32) ; v5(182.81,56.02) 182.81,56.02 U7901.G5 v5(182.16,55.37) ; v5(198.98,111.21) 198.98,111.33 U7700.P1 199.41,111.76 v5(199.73,112.09) U7700.P2 v5(199.08,112.74) ; v5(187.21,140.03) 186.72,139.55 v5(186.32,139.55) 186.04,139.55 U7701.V14 185.47,139.63 v5(185.47,139.63) 185.15,139.3 U7701.V13 v5(184.82,138.98) ; v5(176.29,79.21) U7000.E5 176.34,78.54 v5(176.34,78.49) 176.34,78.46 U7000.E4 176.97,77.83 v5(177.02,77.83) 177.34,78.15 U7000.D4 v5(177.67,78.47) U7000.C5 ; U7801.K3 201.75,102.98 v5(202.08,102.66) 202.4,102.98 U7801.L3 ; U7700.B2 v5(207.53,112.09) 207.53,112.09 U7700.B1 207.53,111.44 v5(207.53,111.41) 207.53,111.12 v2(208.37,110.29) ; U7701.F13 v5(185.47,131.83) U7701.F14 185.9,131.4 v5(186.29,131.4) ; v5(178.91,58.62) 178.91,58.62 U7901.C10 ; U7000.BL16 145.24,86.55 v3(145.37,86.42) ; v5(169.47,131.13) 169.8,131.45 U7600.P2 v5(170.12,131.78) 170.45,131.45 U7600.P1 v5(170.77,131.13) ; U7000.J12 v5(173.49,84.11) U7000.K13 173.47,84.77 v5(173.47,84.8) 173.49,84.8 173.63,84.66 173.81,84.66 173.92,84.56 v5(173.92,84.55) 174.45,84.55 U7000.H13 v5(174.9,84.8) 174.91,84.8 174.94,84.8 v5(175.28,84.46) ; v5(178.26,49.52) 178.26,49.52 U7901.T11 ; v5(183.52,131.83) 183.52,131.83 U7701.G10 ; v5(178.32,138.98) U7701.V2 v5(177.67,139.63) U7701.V1 v5(176.9,139.75) v5(176.12,139.75) ; v5(204.65,98.78) U7801.R10 v5(205.37,98.8) ; U7000.T4 169.18,77.92 v5(169.18,77.71) 168.8,77.33 v5(168.8,77.3) ; v5(196.23,103.96) 196.23,103.96 U7801.B1 196.23,104.61 v5(196.23,104.63) 196.51,104.92 v5(196.51,105.47) ; v5(163.38,58.62) U7900.U10 ; v5(176.28,59.31) 176.31,59.28 176.31,59.28 U7901.B14 v5(176.96,59.27) 176.97,59.27 U7901.B13 ; v5(180.27,128.58) 180.27,128.58 U7701.A5 ; 162.29,81.29 v5(162.66,81.66) ; 162.29,81.29 162.63,80.95 U7000.AE8 ; 162.29,81.29 v5(162.29,81.29) ; U7701.D2 177.68,129.88 177.68,129.88 v5(177.67,129.88) 177.67,129.88 U7701.D1 176.97,129.82 v5(176.95,129.82) ; U7700.L12 v5(201.03,119.24) ; v5(180.39,137.8) U7701.R5 ; U7000.G4 175.25,78.02 175.47,77.8 v5(175.47,77.71) 175.08,77.32 v5(175.04,77.32) ; v3(147.64,86.88) v3(148.27,86.25) ; v5(158.95,71.7) 158.68,71.42 158.68,70.88 158.97,70.59 v5(159.16,70.59) ; U7000.AL8 158.76,80.64 v5(158.79,80.64) 158.79,80.59 v5(158.46,80.26) 158.11,79.91 158.09,79.91 ; v5(149.52,129.83) 149.52,129.83 U7601.D11 148.87,130.48 v5(148.87,130.48) 148.87,130.48 U7601.E10 ; U7000.B37 178.44,101.25 v5(178.22,101.03) 177.89,101.36 v5(177.8,101.36) 177.46,101.36 U7000.D37 ; U7900.V13 v5(165.33,59.27) U7900.V14 165.69,58.95 v5(166.03,59.28) ; U7701.P14 185.48,137.03 v5(185.47,137.03) 185.42,136.97 185.42,136.97 U7701.P13 185.15,136.7 v5(184.82,136.37) ; 205.52,86.39 205.41,86.28 v5(204.68,86.28) ; 205.52,86.39 v5(205.52,86.4) ; 205.52,86.39 v5(205.52,85.69) ; v5(164.63,77.29) 164.63,77.36 v5(164.98,77.71) 164.98,77.92 U7000.AB4 ; v5(161.53,138.14) 161.81,138.14 U7600.D14 162.32,138.28 v5(162.32,138.28) 162.33,138.28 U7600.D13 ; U7601.B1 142.65,128.85 ; 142.65,128.85 142.31,129.19 v5(142.25,129.19) ; U7801.P14 v5(204.68,95.51) ; v5(156.33,106.16) 156.35,106.16 v5(156.7,105.81) 156.35,105.46 U7000.AP43 ; v5(185.55,51.12) 185.52,51.15 U7901.P1 ; v5(145.62,132.43) 145.62,132.43 U7601.G5 v5(144.97,131.78) ; U7000.BC51 150.05,111.26 v5(150.29,111.5) ; U7000.AE47 162.67,108.25 v5(163.02,108.6) 162.67,108.95 v5(162.62,108.95) ; v5(176.12,138.15) 176.82,138.15 v5(176.88,138.09) 176.97,138 U7701.T1 177.67,138.32 v5(177.67,138.33) 177.68,138.31 177.69,138.31 178,138 U7701.T2 v5(178.32,137.68) ; v5(158.18,50.17) U7900.D2 v5(157.53,50.17) U7900.D1 156.73,49.85 v5(156.72,49.84) ; v5(207.93,98.77) 207.93,98.76 U7801.W10 ; v5(185.54,59.27) 185.41,59.27 U7901.B1 v5(184.76,59.27) U7901.B2 v5(184.11,58.62) ; v3(149.01,100.91) U7000.BE36 ; v5(207.28,96.16) U7801.V13 v5(206.63,96.81) ; U7701.L3 178.97,134.43 v5(178.97,134.43) 178.96,134.42 178.96,134.42 178.93,134.39 178.93,134.38 U7701.K3 ; v5(149.52,133.73) 149.52,133.73 U7601.J12 ; v5(164.03,57.97) U7900.T11 163.38,57.32 v5(163.38,57.32) U7900.R10 ; U7000.H19 174.87,88.97 v5(174.87,89) 175.21,88.66 v5(175.27,88.66) ; v5(171.62,135.33) 170.98,135.33 v5(170.96,135.35) U7600.H1 ; v5(178.26,57.97) U7901.D11 178.87,57.36 178.87,57.36 178.9,57.33 v5(178.91,57.32) U7901.E10 ; v5(141.47,139.7) 142.25,139.7 v5(142.34,139.6) U7601.V1 v5(143.02,139.58) U7601.V2 143.35,139.25 v5(143.67,138.93) ; U7701.L12 v5(184.17,134.43) ; U7800.F1 v5(204.35,76.24) ; U7000.D19 177.56,88.86 177.75,88.86 v5(177.77,88.84) 177.86,88.84 v5(178.2,88.5) ; U7901.P14 176.33,50.84 v5(176.23,50.84) ; U7801.A10 195.88,98.43 v5(195.55,98.11) ; v5(200.78,84.18) U7800.L12 ; v3(148.28,88.32) v3(147.67,88.92) ; v5(204.93,117.94) U7700.E10 205.57,117.3 v5(205.57,117.25) ; v5(178.26,54.07) U7901.J12 ; v5(187.18,138.3) v5(186.18,138.3) ; v5(142.15,135.45) 142.02,135.58 v5(141.44,135.58) ; v5(205.45,101.24) 205.41,101.27 U7801.R5 204.68,102.01 v5(204.68,102.01) ; U7000.BG42 v3(146.85,105.15) ; U7600.N5 v5(168.17,132.43) ; U7801.T11 v5(205.98,97.46) ; U7701.E5 v5(179.62,131.18) ; v5(166.73,77.29) 166.73,77.33 167.08,77.68 v5(167.08,77.71) 167.08,77.92 U7000.W4 ; U7000.BL2 v3(143.96,76.26) ; U7601.W5 145.68,140.29 145.68,140.44 v5(145.66,140.46) ; U7601.L12 149.84,134.7 v5(149.52,134.38) ; U7000.BH2 v3(146.2,76.4) ; v5(178.91,51.47) U7901.N10 ; v5(166.83,80.27) 167.16,79.93 v5(167.22,79.93) 167.22,79.92 U7000.W6 166.52,79.22 v5(166.48,79.22) 166.5,79.2 166.53,79.2 v5(166.85,78.87) ; v5(202.08,83.53) U7800.J12 ; v5(158.08,79.91) 158.09,79.91 ; 158.09,79.91 U7000.AL6 ; U7000.N49 170.93,109.77 v5(170.93,110.14) 170.93,110.34 v5(171.18,110.59) ; U7601.N10 v5(148.87,136.33) ; v5(201.43,97.46) U7801.J12 ; v5(158.25,109.1) 158.59,109.1 v5(158.79,109.3) 158.45,109.64 ; v5(178.26,53.42) U7901.L12 ; U7800.R5 v5(198.84,79.64) ; U7801.C10 v5(196.88,98.11) ; U7900.J12 v5(164.03,53.42)
  BOTTOM w0.254: U2000.AV17 235.39,61.91 235.01,62.29 234.98,62.29 v2(234.78,62.49) 234.83,62.53 U2000.AT15 ; U7000.AR9 U7000.AT8 ; U7000.AT8 154.61,81.29 154.59,81.29 ; U7000.AT8 v3(154.6,80.6) ; U7000.AU10 v3(153.9,82) U7000.AV9 U7000.AW8 v3(152.5,81.3) 152.15,80.95 U7000.AY8 ; v3(148.24,98.84) 148.39,98.99 148.49,98.99 U7000.BE34 ; U7000.BD26 v3(149.69,93.21) ; U2000.AV31 v2(235.14,54.51) 235.08,54.45 235.08,54.36 U2000.AV33 ; U9400.16 102.36,166.42 103.09,165.69 v2(103.28,165.69) ; R8041.2 52.43,192.79 ; v3(147.6,92.5) U7000.BG25 ; v3(147.61,84.78) 147.58,84.78 U7000.BG13 ; U7000.BJ32 U7000.BJ33 U7000.BH33 ; U7000.BC22 150.39,90.41 v3(150.39,90.4) ; U7000.BC4 150.16,78.04 150.16,77.49 v3(149.97,77.3) 150.05,77.22 U7000.BC2 ; v3(73.78,109.16) 73.89,109.05 U0300.BT9 ; v3(149.68,97.4) 149.65,97.36 149.65,97.35 v3(149,96.7) 148.66,97.05 U7000.BE31 ; v3(149.68,97.4) 149.35,97.73 U7000.BD32 ; v3(149.68,97.4) 150.03,97.05 U7000.BC31 ; U7000.AU2 154.37,76.87 v3(154.37,77.4) ; C80108.2 53.67,188.83 v2(53.67,189.83) ; U7000.BJ31 U7000.BJ30 U7000.BJ29 145.8,95.6 145.8,95 U7000.BJ28 ; U7000.BL10 145.15,82.35 v3(145.41,82.09) 145.59,82.09 U7000.BJ10 ; C1169.2 C1171.2 291.55,42.35 v5(291.52,42.37) ; U7000.BJ25 145.55,92.85 145.39,92.69 ; U7000.BJ25 145.73,92.97 145.73,93.43 U7000.BJ26 U7000.BJ27 U7000.BJ28 ; U7000.BJ25 U7000.BJ24 ; R8087.2 49.76,192.77 ; U0300.AY14 85.84,112.08 v3(85.36,112.55) ; U7000.AT51 U7000.AT52 v5(154.95,112.33) ; v2(210.37,41.94) 210.04,42.27 R2256.2 210.85,42.9 R2255.2 ; v3(152.48,78.52) 152.15,78.19 U7000.AY4 152.15,77.33 v3(152.18,77.3) ; v3(152.48,78.52) 152.85,78.15 U7000.AW4 U7000.AV4 U7000.AU4 U7000.AT4 ; v3(152.48,78.52) 152.81,78.85 U7000.AW5 ; R8021.1 59.54,192.82 59.43,192.93 59.42,192.93 ; U7000.BJ17 145.75,87.15 145.75,86.67 145.85,86.57 U7000.BJ16 ; v5(177.68,109.31) U7000.D49 v5(177.68,109.98) ; v3(153.9,79.89) U7000.AU6 U7000.AT5 ; U2000.T42 224.72,49.79 v2(224.72,50.23) ; v3(150.4,88.28) 150.05,88.63 U7000.BC19 ; U7600.B14 v5(162.32,139.58) ; U0300.BK25 U0300.BJ25 ; U0300.D20 113.14,117.15 113.71,116.58 U0300.C19 ; v3(148.99,90.39) 148.65,90.73 U7000.BE22 ; v2(295.51,90.41) 295.51,90.66 295.75,90.9 CON5300.33 v2(295.75,92.82) ; CON5100.20 24.75,14.77 24.97,14.99 v2(25.08,14.99) ; U2000.AK42 231.7,50.16 v2(231.74,50.2) ; C8014.1 61.32,192.62 61.62,192.93 ; C1170.2 289.9,40.07 v5(290.26,40.43) ; U7000.BG16 147.4,86.7 147.45,86.7 v3(147.64,86.88) ; v3(148.3,94.61) 148.64,94.95 U7000.BE28 148.99,94.61 v3(149.02,94.61) 148.66,94.25 U7000.BE27 148.65,94.26 v3(148.3,94.61) ; v3(148.3,94.61) 147.62,95.3 v3(147.59,95.3) 147.25,94.95 U7000.BG28 ; U0300.G28 111.11,123.52 v3(111.43,123.85) 111.76,124.17 U0300.F29 ; U7000.BE13 148.94,84.16 v3(149.08,84.16) ; U7000.BG40 U7000.BH39 ; v3(95.48,126.44) 95.43,126.44 95.11,126.76 U0300.AH33 U0300.AH34 ; U7000.BF6 U7000.BG7 147.25,80.25 v3(146.89,80.6) 146.39,80.09 146.01,80.09 U7000.BJ7 ; v3(79.47,118.5) U0300.BJ22 78.82,118.62 78.41,118.62 U0300.BK22 ; v2(249.99,72.93) 250.25,72.68 251.07,72.68 251.19,72.8 U2402.3 ; U7000.BG19 147.52,88.92 v3(147.67,88.92) ; U7000.BJ15 U7000.BJ16 ; U7000.BJ15 U7000.BJ14 145.78,85.08 145.78,84.52 U7000.BJ13 145.79,84.45 v3(145.47,84.13) ; U7000.BJ15 U7000.BH15 ; U7000.BJ16 145.5,86.55 v3(145.37,86.42) ; v3(145.27,99.03) 145.39,99.15 U7000.BJ34 145.68,99.32 145.68,99.68 U7000.BJ35 U7000.BJ36 ; R8028.2 53.32,192.89 ; v2(226.97,50.21) 227.15,50.03 U2000.AA42 ; U7000.BC25 150.28,92.62 v3(150.48,92.62) 150.05,92.19 U7000.BC24 U7000.BD24 149.35,92.42 v3(149.16,92.62) 148.88,92.62 U7000.BE25 ; U7000.BE10 148.45,82.15 148.44,82.15 v3(148.29,82) ; R2413.1 245.09,56.75 244.89,56.75 244.84,56.8 v2(244.84,56.84) 244.84,57.08 245.01,57.26 R2460.1 ; C8016.1 62.21,192.92 ; U7000.AU51 v5(154.25,110.59) ; U7000.BC16 150.05,86.53 v3(150.4,86.18) ; U7000.BJ24 U7000.BH24 ; U7000.BJ24 U7000.BJ23 U7000.BJ22 U7000.BJ21 ; R6102.2 v2(219.82,42.32) ; v2(248.01,67.35) 248.03,67.35 248.47,66.91 C2401.2 ; R8029.1 60.43,192.75 60.25,192.94 ; U7000.BH18 U7000.BJ18 145.95,88.05 145.95,88.54 U7000.BJ19 145.85,88.71 145.73,88.83 145.73,89.23 U7000.BJ20 U7000.BJ21 ; 154.59,81.29 U7000.AU8 ; 154.59,81.29 v3(154.6,81.3) ; U7000.BE15 148.96,86.16 148.98,86.16 v3(149,86.19) 148.65,86.54 U7000.BE16 148.52,86.42 148.44,86.42 v3(148.27,86.25) ; U2000.BB16 237.46,62.39 v2(236.6,62.39) ; v3(149,98.81) 148.65,98.46 U7000.BE33 ; U7000.BJ21 U7000.BH21 146.56,90.05 v3(146.9,90.39) 147.25,90.74 U7000.BG22 v3(147.6,91.1) ; U7000.BG10 147.41,82.51 147.43,82.51 v3(147.61,82.68) ; U9400.4 102.86,170.15 103.16,170.44 v2(103.31,170.44) ; C1172.2 289.22,41.26 288.83,41.64 v5(288.83,41.66) ; U7000.BD35 v3(149.69,99.5) U7000.BC34 ; C1185.2 292.08,45.77 v5(292.61,46.3) ; U7000.AY10 v3(151.8,82) ; v7(145.19,101.13) 145.31,101.25 U7000.BJ37 ; v5(293.47,43.67) 293.47,43.04 C1167.2 ; R2121.2 226.68,39.81 v2(226.9,39.59) ; R8085.2 48.88,192.77 ; U7000.BJ28 145.22,94.95 v7(145.14,94.88) 145.07,94.95 U7000.BL28 ; U7000.BJ38 U7000.BJ39 U7000.BJ40 145.75,103.45 145.75,103.95 U7000.BJ41 ; v2(236.99,57.72) 237,57.72 237.19,57.91 U2000.BB25 ; U0300.F27 111.76,122.59 v3(112.09,122.27) ; v3(144.92,84.27) 145.33,84.27 v3(145.47,84.13) ; U7000.BF2 148.06,76.86 148.06,77.33 v3(147.6,77.8) U7000.BF4 ; U0300.BL35 77.53,128.06 77.41,127.95 U0300.BM35 ; v5(204.87,121.37) 204.12,121.37 203.31,120.56 U7700.H14 ; U7000.BC28 150.02,94.95 v3(149.69,95.28) 149.35,95.62 U7000.BD29 U7000.BE30 ; U2000.D45 218.74,47.92 v2(219.14,47.53) ; C8013.2 66.78,184.2 v2(66.88,184.3) ; U7000.AY6 v3(151.8,79.9) ; v2(244.84,58.2) R2425.2 ; v5(205.52,85.69) 205.52,85.29 U7800.D14 v5(205.98,84.83) U7800.D13 ; v3(77.31,121.25) U0300.BM25 ; v3(150.42,80.6) 150.4,80.6 U7000.BC8 ; v3(150.4,79.92) 150.05,79.57 U7000.BC6 ; R8046.2 50.65,192.77 ; v3(145.47,84.13) U7000.BJ12 ; C8010.1 58.65,192.93 ; U7000.BE19 v3(149,88.3) 148.66,87.95 U7000.BE18 v3(148.28,88.32) 148.62,88.65 U7000.BE19
  BOTTOM w0.279: XDP4400.8 53.64,144.95 v2(53.45,144.76) ; v2(59.5,143.3) 59.65,143.45 XDP4400.13 ; v2(53.12,145.85) 53.71,146.45 XDP4400.2 ; v2(17.71,37.98) U6701.3 U6701.8 15.78,37.98 v2(15.63,38.13) ; XDP4400.19 v2(59.51,141.95) ; XDP4400.7 59.52,144.95 v2(59.32,144.75) ; XDP4400.14 v2(53.5,143.45) ; v2(53.7,133.94) 53.7,134 54.15,134.45 XDP4400.50 ; U1208.8 U1208.3 v2(307.88,33.33) ; v2(173.5,19.62) CON4402.11 ; XDP4400.20 v2(53.45,141.95) ; XDP4400.26 v2(53.47,140.45) ; v2(62.72,137.52) 62.65,137.45 XDP4400.37 ; XDP4400.32 v2(53.47,138.95) ; XDP4400.49 62.47,134.45 v2(62.76,134.74) ; v2(307.27,36.63) 307.45,36.46 U1207.8 U1207.3 309.91,36.46 309.99,36.38 310.14,36.38 v2(310.27,36.25) ; XDP4400.38 v2(53.5,137.45) ; v2(59.49,140.45) XDP4400.25 ; XDP4400.31 v2(62.77,138.95)
  BOTTOM w0.28: U7000.B51 179.12,111.42 v5(179.12,111.43) 179.06,111.43 U7000.B52 ; U7701.H14 185.98,132.62 v5(186.25,132.62) ; v5(161.39,139.46) 161.8,139.46 U7600.B14 ; v5(199.05,122.01) 199.08,121.98 v5(199.08,120.54) ; v5(159.48,50.17) U7900.E5 ; U7000.BL31 144.9,97.05 v3(144.94,97.01) ; v5(185.54,59.27) 185.99,59.27 v5(186.28,58.99) ; v5(156.72,49.84) 156.49,50.07 v5(156.03,50.07) ; U7601.K14 151.38,134.28 v5(151.63,134.28) ; v5(156.75,55.22) 156.44,55.53 155.91,55.53 v5(155.75,55.69) ; v5(156.48,59.3) 155.75,60.03 155.75,60.06 v5(155.74,60.08) ; U7801.H14 200.45,95.81 200.28,95.63 v5(200.28,95.4) ; v5(167.42,57) 166.86,57 166.55,56.69 v5(166.04,56.69) ; v5(186.28,57.39) 185.67,57.99 v5(185.53,57.99) ; v5(156.51,57.97) 156.46,57.92 155.94,57.92 v5(155.73,57.71) ; v5(176.23,50.84) 176.22,50.82 175.87,50.82 175.11,51.58 v5(175.11,51.72) 175.51,52.12 v5(176.31,52.12) ; U7701.K14 186.04,134.34 v5(186.21,134.34) ; v5(162.32,139.58) 162.32,139.58 U7600.B13 ; v5(176.8,135.5) 177.25,135.5 U7701.M1 ; v5(151.63,132.58) 151.4,132.58 151.22,132.75 U7601.H14 ; v5(142.15,135.45) 142.25,135.35 U7601.M1 ; v5(201.99,95.42) 201.99,95.6 U7801.K14 ; U7700.D1 205.91,111.29 v5(205.92,111.28) ; v5(176.31,48.22) 175.63,48.22 v5(175.23,47.82) ; v5(158.18,56.67) U7900.P2 v5(157.53,56.02) ; v5(150.82,138.28) U7601.T14 ; U7700.T13 v5(198.43,119.24) ; v5(151.47,135.68) 151.87,136.08 v5(152.66,136.08) ; v5(167.46,59.25) 167.42,59.28 v5(166.03,59.28) ; v5(156.39,47.8) 156.43,47.8 v5(156.85,48.22) ; v5(186.28,56.59) 186.19,56.67 v5(185.41,56.67) ; v5(176.31,49.52) 176.28,49.55 v5(175.19,49.55) ; v2(205.97,110.29) 205.92,110.34 ; v5(184.76,49.52) U7901.T1 185.46,49.85 185.51,49.8 v5(185.56,49.8) 186.21,49.8 v5(186.31,49.7) ; v5(176.23,55.33) 176.35,55.33 U7901.H14
  BOTTOM w0.292: CON4402.9 v2(174.5,19.62)
  BOTTOM w0.3: U7000.W51 166.85,110.71 v5(167.02,110.54) ; 173.88,105.79 v5(174.03,105.64) 173.88,105.79 ; 173.88,105.79 173.88,106.69 v5(174.29,107.1) ; U7000.B48 v5(179.08,109.28) ; v5(196.22,85.53) 196.22,87.16 v5(196.27,87.21) ; U7000.AE51 162.65,110.6 v5(162.66,110.59) ; v5(176.96,50.82) U7901.P14 ; v5(179.92,76.11) 179.92,76.28 U7000.A2 ; U7701.F1 177.02,131.18 v5(177.02,131.18) ; U7000.N4 171.25,77.95 171.25,77.47 171.02,77.24 v5(171.02,77.22) 171.05,77.19 U7000.N2 ; v5(160.35,139.41) 161.2,139.41 161.24,139.46 v5(161.39,139.46) ; v5(151.66,130.14) 152.63,130.14 v5(152.68,130.09) ; U7000.A3 v5(180.05,77.45) ; v5(168.8,77.3) 168.95,77.15 U7000.T2 ; U7000.AB51 164.75,110.57 v5(164.83,110.49) ; U7900.H1 156.75,52.45 v5(156.73,52.47) 156.15,52.47 v5(156.07,52.39) ; U7000.J20 173.49,88.99 v5(173.46,88.99) ; v5(196.23,103.96) U7801.B2 196.88,103.31 v5(196.88,103.31) ; v5(160.13,56.67) U7900.R5 ; v5(207.3,104.63) 206.6,105.33 v5(206.6,105.48) ; U7000.H28 174.2,95.3 ; 174.2,95.3 v5(174.2,95.35) ; 174.2,95.3 174.2,95.27 ; v5(178.2,92.7) 178.35,92.85 U7000.B25 ; U7000.W2 166.85,77.17 v5(166.73,77.29) ; v5(176.99,76.45) 176.95,76.45 U7000.E2 ; C7703.2 189.01,133.25 189.09,133.25 v5(189.4,132.94) ; U7801.G10 199.48,98.11 v5(199.48,98.11) ; v5(173.45,101.6) 173.45,101.55 U7000.K37 ; v5(163.02,105.82) U7000.AD44 ; U7000.G51 175.25,110.96 v5(175.54,110.67) ; v5(203.03,76.22) 203.11,76.14 203.11,75.33 v2(203.18,75.27) ; U7000.B10 v5(179.1,82) ; v5(164.63,77.29) 164.75,77.17 U7000.AB2 ; 158.27,77.68 157.8,78.15 U7000.AM4 ; v5(160.35,137.82) 161.21,137.82 v5(161.53,138.14) ; U7000.B19 178.35,88.65 v5(178.2,88.5) ; U7000.J1 v5(173.85,75.49) ; v5(184.8,140.35) 184.8,140.26 U7701.W12 v5(184.17,139.63) ; U7000.T47 169.25,108.55 v5(169.25,108.65) ; v5(202.33,118.59) U7700.J12 ; v5(178.2,90.6) 178.35,90.75 U7000.B22 ; U7601.B2 v5(143.02,128.53) U7601.B1 ; U7000.AL45 v5(158.11,107.19) ; v5(198.83,85.48) 198.63,85.68 v5(198.63,87.2) ; v5(175.23,80.29) 175.23,80.29 ; 175.23,80.29 175.26,80.26 175.26,80.24 v5(175.6,79.9) U7000.G6 v5(174.89,79.91) 174.89,79.95 175.23,80.29 ; v5(178.29,84.26) 178.48,84.45 U7000.B13 ; v5(164.56,109.09) 164.57,109.09 v5(165.06,108.6) ; v5(171.18,110.59) 171.05,110.72 U7000.N51 ; 158.85,105.85 U7000.AK44 ; v5(199.48,82.88) U7800.N10 ; v5(176.32,92.48) U7000.F25 ; 205.92,110.34 v5(205.92,111.28)
  BOTTOM w0.305: CON1701.172 85.37,45.78 86.62,47.03 v2(86.86,47.03) ; CON6700.38 12.56,53.2 v2(12.55,53.19) ; C7947.2 C7948.2 186.37,49.64 v5(186.31,49.7) ; v2(298.58,90.41) 298.58,90.62 298.75,90.79 CON5300.45 298.75,92.53 v2(298.75,92.82) ; U0300.H22 U0300.J22 109.38,118.34 v3(109.24,118.34) ; U0300.C23 113.06,120.16 U0300.D24 113.39,120.62 v3(113.39,120.7) 113.71,121.02 U0300.C25 ; v2(12.55,51.67) 12.58,51.7 CON6700.35 ; v3(83.67,126.44) 83.6,126.44 U0300.BC33 ; v5(201.52,93.92) 201.52,93.96 201.14,94.34 199.88,94.34 199.55,94.01 C7833.2 ; 56.38,43.35 CON1701.64 56.38,45.8 v2(56.44,45.86) ; CON6700.44 12.64,56.2 v2(12.55,56.12) ; v3(88.39,127.09) 88.07,127.41 U0300.AU34 ; v2(32.16,39.09) 32.03,38.95 CON5102.1 ; v2(93.94,66.3) 93.99,66.35 94.42,66.35 94.63,66.15 CON1601.209 ; v2(21.29,34.36) 20.88,33.95 CON5103.21 ; v3(73.21,126.12) 73.4,126.31 U0300.BT32 ; v3(81.31,126.44) 81.24,126.44 U0300.BF33 ; CON1601.103 66.13,65.95 ; 52.13,66.19 CON1601.47 ; U0300.BR38 v3(74.98,130.66) ; CON5104.27 46.25,12.85 45.07,11.67 v2(45.07,10.78) ; v3(104.93,126.43) 104.86,126.43 U0300.T33 ; 96.63,66.35 CON1601.217 96.63,63.29 v2(96.93,62.98) ; U0300.BA37 U0300.BA38 v3(84.85,130.64) ; 86.13,66.19 CON1601.175 ; U0300.H25 U0300.J25 v3(109.24,121.09) ; v2(104.06,63.46) 104.13,63.52 CON1601.247 v2(104.13,66.17) ; U0300.BC34 83.34,127.41 v3(83.67,127.09) ; CON1701.9 42.63,53.88 ; v2(38.97,10.52) 38.97,11.54 40.25,12.82 CON5104.51 ; 92.32,63.46 91.8,63.46 91.63,63.63 CON1601.197 ; v3(94.56,110.22) 94.65,110.22 U0300.AH12 ; v2(289.92,97.9) v2(290.56,97.9) v2(291.19,97.9) 291.7,97.9 292,98.2 292,98.94 CON5300.18 292,100.27 v2(291.26,101.01) ; v3(103.75,130.71) U0300.U38 U0300.U37 ; v2(305.59,90.33) 305.11,90.33 304.75,90.69 CON5300.69 ; v3(89.58,130.64) U0300.AR38 U0300.AR37 ; 92.63,63.15 CON1601.201 92.63,66.18 ; 50.13,66.13 CON1601.39 ; v2(28.07,31.93) 28.23,32.09 29.83,32.09 30.19,32.45 CON5102.27 ; v2(287.89,90.15) 287.75,90.29 CON5300.1 287.75,92.53 287.64,92.64 287.64,93.05 287.94,93.35 288.63,93.35 288.88,93.1 v2(288.88,92.84) 289.25,92.48 CON5300.7 v2(289.25,90.15) ; U0300.AT30 U0300.AT29 v3(88.79,123.58) ; v2(18.78,24.62) 19.11,24.95 CON5103.57 ; 85.13,66.3 CON1601.171 ; v2(32.19,38.46) 32.18,38.45 CON5102.3 ; 54.62,66.32 CON1601.57 ; U0300.AC37 U0300.AC38 v3(99.02,130.71) ; U0300.BF34 80.98,127.41 v3(81.31,127.09) ; v2(11.79,48.62) 11.79,49.38 12.61,50.2 CON6700.32 ; v2(105.38,46.25) 105.38,45.72 CON1701.252 ; U0300.G26 110.76,122.23 v3(110.76,122.27) ; U8001.28 70.72,144.43 C8068.1 ; 56.38,55.34 CON1601.64 ; v2(63.62,45.88) 63.88,45.63 CON1701.94 63.88,43.56 63.48,43.16 ; CON1701.40 50.38,43.44 ; CON1601.65 56.62,66.14 56.69,66.21 ; CON1701.68 57.38,43.27 ; C1181.2 292.77,39.35 292.54,39.12 v5(292.17,39.12) ; U0300.AW30 U0300.AW29 86.43,123.52 v3(86.38,123.48) ; v2(59.92,43.29) 59.88,43.34 CON1701.78 59.88,45.79 v2(59.68,45.98) ; v3(93.51,123.58) U0300.AK29 U0300.AK30 ; CON1601.14 43.88,55.25 ; v2(303.25,90.41) 303.25,92.42 ; 303.25,92.42 v2(303.25,92.77) ; 303.25,92.42 CON5300.63 ; v2(205.85,22.6) 205.75,22.5 CON3104.14 205.75,20.81 v2(205.87,20.68) ; U0300.AY34 85.7,127.41 v3(86.03,127.09) ; v2(18.78,29.7) 19.08,29.7 19.33,29.45 CON5103.39 ; U0300.F25 111.43,120.76 v3(111.43,120.7) ; U0300.AL34 92.79,127.41 v3(93.12,127.09) ; 225.89,40.49 225.89,40.29 v2(225.28,39.68) 225.13,39.83 225.13,40.49 ; 98.13,66.22 CON1601.223 98.13,63.58 98.82,62.89 v2(98.82,62.26) 99.35,62.26 99.73,61.88 v2(100.08,61.88) ; CON5103.73 19.17,20.95 18.66,20.95 v2(18.52,20.81) 18.88,20.45 19.18,20.45 CON5103.75 ; v2(12.43,47.23) 12.45,47.2 CON6700.26 ; v2(40.93,45.85) 40.88,45.8 CON1701.2 40.88,43.62 41.51,42.98 ; U0300.AA30 U0300.AA29 101.01,123.7 v3(101.01,123.55) ; v2(211.56,20.94) 211.97,20.94 212.25,21.22 CON3104.1 212.25,22.52 v2(212.33,22.6) ; v3(110.78,119.91) 110.78,119.97 U0300.G24 ; CON5104.21 47.75,13.21 45.7,11.16 v2(45.7,10.78) ; v3(102.07,123.55) 102.4,123.55 U0300.V29 U0300.V30 ; CON6700.4 v2(14.71,36.2) ; v2(38.46,10.9) 38.46,12.05 38.75,12.33 CON5104.57 ; CON5103.71 19.1,21.45 18.53,21.45 v2(18.52,21.44) ; C8070.1 70.98,162.97 U8003.28 ; v3(101.39,130.71) U0300.Y38 U0300.Y37 ; v3(91.08,123.48) 91.15,123.55 U0300.AN29 U0300.AN30 ; v2(48.04,45.99) 47.88,45.83 CON1701.30 v2(47.88,43.22) ; CON1701.36 49.38,43.32 ; U0300.T34 104.86,127.08 v3(104.93,127.08) ; U0300.AG30 U0300.AG29 v3(95.87,123.58) ; v3(82.06,123.48) 81.7,123.83 U0300.BE29 U0300.BE30 ; CON5102.73 31.02,20.95 29.56,20.95 v2(29.29,20.68) 29.53,20.45 31.02,20.45 CON5102.75 ; CON1601.85 61.63,66 ; CON1601.94 63.88,55.29 v2(63.76,55.18) ; CON1601.48 52.38,55.55 52.15,55.33 v2(51.52,55.33) 51.38,55.48 CON1601.44 ; CON5104.39 43.25,12.95 U1501.23 ; v2(18.78,30.33) 19.39,30.95 19.52,30.95 CON5103.33 ; CON1601.1 40.63,66.08 ; v2(145.12,24.06) 145.93,24.06 146.4,23.59 U0703.3 ; CON1601.239 102.13,66.11 ; CON5102.71 31.02,21.45 v2(29.29,21.45) ; v3(105.32,123.5) U0300.R29 U0300.R30 ; U0300.AE33 97.78,126.43 v3(97.84,126.43) ; C1110.2 274.17,52.26 v2(273.87,51.96) ; 51.13,66.21 CON1601.43 ; v2(55.28,55.32) 55.38,55.42 CON1601.60 ; v3(80.13,130.64) U0300.BG38 U0300.BG37 ; v3(142.95,77.1) 143,77.1 143.01,77.09 143.08,77.09 143.45,77.45 U7000.BM3 ; CON6700.29 12.63,48.7 v2(12.55,48.62) ; 54.64,43.34 54.38,43.61 CON1701.56 ; v2(58.38,45.94) CON1701.72 58.38,43.31 ; U0300.BT3 74.11,104.68 73.84,104.41 73.75,104.41 v3(73.74,104.42) ; C7725.2 187.92,128.28 v5(187.55,128.65) ; CON1601.78 59.88,55.24 ; 57.63,66.28 57.62,66.27 CON1601.69 ; CON5103.27 19.11,32.45 18.78,32.11 v2(18.78,31.1) ; U0300.AP33 90.69,126.44 v3(90.75,126.44) ; CON5602.21 91.75,185.35 v2(91.5,185.6) ; CON5102.51 31.94,26.45 v2(32.29,26.8) ; U0300.AB33 100.14,126.43 v3(100.21,126.43) ; CON1601.23 46.13,66.03 ; U0300.F23 111.44,119.19 v3(111.44,119.12) 111.11,119.44 U0300.G23 ; CON4400.4 v2(145.25,7.86) ; C7731.2 188.03,129.25 v5(187.55,129.25) ; CON1701.48 v2(52.38,43.29) ; CON5102.15 v2(32.21,35.45) ; v2(44.43,10.78) 44.43,12.43 44.75,12.75 CON5104.33 ; U0300.BB30 U0300.BB29 v3(84.06,123.58) ; v2(300.25,92.82) 300.25,92.58 CON5300.51 300.25,90.83 299.98,90.56 299.34,90.56 v2(299.19,90.41) ; v5(208.86,96.41) 209.06,96.21 C7815.2 ; v2(21.57,37.57) 21.57,37.32 21.2,36.95 CON5103.9 ; CON1701.73 58.63,53.99 ; v2(45.88,43.22) CON1701.22 45.88,45.77 v2(45.94,45.84) ; CON5102.45 32.14,27.95 v2(32.19,28) ; 55.62,66.16 CON1601.61 ; v3(98.24,123.48) U0300.AD29 U0300.AD30 ; CON5602.1 81.75,183.68 v2(81.34,183.27) ; U0300.AY33 85.96,126.44 v3(86.03,126.44) ; CON1601.82 60.88,55.19 ; v2(59.75,131.43) 59.75,131.61 60.09,131.95 XDP4400.59 ; 101.22,66.13 v2(101.23,66.12) 101.13,66.02 CON1601.235 ; v2(61.88,45.89) CON1701.86 61.88,43.33 v2(61.83,43.29) ; v2(44.82,45.84) 44.88,45.79 CON1701.18 44.88,43.17 ; v3(93.74,130.71) 94.3,130.16 U0300.AJ38 U0300.AJ37 ; U0300.F17 112.09,114.47 v3(112.09,114.4) ; v3(79.49,115.6) 79.19,115.6 U0300.BJ18 U0300.BK18 ; v2(32.29,24.72) 32.06,24.95 CON5102.57 ; CON1701.26 v2(46.88,43.24) ; v3(73.7,105.32) 73.79,105.4 U0300.BT4 ; C1111.2 279.13,51.71 v2(278.87,51.45) ; v2(12.55,54.72) 12.57,54.7 CON6700.41 ; 53.11,66.16 53.13,66.15 CON1601.51 ; CON1601.189 89.63,65.94 ; CON1601.9 42.63,66.16 ; CON5102.39 32.07,29.45 v2(32.17,29.54) ; CON5103.3 21.33,38.45 v2(21.57,38.21) ; v2(87.8,66.15) 87.63,65.97 CON1601.181 ; CON1701.82 60.88,43.22 ; v2(32.26,36.95) CON5102.9 ; v2(54.04,46.48) 53.38,45.82 CON1701.52 53.38,43.42 ; 57.62,54.02 CON1701.69 ; CON1601.227 99.13,66.34 ; U1501.22 41.75,12.97 CON5104.45 ; 52.13,54.04 CON1701.47 ; CON5103.51 19.34,26.45 v2(18.78,25.89) ; v3(76.01,126.77) 76.01,126.83 ; 76.01,126.83 U0300.BN34 ; 76.01,126.83 U0300.BP34 ; 50.38,55.32 CON1601.40 ; U0300.G16 111.44,113.68 v3(111.44,113.61) ; CON1601.213 95.63,66.29 ; v2(57.13,55.32) 57.38,55.56 CON1601.68 ; v2(50.75,15.35) CON5104.9 v2(50.75,12.97) 51.95,12.97 52.25,13.26 CON5104.3 v2(52.25,15.35) ; CON1701.27 47.13,53.91 ; C1182.2 292.92,37.24 v5(292.82,37.14) ; CON5103.45 v2(18.78,27.95) ; CON1601.205 93.63,65.99 ; v3(102.57,126.43) 102.5,126.43 U0300.W33 ; v3(109.21,115.58) U0300.J18 U0300.H18 U0300.G18 ; U0300.BM38 v3(77.13,130.64) ; v2(297.25,92.82) CON5300.39 297.25,90.83 297.41,90.66 v2(297.41,90.41) ; CON1601.72 58.38,55.36 v2(58.39,55.34) ; U0300.AL33 93.05,126.44 v3(93.12,126.44) ; CON1601.15 44.13,66.18 ; CON6700.10 v2(14.71,39.2) ; U7000.BK1 145.15,75.85 v3(144.82,75.51) ; U0300.F21 111.44,118.26 v3(111.44,118.34) 111.11,118.66 U0300.G22 ; CON5300.75 306.25,91.63 v2(306.25,90.45) ; CON1601.30 47.88,55.37 ; CON1701.168 84.37,46.2 v2(84.21,46.36) ; v2(105.31,63.33) 105.13,63.52 CON1601.251 105.13,66.2 ; U0300.BN30 76.01,125.12 v3(76.01,125.19) 76.01,125.26 U0300.BN31 ; 49.38,55.37 CON1601.36 ; 103.13,66.3 CON1601.243 ; v2(32.24,30.23) 32.24,30.56 31.85,30.95 CON5102.33 ; 42.68,43.29 42.88,43.49 CON1701.10 42.88,45.85 43.06,46.03 v2(43.31,46.03) 43.62,46.03 43.88,45.77 CON1701.14 43.88,43.44 44.02,43.29 ; U0300.AP34 90.43,127.41 v3(90.75,127.09) ; CON1601.89 62.63,66.06 ; CON1601.26 46.88,55.46 ; U0300.BD37 U0300.BD38 v3(82.49,130.64) ; v2(12.55,56.75) 12.61,56.7 CON6700.45 ; U0300.AM37 U0300.AM38 v3(91.94,130.64) ; v2(32.16,34.12) 31.99,33.95 CON5102.21 ; v5(198.01,94.05) 197.9,93.94 C7821.2 ; C7924.2 174.77,57 v5(174.83,56.95) ; CON1701.81 60.63,53.87 ; v2(100.13,66.31) CON1601.231 ; CON1701.6 41.88,43.25 ; U0300.K38 v3(109.26,130.63) ; 60.63,66.2 CON1601.81 ; CON5300.57 v2(301.75,92.82) ; CON1701.65 56.62,53.91 ; C8069.1 75.72,178.16 U8002.28 ; U0300.BT36 74.5,128.58 U0300.BR36 ; U7000.BL1 144.45,75.89 v3(143.96,75.41) ; CON1601.35 49.13,66.15 ; U0300.AV37 U0300.AV38 v3(87.21,130.64) ; 62.88,43.19 CON1701.90 62.88,46.05 v2(63.33,46.5) ; CON1601.10 42.88,55.06 ; CON1601.6 41.88,55.18 ; v3(106.11,130.71) U0300.P38 U0300.P37 ; U0300.AB34 100.14,127.08 v3(100.21,127.08) ; v3(97.84,127.08) 97.78,127.08 U0300.AE34 ; U0300.AU33 88.33,126.44 v3(88.39,126.44) ; v2(64.62,45.9) 64.88,45.65 CON1701.98 64.88,43.46 v2(65.17,43.17) ; CON1601.31 48.13,66.16 ; CON1601.99 65.13,66.01 ; CON1601.107 67.13,66.09 ; U0300.W34 102.5,127.08 v3(102.57,127.08) ; CON1701.102 65.88,43.49 v2(66.23,43.14) 66.41,43.14 66.88,43.61 CON1701.106 ; CON1601.106 66.88,55.34 ; CON1701.51 53.13,54.07 ; CON1601.27 47.13,66.12 ; 45.88,55.42 CON1601.22 ; CON6700.7 v2(14.71,37.7) ; v2(14.99,34.91) 14.79,34.7 CON6700.1 ; CON4400.2 v2(146.25,7.89) ; CON1601.18 44.88,55.45 ; CON1601.93 63.63,65.99 ; U0300.BL38 v3(77.84,130.64) ; CON1701.57 54.62,54.51 ; CON1601.193 90.63,66.04 ; CON1601.185 88.63,66.33 ; CON1601.167 84.13,66.35 ; v2(55.32,45.86) 55.38,45.8 CON1701.60 55.38,43.24 ; CON1701.44 51.38,43.25 ; CON1701.77 59.63,54.2
  BOTTOM w0.33: U0300.BJ25 v3(79.47,120.86) ; v5(176.07,135.68) 176.03,135.72 C7730.2
  BOTTOM w0.356: v2(148.41,52.61) 148.62,52.61 148.94,52.29 U7409.1 ; U7404.4 145.48,65.11 145.89,64.7 v2(145.98,64.7) ; U7405.4 152.65,67.97 153.01,67.61 v2(153.51,67.61) ; U5704.1 126.56,165.76 127.11,166.3 v2(127.31,166.3) ; v2(150.84,66.04) 150.79,66.1 R7468.2 ; C7400.2 132.37,60.18 v2(132.06,60.49) ; U7405.1 v2(151.35,69.74) ; v2(151.52,64.9) 152.18,64.9 C7402.2 ; U0701.3 68.36,106.22 68.73,105.85 C0701.2 70.37,105.85 ; v2(241.89,42.3) 241.93,42.26 U2302.4 ; v2(138.74,55.94) 138.85,55.82 U7403.1 ; v2(150.37,50.54) 150.24,50.41 U7409.4 ; U7408.1 148.37,70.62 v2(148.07,70.92) R7429.1 ; v2(134.8,55.73) 134.55,55.99 C7405.2 ; v2(248.34,73.99) 248.12,73.78 U2403.3 ; U5702.4 235.39,26.81 v2(235.29,26.7) ; U7402.1 147.67,61.48 147.4,61.75 v2(147.09,61.75) ; v2(149.54,67.37) 149.94,67.77 U7408.4 ; U2302.1 240.63,42.95 v2(241.28,42.3) ; U7403.4 137.55,57 v2(137.97,56.59) ; v2(240.01,30.49) 240.01,29.85 239.4,29.24 238.64,29.24 238.07,28.67 U5702.1 ; v2(146.29,53.19) 145.89,52.79 U7410.4 ; U7416.3 v2(141.73,56.58) ; v2(136.28,58.15) 136.46,58.33 C7406.2 ; v2(147.33,59.66) 147.37,59.62 148.63,59.62 148.97,59.28 U7402.4 ; U7404.1 146.78,62.68 v2(147.1,62.36) ; R7711.1 v2(200.01,127.95) ; U0702.3 v2(118.9,80.77)
  BOTTOM w0.381: v2(169.06,52.29) 169.09,52.33 R7911.1 ; v2(278.97,58.58) 278.97,58.45 279.3,58.12 R1241.2 ; C8004.2 50.35,180.8 50.35,180.78 v2(50.07,180.5) 51.25,180.5 51.45,180.7 R8038.2 ; v2(172.98,54.95) 173.67,54.26 C7903.2 ; C7714.2 187.02,135.85 v5(186.79,136.08) ; R7811.1 203.1,89.03 v2(203.26,88.88) ; v5(155.28,136.28) 154.69,135.69 C7604.2 R7611.1 ; v5(208.92,80.25) 208.97,80.19 C7855.2 ; R1327.2 v2(301.35,79.81) ; C8022.2 62.03,183.54 v2(62.03,183.7) ; R1120.2 281.73,52.03 v2(281.92,52.22) ; v2(235.77,39.43) 235.29,39.91 R2317.2 ; v5(296.77,35.19) 296.78,35.17 296.78,35.15 296.83,35.1 R1123.1 ; v5(297.68,35.19) 298.06,35.56 R1124.1 ; v3(71.15,126.47) 70.92,126.25 C80134.2 ; R1108.2 288.59,37.76 288.81,37.98 v5(288.82,37.98) ; R1613.2 104.33,74.95 v2(104.01,74.63) 103.51,75.13 R1614.2 ; v2(69.32,122.28) 69.7,122.66 R1016.2 ; v2(65.79,118.73) 65.37,119.15 R0705.2 ; C5005.2 42.63,118.88 v2(42.63,118.47)
  BOTTOM w0.406: U2404.3 253.81,45.95 v2(254.08,45.68) ; R30104.2 151.45,14.55 v2(151.45,14.72) ; v5(150.01,141.56) 150.01,141.51 150.19,141.32 v5(150.19,140.34) ; v2(185.5,15.54) CON3110.16 ; v5(209.49,120.11) v5(209.49,119.31) 209.42,119.24 v5(208.18,119.24) ; R7489.2 140.87,50.71 v2(140.34,50.17) ; R7427.1 134.22,69.32 134.46,69.09 v2(135.21,69.09) ; v5(185.44,48.2) 186.21,48.2 v5(186.31,48.1) ; v2(99.23,71.25) 99.46,71.48 R1618.2 ; v2(97.65,69.69) 97.77,69.58 C1605.1 C1606.2 ; v2(140.37,72.7) 140.35,72.71 C7215.2 ; v2(65.28,149.94) 64.46,149.94 64.06,149.54 R4424.1 ; U7003.3 144.14,65.34 143.81,65.01 143.52,65.01 v2(143.44,64.93) ; v5(175.23,47.82) 174.81,47.4 C7910.2 ; v2(129.75,89.81) U7002.3 ; v5(204.87,121.37) 205.7,121.37 v5(205.77,121.44) ; R7482.2 151.54,56.88 v2(151.09,56.42) ; v5(176.29,127.29) 176.31,127.31 v5(177,127.31) ; v2(138.16,64.8) 137.98,64.8 137.52,65.26 R7432.1 ; v5(205.8,104.81) v5(205.8,105.48) v5(205,105.48) ; v2(146.03,61.3) 146.3,61.03 U7412.3 ; R7424.1 v2(135.74,66.96) ; v2(157.36,14.73) 156.71,14.08 R30103.2 ; R4423.2 56.72,127.47 v2(56.35,127.84) ; v2(139.71,54.92) 139.45,54.67 139.45,54.11 R7461.2 ; v2(193.91,15.55) 194,15.64 CON3110.15 ; v2(100.44,67.95) R1617.2
  BOTTOM w0.432: v2(288.25,84.82) 287.94,85.12 C1314.2 ; C1619.2 74.33,68.73 74.02,68.42 v2(74.02,67.5) ; C7408.2 C7407.2 136.07,53.65 135.85,53.42 v2(135.79,53.42) ; C7749.2 206,110.26 v2(205.97,110.29) ; C9603.2 114.46,144.18 v2(114.15,144.48) ; C1719.2 v2(113.77,46.46) ; v5(152.68,128.61) 152.87,128.42 C7659.2 ; R0740.2 69.48,128.81 68.99,129.29 v2(68.99,129.8) ; R1142.2 288.96,45.65 v2(288.91,45.7) ; C8904.2 254.34,82.2 v2(254.13,82.4) ; C7949.2 175.85,137.62 v5(176.12,137.35) ; v5(205.68,75.59) 205.8,75.47 C7851.2 ; v2(243.06,68.43) 243.42,68.08 C2501.2 ; C8020.1 v2(46.73,177.88) ; C1718.2 80.55,42.65 v2(80.65,42.76) ; v2(231.91,38.56) R2321.2 ; v2(141.13,49.43) 141.13,49.13 142.33,47.93 U7411.3 ; v2(290.53,83.58) 290.94,83.17 R1320.2 ; C7653.2 152.7,130.11 v5(152.68,130.09) ; v5(198.63,87.2) 198.66,87.23 C7856.2 ; C1703.1 66.3,69.56 v2(65.74,69.56) ; C7803.2 204.19,93.03 ; 204.19,93.03 v2(204.65,92.56) ; 204.19,93.03 204.3,93.14 C7829.2 204.27,93.66 v5(203.77,94.16) ; C2405.1 255.12,74.91 v2(255.3,75.09) ; C7628.2 150.88,141.63 v5(150.81,141.56) ; v2(274.18,62.36) 273.51,63.03 C2827.2 ; C7620.2 171.71,137.82 v5(171.62,137.73) ; R2484.1 249.82,50.73 250.2,51.11 v2(250.2,51.43) ; R2474.2 v2(227.67,75.35) ; v2(306.28,77.78) 306.43,77.63 C6001.1 ; U7410.1 147.19,49.93 148.29,51.04 v2(148.75,51.04) ; C4403.2 62.14,127.18 v2(62.46,126.85) ; v5(196.27,87.21) 196.09,87.38 196.09,87.84 C7832.2 ; C4538.2 102.09,188.89 v2(102.04,188.94) ; C2302.2 v2(245.22,78.26) ; R1169.1 v2(286.19,42.27) ; R7322.2 130.18,79.86 v2(129.77,80.27) ; C7621.2 160.23,128.45 v5(160.35,128.57) ; C8839.2 144.79,15.55 v2(144.51,15.27) ; v2(137.9,60.56) 138.23,60.23 R7467.2 ; C1713.2 v2(84.24,41.49) ; v2(112.5,148.57) R9604.1 ; v2(65.74,70.24) 66.08,70.57 C1702.1 C1602.1 ; C7925.2 174.79,59.27 v5(174.87,59.19) ; R0751.2 C0703.1 148.06,27.85 v2(148.39,27.52) ; C7409.2 147.73,54.85 v2(147.55,55.02) ; v2(113.62,147.3) C9612.2 ; v5(177.77,46.34) 177.77,46.15 C7926.2 ; v2(147.1,62.36) 147.4,62.36 R7436.1 ; v2(203.57,110.29) 203.41,110.13 C7757.2 ; v2(106.85,41.51) 106.84,41.52 C1840.2 ; v2(38.89,16.69) 38.84,16.75 R1512.1 ; C7658.2 141.4,137.24 v5(141.47,137.3) ; R2235.2 v2(229.37,75.35) ; v2(286.47,46.36) 286.95,46.84 R1170.1 R1172.1 ; v5(152.66,136.08) 152.66,136.3 152.86,136.5 C7657.2 ; v2(283.29,38.51) 283.29,39.4 284,40.11 R1154.2 ; v2(129.77,82.18) 129.98,82.38 R7321.2 ; R1110.2 297.26,44.08 297.38,44.19 v5(297.38,44.35) ; C8070.1 71.79,162.8 v2(72.07,162.52) ; v2(281.93,51.49) 282.14,51.29 R1102.2 ; v2(97.11,13.47) 97.16,13.47 97.69,14 C9511.2 ; v2(126.57,151.82) 126.73,151.98 R8741.2 ; SR2001.1 223.53,76.03 R2526.1 223.53,74.95 v2(223.93,74.54) ; C8067.1 66.25,165.23 v2(66.25,164.65) ; v2(102.01,67.66) 102.42,68.07 C1705.1 C1706.2 C1704.2 102.42,70.62 v2(102.83,71.03) ; v2(211.56,67.09) 211.23,66.76 C2503.2 ; v2(164.78,22.37) 164.9,22.49 R3004.2 ; v2(243.49,71.28) 243.62,71.15 C2500.2 ; 91.9,68.26 91.91,68.26 R1615.2 ; C1512.1 45.98,16.9 v2(45.98,16.64) 45.98,16.34 R1513.1 ; C7617.2 171.73,135.22 v5(171.62,135.33) ; R2315.2 234.42,39.4 234.09,39.07 v2(234.09,38.92) ; v5(141.47,138.1) 141.44,138.13 C7618.2 ; v5(294.04,35.19) 293.55,35.67 R1101.2 ; C7941.2 167.51,56.9 v5(167.42,57) ; C1614.2 86.65,70.12 v2(86.62,70.09) 86.6,70.06 C1612.2 ; v2(274.96,64.97) 274.6,65.34 C2826.2 ; v2(122.05,99.17) 122.02,99.14 R0506.1 ; R2319.2 237.88,39.82 v2(237.67,39.62) ; v2(87.84,68.16) 87.97,68.28 C1615.1 88.39,68.79 88.97,69.37 89.54,69.37 89.77,69.61 R1619.2 ; C2306.2 v2(239.48,42.32) ; v2(113.14,46.46) 113.14,46.21 113.77,45.57 R1719.2 ; C3105.2 277.88,58.15 v2(278.11,57.92) ; v5(199.05,122.01) 198.84,122.23 C7756.2 ; C2406.1 254.24,71.38 v2(254.01,71.61) ; v2(142.78,60.84) 142.53,61.09 R7006.2 ; C2310.2 v2(242.55,78.26) ; C7947.2 186.36,50.45 v5(186.31,50.5) ; v2(240.29,75.19) 240.06,75.19 239.83,74.96 R2479.2 239.86,74.51 R2165.2 ; U9700.24 199.12,188.7 R9727.2 ; R1515.2 38.55,16.02 38.26,15.73 v2(38.26,15.25) ; v2(284.21,104.76) 284.21,104.4 283.78,103.97 R5017.1 ; C2204.2 246.44,53.68 v2(246.84,53.68) ; 66.43,67.75 66.43,67.75 C1603.1 65.77,68.79 v2(65.77,68.79) ; v2(122.66,97.9) 122.54,98.03 R0507.2 ; C4404.1 178.54,23.15 178.95,23.55 v2(178.95,24.15) ; v5(187.18,138.3) 187.22,138.34 C7732.2 ; C9120.2 257.94,80.3 v2(257.92,80.32) ; v2(283.5,55.73) 283.85,55.73 283.9,55.79 C1229.2 284.13,56.24 R1133.2 ; R3003.2 152.51,21.83 152.81,21.52 v2(152.81,20.86) ; C8069.1 75.34,177.98 74.61,177.25 v2(74.61,176.89) ; C3321.2 278.06,105.11 277.98,105.19 v2(277.98,105.2) ; R7470.1 134.98,90.15 v2(134.47,90.15) ; R3007.1 159.82,29.98 160.35,30.51 v2(160.71,30.51) ; v2(69.32,122.28) 69.3,122.31 R0742.2 R1015.2 ; R7425.1 137.78,89.76 138.1,90.08 v2(138.49,90.08) ; v2(63.58,176.71) 63.58,176.67 C8031.1 ; SR4410.2 C4402.2 54.96,127.46 v2(55.25,127.74) ; C2828.2 272.38,62.98 v2(271.94,62.98) ; C7403.2 148.01,64.04 147.73,63.76 v2(147.73,63.66) ; v2(210.6,69.85) 210.9,69.54 C2502.2 ; v2(149.43,56.26) 149.43,56.75 R7459.1 ; C3621.2 14.92,21.09 C3620.2 14.59,22.03 14.22,22.03 v2(14.2,22.04) ; C7932.2 186.5,46.31 v5(186.31,46.5) ; v2(165.14,18.03) 165.14,18.33 164.45,19.03 R3045.2 ; C80104.1 v2(47.68,189.47) ; R0741.2 69.7,124.06 v2(70.03,124.39) ; v2(70.9,143.62) C8068.1 ; v2(290.68,85.33) 290.81,85.2 C1304.2 ; v2(84.24,71.84) 84.24,71.84 R1612.2 ; C7729.2 184.61,141.71 v5(184.51,141.6) ; v5(160.35,137.82) C7652.2 ; R0734.1 70.65,103.2 ; v2(149.54,62.58) 149.59,62.58 149.6,62.59 150.02,62.59 C7404.2 ; R7502.2 160.74,43.5 160.48,43.24 v2(160.48,42.17) ; C8065.1 v2(66.48,146.54) ; v2(149.55,54.96) 149.41,54.82 R7486.2 ; v2(115.65,186.37) 116.01,186.72 R4524.1 ; v2(212.48,42.22) 212.17,42.22 211.94,42.45 R6116.2 R2201.2 ; C4536.2 108.82,188.88 108.82,190.23 108.44,190.61 v2(108.24,190.61) ; C8716.2 125.84,151.87 v2(125.89,151.82) ; v2(76.71,70.7) 76.54,70.87 C1620.2 ; R7484.2 148.11,46.67 148.09,46.64 v2(148.09,46.6) ; C9411.2 100.69,164.19 100.18,163.68 v2(100.18,163.43) ; 233.74,74.78 v2(233.74,75.36) ; v5(156.07,52.39) 155.87,52.59 C7953.2 ; C4526.1 R4505.1 119.79,190.68 119.41,191.07 v2(119.41,191.24) ; C2201.2 v2(228.51,75.35) ; C2301.2 v2(243.44,78.26) ; v2(108.25,189.34) 107.85,188.95 C4539.2 ; v2(122.64,147.78) 122.38,147.78 122.03,147.43 C9608.2 ; v2(138.79,107.11) 138.97,106.93 R7009.2 ; v2(144.47,55.06) 144.44,55.03 C7410.2 ; C7841.2 v2(203.18,75.27) ; C8815.2 146.03,15.48 v2(146.41,15.09) ; v5(196.64,122.02) 196.69,122.07 C7751.2 ; v5(156.39,47.8) 156.33,47.73 C7955.2 ; v2(253.5,82.4) 253.24,82.66 C8908.2 ; v2(286.49,45.35) 286.9,44.94 R1171.1 R1168.1 ; C3320.2 280.33,105 v2(280.04,105.29) ; v2(281.29,111.11) 281.65,111.48 C5007.1 ; v2(250.88,76.59) C2404.1 ; C7401.2 152.84,63.35 v2(152.99,63.51) ; R1717.2 v2(85.4,41.46) ; v2(290.68,86.34) 290.81,86.21 C1303.2 ; v3(149.55,73.09) 150.02,72.62 R7456.2 ; C4545.2 v2(106.36,192.18) ; R8709.1 v2(130.16,165.84) ; C1315.2 294.57,88.3 v2(294.49,88.37) ; v5(167.46,59.25) 167.58,59.37 C7950.2 ; v2(247.33,61.55) 248.01,61.55 R2263.2 ; v5(160.34,130.95) 160.29,131 C7624.2 ; v2(128.66,162.69) 128.73,162.77 C8702.2 ; C7951.2 155.98,50.02 v5(156.03,50.07) ; C2300.2 v2(244.33,78.26) ; R8601.2 121.01,58.43 v2(120.86,58.27) 120.86,57.82 121.09,57.59 C8607.2 ; v2(107.55,41.51) 107.63,41.59 R1716.2 ; C1604.2 97.09,70.64 ; C1826.2 v2(104.32,41.51) ; v2(163.98,23.71) 163.51,24.19 C3005.2 ; v2(137.9,61.75) 137.62,61.48 R7430.1 ; v2(272.55,58.86) 272.73,59.04 R3168.2 ; R9406.2 v2(103.44,164.47) ; C9703.2 200.34,188.62 U9700.23 ; SR9401.1 v2(102.6,162.64) ; C1613.1 84.95,68.06 ; C7626.2 153.15,131.4 v5(152.57,131.4) ; R7435.2 v2(153.87,66.9) ; R1715.2 v2(103.54,41.51)
  BOTTOM w0.457: R0504.1 121.65,101.07 v2(122.08,100.64) ; R2258.2 R6120.2 v2(215.37,42.32) ; C3309.2 276.6,103.46 C3322.2 ; C0702.2 123.07,79.48 v2(123.3,79.26) ; R2112.2 v2(226.29,42.32) ; v2(62.06,181.03) 62.06,180.27 R8092.1 ; R2145.2 223.96,40.24 v2(223.37,39.65) ; v2(240.87,77.93) 240.9,77.93 241.16,77.68 R2477.2 ; R7404.1 v2(137.93,68.79) ; C8035.1 61.07,180.37 61.45,180.75 v2(61.45,181) ; R6124.2 v2(216.26,42.32) ; R7416.1 v2(137.95,70.47) ; C4401.2 59.54,127.66 v2(59.62,127.74) ; C3311.2 274.77,101.31 v2(274.62,101.46) ; D6005.1 286.37,28.14 286.37,28.8 v2(286.11,29.05) ; R2261.2 v2(218.04,44.35) ; v2(139.55,75.81) C7216.2 ; R2257.2 v2(217.15,42.32) ; R7417.1 137.95,67.06 v2(137.9,67.01) ; C8028.2 v2(65.44,181.94) ; C8032.1 62.26,177.27 v2(62.16,177.17) ; v2(76.05,182.99) 75.93,182.86 75.93,182.4 ; R7413.1 v2(137.95,69.63) ; R7420.1 v2(137.95,71.3) ; R7211.1 137.34,76.55 v2(137.23,76.66) ; R2146.2 v2(221.6,42.32) ; R6114.2 v2(218.93,42.32) ; CON6002.6 U1301.43
  BOTTOM w0.508: R2801.2 94.17,14.33 93.96,14.54 v2(93.96,14.84) ; CON4402.14 170.9,15.58 170.9,15.58 v2(170.9,15.54) ; v2(204.58,18.9) 204.37,18.7 CON3104.16 ; U4502.2 110.72,186.42 v2(110.6,186.54) ; CON5501.13 319.5,88.31 ; CON5501.13 317.63,87.45 ; CON5501.13 321.37,87.45 ; 312.44,131.26 CON4601.21 ; CON4601.21 312.44,133.04 ; CON4601.21 311.06,132.15 ; v2(314.81,39.3) 314.81,39.86 ; v5(206.6,105.48) 207.04,105.92 C7860.2 ; D5504.2 307.88,81.62 v2(307.63,81.87) ; C3309.2 276.08,103.44 275.7,103.06 v2(275.7,103) ; CON4400.13 v2(148.85,7.09) ; CON3600.5 v2(5.72,20.1) ; Q5713.2 281.25,65.3 281.74,64.8 v2(281.74,64.35) ; C9709.2 200.77,187.05 U9700.22 ; v2(160.71,30.51) 160.71,30.04 R3040.2 ; CON5100.21 14.2,13.5 15.22,12.48 v2(15.22,12.17) ; v2(96.63,189.72) 96.9,189.45 CON5602.30 ; CON5103.77 18.84,19.35 18.52,19.67 v2(18.52,20.05) ; v2(216.76,69.47) v2(215.27,69.47) v2(213.08,69.47) 211.84,69.47 210.72,70.59 v2(209.49,70.59) v2(207.54,70.59) 206.5,70.59 205.67,69.75 v2(205.67,69.6) v2(205.67,67.43) 205.67,66.31 v2(206.23,65.75) 206.51,65.46 v2(208.4,65.46) 210.92,65.46 212.51,67.05 v2(213.16,67.05) 214.45,67.05 ; U8700.43 124.94,157.72 C8768.2 ; Q5703.2 232.42,26.75 v2(232.44,26.73) ; C7940.2 175.04,51.65 v5(175.11,51.72) ; CON5602.29 v2(80.1,189.39) ; v2(130.59,172.35) 131.21,171.72 Q5715.2 ; D5503.2 309.13,78.01 v2(309.2,78.09) ; v2(306.86,90.63) 307.07,90.84 307.07,92.12 CON5300.77 307.35,92.97 307.96,93.58 v2(308.46,93.58) ; C8066.1 v2(78.59,183.22) ; CON5001.2 262.42,84.78 261.7,84.06 260.98,84.06 259.84,82.91 v2(259.65,82.91) ; CON5000.5 v2(56.43,116.21) ; v5(204.68,86.28) 204.83,86.44 C7823.2 ; D6006.1 v2(285.03,31.16) ; v2(15.22,9.89) 15.21,9.9 CON5100.23 ; 313.71,121.95 CON4601.16 312.27,121.95 ; v2(63.81,187.41) 63.81,186.97 63.3,186.47 C8009.1 ; v2(159.42,30.54) 159.84,30.96 R3039.2 ; v2(154.97,20.89) 154.97,21.6 155.56,22.18 R3038.2 ; v5(207.4,121.4) 207.48,121.4 207.88,121.8 C7705.2 ; C8015.1 v2(62.8,187.41) ; C8012.2 v2(47.4,181.89) ; R4597.2 v2(111.49,181.59) ; v2(280.3,56.48) 279.91,56.1 U1104.3 ; CON5102.77 v2(30.05,19.35) ; C7812.2 205.49,105.79 v5(205.8,105.48) ; v2(305.59,87.97) U4801.1 ; CON5100.24 v2(25.8,8.82) ; C7737.2 175.95,139.58 v5(176.12,139.75) ; v2(168.84,50.83) 168.8,50.88 C7922.2 167.11,50.88 v5(167.02,50.8) ; v2(135.13,75.95) 135.27,75.81 135.74,75.81 X7200.2 ; CON5001.5 257.37,89.41 v2(258.17,90.2) ; C1000.2 122,104.35 122.51,103.84 v2(122.51,103.7) ; CON6002.4 298.85,81.85 U1301.44 ; v2(253.73,69.55) 253.6,69.43 Y2500.3 ; CON4601.2 313.04,129.72 ; D6002.2 293.1,28.14 v2(293.49,27.75) ; CON4400.14 v2(139.15,7.32) ; Q7600.2 v2(157.55,140.16) ; v2(128.35,84.28) 128.73,84.67 Q5714.2 ; CON6002.5 U1301.49 ; H62.1 300.51,125.25 ; H62.1 297,121.74 ; H62.1 293.49,125.25 ; v5(209.49,120.11) 210.33,120.11 C7760.2 ; v2(273.92,48.67) 274.13,48.46 U1105.3 ; v2(209.44,66.07) 209.44,66.88 Y2501.2 ; U1301.42 298.85,85.55 CON6002.3 ; v2(283.14,108.67) 282.71,108.67 282.2,108.16 U5003.2 ; U4501.2 v2(104.76,186.29) ; v2(5.94,26.76) CON3600.6 ; C3622.2 10.55,19.18 10.14,18.78 v2(9.25,18.78) ; C8721.2 130.45,155.08 130.28,154.92 v2(129.77,154.92) ; v5(207.85,75.63) 208.3,75.18 C7863.2 ; v2(240.65,14.71) 240.71,14.78 Q8810.2 ; v2(317.1,39.3) 317.1,39.86 ; 312.31,124.45 CON4601.11 310.77,124.45 ; v2(17.25,30.72) 16.75,31.22 D6701.2 ; Y2501.4 206.87,69.33 v2(206.61,69.07) ; C7640.2 141.16,140.01 v5(141.47,139.7) ; D6702.2 16.75,35.59 v2(15.65,36.68) ; U5003.4 v2(280.52,110.14) ; 320.02,133.41 CON4601.23 ; CON4601.23 321.4,134.3 ; CON4601.23 318.64,134.3 ; v2(49.89,122.92) 50.78,122.92 51.38,122.32 CON5000.2 ; CON4800.20 317.36,109.85 ; CON4800.20 315.8,110.81 ; CON4800.20 314.34,109.85 ; Q0702.2 v2(67.48,128.86) ; 311.54,119.67 CON4601.19 ; CON4601.19 312.31,120.45 ; CON4601.19 310.77,120.45 ; R1007.1 v2(63.94,107.3) ; v5(148.4,141.16) 148.4,141.88 C7663.2 149.2,141.99 v5(149.2,141.16) ; v2(208.41,90.08) 208.25,89.91 Q7800.2 ; CON5103.76 21.38,40.05 22.82,38.62 22.82,37.32 22.43,36.94 v2(22.21,36.94) ; v2(208.37,110.29) 208.51,110.15 C7766.2 ; v2(275.7,54.9) 275.44,54.64 U3103.2 ; 310.77,127.45 CON4601.5 312.31,127.45 ; v2(309.48,47.91) 309.48,47.63 309,47.15 D5502.2 ; v2(90.64,42.51) 90.28,42.15 C1822.2 ; Q7900.2 170.4,46.14 169.97,46.58 v2(169.97,46.87) ; v2(271.53,96.86) 271.42,96.97 271.42,97.54 271.92,98.04 Q5711.2 ; 319.5,71.01 CON5501.12 317.76,71.75 ; R8834.1 240.01,14.28 v2(240.01,14.71) ; v2(268.13,88.17) 268.11,88.15 CON5001.6 266.22,90.22 v2(264.98,91.47) ; C3619.2 17.35,24.77 v2(17.41,24.77) ; v5(207.23,86.25) 207.64,86.66 C7811.2 ; R6005.2 v2(34.88,57.77) ; Y2500.2 253.57,70.33 v2(253.73,70.18) ; v5(204.87,121.37) 204.87,122.14 C7764.2 ; v5(160.35,139.41) 159.79,139.41 C7611.2 159.98,140.29 v5(160.41,140.29) ; CON4601.22 312.44,116.64 ; CON4601.22 311.06,115.75 ; CON4601.22 312.44,114.86 ; C7838.2 206.38,94.24 v5(205.98,94.64) ; Q5712.2 276.22,70.05 v2(276.69,69.58) ; v2(319.51,39.3) 319.51,39.99 ; v2(140.09,38.74) 140.09,37.93 140.76,37.26 Q5706.2 ; v2(53.19,15.73) 53.19,15.48 53.85,14.82 CON5104.76 ; v2(135.19,65.49) 134.83,65.84 U7401.4 ; U8900.22 247.04,81.1 246.05,81.1 C8910.2 ; CON4601.24 320.02,114.49 ; CON4601.24 318.64,113.6 ; CON4601.24 321.4,113.6 ; D6003.2 291.57,31.5 291.65,31.58 v2(291.65,31.97) ; D5501.2 307.45,46.53 v2(307.63,46.34) ; U3600.52 11,31.83 CON6700.46 ; v2(12.22,58.14) 12.21,58.12 11.23,58.12 CON6700.47 11.59,58.94 v2(12.17,58.94) ; v2(26.4,14.97) 26.4,14.5 CON5100.22 ; CON5102.76 32.51,40.05 33.31,39.25 v2(33.31,38.46) ; C7912.2 167.41,48.01 v5(167.02,48.4) ; 319.5,60.91 CON5500.13 317.63,60.05 ; Q7700.2 v2(206.66,127.18) ; v4(186.92,175.24) 186.29,174.61 186.29,172.1 C9725.2 ; v5(152.55,139.98) 152.93,140.35 C7660.2 ; v2(24.84,69.02) CON6003.3 ; v5(187.21,140.03) 187.96,140.78 C7710.2 ; R2802.2 97.13,14.32 v2(97.64,14.84) ; Q4501.2 v2(101.93,182.77) ; 321,110.81 CON4800.22 319.54,109.85 ; v2(317.99,39.3) 317.99,39.86 ; Q5704.2 201.51,50.47 201.94,50.05 v2(201.94,49.66) ; 312.27,125.95 CON4601.8 ; C3104.2 276.08,51.16 v2(275.93,51.01) ; X7200.4 138.12,72.71 v2(137.32,71.91) ; Q5707.2 139.95,28.83 140.44,29.32 v2(140.44,30.69) ; CON4402.13 v2(180.6,15.54) ; v2(320.27,39.3) 320.27,39.99 ; CON6003.4 v2(26.65,73.1) ; v2(318.75,39.3) 318.75,39.99 ; v2(316.34,39.3) 316.34,39.99 ; v2(47.58,120.91) CON5000.6 ; v2(315.58,39.3) 315.58,39.99 ; CON3104.15 v2(214.35,20.35) ; C8005.2 v2(47.38,182.78)
  vias: v2(0.77,81.77) v2(0.77,79.23) v2(0.77,76.69) v2(0.77,74.15) v2(0.77,71.61) v2(0.77,69.07) v2(0.77,66.53) v2(0.77,63.99) v2(0.77,61.45) v2(0.77,58.91) v2(0.77,56.37) v2(0.77,53.83) v2(0.77,51.29) v2(0.77,48.75) v2(0.77,46.21) v2(0.77,43.67) v2(0.77,41.13) v2(0.77,38.59) v2(0.77,36.05) v2(0.77,33.51) v2(0.77,30.97) v2(0.77,29.83) v2(0.77,28.43) v2(0.77,27.54) v2(0.77,26.4) v2(0.77,25.13) v2(0.77,23.35) v2(0.77,20.81) v2(0.77,18.27) v2(0.77,15.73) v2(0.77,13.19) v2(0.77,10.65) v2(0.77,8.11) v2(1.4,18.4) v2(1.5,41) v2(1.47,16.36) v2(1.63,39.22) v2(1.63,38.59) v2(1.63,37.32) v2(2.34,52.62) v2(2.27,5.26) v2(2.39,54.85) v2(2.98,52.6) v2(3.92,23.86) v2(3.92,23.22) v2(3.92,22.59) v2(4.43,82.71) v2(4.81,5.26) v2(5.44,46.59) v2(6.08,46.59) v2(7.35,5.26) v2(7.85,83.75) v2(7.98,46.59) v2(8.62,46.59) v2(8.69,78.26) v2(9.53,62.01) v2(9.89,5.26) v2(10.04,48.72) v2(10.14,54.59) v2(10.73,49.49) v2(10.78,82.18) v2(10.9,56.37) v2(10.9,54.97) v2(11.39,82.18) v2(11.54,85.17) v2(11.79,56.37) v2(11.79,54.97) v2(11.79,53.58) v2(12,82.18) v2(12.43,5.26) v2(14.26,83.07) v2(14.26,82.46) v2(14.26,81.85) v2(14.84,47.23) v2(14.97,86.85) v2(14.97,5.26) v2(15.32,36.13) v2(15.6,61.63) v2(15.6,60.99) v2(16.11,28.23) v2(16.8,25.97) v2(17.13,44.3) v2(17.13,43.67) v2(17.51,5.26) v2(18.01,77.25) v2(18.4,88.88) v2(18.83,54.57) v2(18.91,11.45) v2(18.89,10.79) v2(19.53,10.79) v2(20.05,5.26) v2(20.16,10.79) v2(20.89,87.81) v2(20.89,87.18) v2(21.49,87.18) v2(21.6,91.17) v2(22.59,5.26) v2(23.35,23.22) v2(23.35,22.59) v2(23.35,21.95) v2(23.35,21.32) v2(24.36,93.45) v2(24.64,81.62) v2(24.7,88.6) v2(24.7,87.99) v2(24.7,87.36) v2(24.7,86.72) v2(25.13,5.26) v2(25.18,89.14) v2(25.25,81.62) v2(25.51,54.46) v2(26.27,54.46) v2(26.4,90.28) v2(27.18,35.19) v2(27.54,96.63) v2(27.67,5.26) v2(27.86,29.17) v2(27.9,26.09) v2(27.9,10.52) v2(28.07,21.56) v2(28.07,20.95) v2(28.38,39.61) v2(28.38,38.97) v2(28.38,38.34) v2(28.35,37.73) v2(28.43,14.18) v2(28.48,10.17) v2(28.68,12.35) v2(30.08,99.68) v2(30.21,5.26) v2(31.98,96.12) v2(32.16,102.6) v2(32.49,96.5) v2(32.75,5.26) v2(33.01,28.53) v2(33.31,36.2) v2(33.28,35.59) v2(33.64,27.06) v2(33.89,105.39) v2(33.88,35.92) v2(33.88,35.29) v2(34.04,29.62) v2(34.14,37.95) v2(34.14,12.81) v2(34.35,43.57) v2(34.45,27.16) v2(34.42,24.42) v2(34.78,12.81) v2(34.88,57.13) v2(34.88,56.34) v2(35.29,10.9) v2(35.29,5.26) v2(35.36,108.31) v2(35.41,12.81) v2(35.67,42.02) v2(35.87,43.64) v2(35.87,27.06) v2(35.92,10.9) v2(36.61,111.23) v2(36.56,10.9) v2(37.19,10.9) v2(37.52,41.84) v2(37.57,113.9) v2(37.83,40.67) v2(37.83,10.9) v2(37.83,5.26) v2(38.31,116.44) v2(38.82,39.3) v2(38.92,118.98) v2(39.35,121.52) v2(39.53,114.56) v2(39.5,56.75) v2(39.66,124.06) v2(39.83,126.6) v2(39.78,118.83) v2(39.78,57.72) v2(39.87,192.59) v2(39.87,190.05) v2(39.87,187.51) v2(39.87,184.97) v2(39.87,182.43) v2(39.87,179.89) v2(39.87,177.35) v2(39.87,174.81) v2(39.87,172.27) v2(39.87,159.57) v2(39.87,157.03) v2(39.87,154.49) v2(39.87,151.95) v2(39.87,149.41) v2(39.88,131.68) v2(39.88,129.14) v2(40.09,55.07) v2(40.07,52.33) v2(40.09,37.09) v2(40.09,35.72) v2(40.31,54.51) v2(40.37,5.26) v2(40.71,26.35) v2(40.85,62.85) v2(41.18,54.97) v2(41.18,54.34) v2(41.41,132.01) v2(41.51,153.27) v2(41.56,188.91) v2(41.56,129.29) v2(42.27,133.2) v2(42.27,116.19) v2(42.27,115.55) v2(42.4,192.92) v2(42.42,43.29) v2(42.37,25.68) v2(42.53,152.15) v2(42.53,10.9) v2(42.63,55.37) v2(42.63,54.74) v2(42.63,54.13) v2(42.65,148.77) v2(42.78,47.76) v2(42.91,5.26) v2(43.01,75.8) v2(43.16,10.9) v2(43.29,69.93) v2(43.29,69.32) v2(43.31,67.02) v2(43.31,66.39) v2(43.6,54.06) v2(43.77,171.43) v2(43.78,26.05) v2(43.8,10.9) v2(43.92,51.35) v2(43.97,59.39) v2(44,48.87) v2(44.05,16.77) v2(44.3,61.22) v2(44.3,43.29) v2(44.43,72.55) v2(44.61,132.06) v2(44.68,37.32) v2(44.68,36.68) v2(44.94,192.92) v2(44.91,149.64) v2(45.11,51.34) v2(45.19,148.47) v2(45.32,37.32) v2(45.41,63.25) v2(45.45,5.26) v2(45.57,133.61) v2(45.65,67.09) v2(45.65,66.45) v2(46.21,188.14) v2(46.52,55.33) v2(46.52,54.06) v2(46.66,50.94) v2(46.72,36.68) v2(46.74,30.41) v2(47.15,55.33) v2(47.15,54.06) v2(47.35,147.5) v2(47.48,192.92) v2(47.68,37.4) v2(47.99,5.26) v2(48.32,135.24) v2(48.32,29.45) v2(48.39,48.37) v2(48.55,51.26) v2(49.03,58.91) v2(48.95,37.4) v2(49.13,179.23) v2(49.05,60.76) v2(49.23,145.78) v2(49.16,54.13) v2(49.51,31.81) v2(50.02,192.92) v2(50.04,48.65) v2(50.12,67.01) v2(50.07,51.28) v2(50.15,29.45) v2(50.17,137.78) v2(50.5,143.36) v2(50.53,43.29) v2(50.53,5.26) v2(50.86,140.57) v2(51.17,50.63) v2(51.34,51.22) v2(51.34,32.04) v2(51.52,54.06) v2(52.03,29.45) v2(52.28,25.46) v2(52.56,192.92) v2(52.66,55.33) v2(52.76,61.27) v2(53.05,189.84) v2(53.02,48.22) v2(53.06,66.89) v2(53.07,59.54) v2(53.07,43.29) v2(53.07,5.26) v2(53.24,30.28) v2(53.52,6.84) v2(53.63,125.64) v2(54.04,57.83) v2(54.24,125.64) v2(54.25,49.31) v2(54.31,25.46) v2(54.34,8.49) v2(54.67,55.1) v2(54.74,54.13) v2(55.1,192.92) v2(55.28,30.28) v2(55.48,43.29) v2(55.51,24.98) v2(55.6,50.94) v2(55.66,51.55) v2(56.11,43.29) v2(56.62,8.77) v2(56.72,66.83) v2(56.72,66.22) v2(56.76,62.67) v2(57.16,30.23) v2(57.38,16.11) v2(57.49,24.78) v2(57.64,192.92) v2(57.77,43.29) v2(57.94,169.15) v2(57.94,168.51) v2(57.94,167.88) v2(57.94,167.24) v2(57.94,166.61) v2(57.94,48.65) v2(58.02,16.11) v2(58.43,62.47) v2(58.39,61.53) v2(58.4,43.29) v2(58.5,59.53) v2(58.55,66.94) v2(58.55,66.3) v2(59,55.34) v2(59.11,30.21) v2(59.16,8.77) v2(59.29,63.41) v2(59.26,47.56) v2(59.36,69.77) v2(59.37,51.57) v2(59.37,50.95) v2(59.67,16.62) v2(60.18,192.92) v2(60.31,16.62) v2(60.56,43.29) v2(61.19,43.29) v2(61.31,66.94) v2(61.31,66.3) v2(61.65,55.35) v2(61.7,8.77) v2(62.72,192.92) v2(63.2,58.27) v2(63.23,43.29) v2(63.77,54.24) v2(63.79,51.42) v2(64.24,8.77) v2(64.52,38.13) v2(64.93,189.36) v2(65.26,192.92) v2(65.49,42.45) v2(65.72,57.89) v2(65.71,55.34) v2(65.77,66.87) v2(66.25,38.13) v2(66.68,33.43) v2(66.99,6.46) v2(66.99,3.92) v2(66.99,1.38) v2(67.8,192.92) v2(68.18,5.7) v2(68.36,38.13) v2(68.41,33.43) v2(68.81,5.7) v2(68.99,67.18) v2(69.15,43.08) v2(69.45,0.77) v2(70.19,13.51) v2(70.4,106.54) v2(70.52,33.43) v2(70.52,28.1) v2(70.75,38.11) v2(71.2,70.02) v2(71.2,69.38) v2(71.2,68.77) v2(71.56,54.7) v2(71.74,21.19) v2(71.84,115.2) v2(71.99,0.77) v2(72.27,114.76) v2(72.29,43.06) v2(72.9,33.41) v2(72.9,28.07) v2(73.54,42.96) v2(73.55,55.36) v2(73.58,54.75) v2(73.74,38.11) v2(74.53,0.77) v2(74.73,21.19) v2(75.21,51.23) v2(75.8,48.67) v2(75.83,48.04) v2(75.91,54.68) v2(75.9,33.41) v2(75.9,28.07) v2(75.93,4.17) v2(75.93,3.54) v2(76.31,50.31) v2(76.41,58.33) v2(76.51,61.11) v2(76.56,4.17) v2(76.56,3.54) v2(76.74,68.28) v2(76.89,62.81) v2(76.87,42.27) v2(77.15,38.11) v2(77.07,0.77) v2(77.4,46.49) v2(78.75,62.6) v2(78.75,60.77) v2(78.97,4.17) v2(78.97,3.54) v2(79.27,54.72) v2(79.31,33.41) v2(79.31,28.07) v2(79.43,191.93) v2(79.61,4.17) v2(79.61,3.54) v2(79.61,0.77) v2(80.37,70.35) v2(80.37,69.74) v2(81.97,191.93) v2(82.15,0.77) v2(82.38,183.22) v2(83.8,70.37) v2(84.23,70.85) v2(84.51,191.93) v2(84.66,95.61) v2(84.69,0.77) v2(84.89,98.41) v2(85.38,98.84) v2(85.63,68) v2(85.61,67.02) v2(85.61,66.38) v2(85.67,55.35) v2(85.81,99.27) v2(85.81,58.12) v2(86.57,54.41) v2(86.72,38.16) v2(86.98,33.43) v2(87.05,191.93) v2(87.13,43.14) v2(87.23,0.77) v2(87.85,51.32) v2(88.11,46.34) v2(88.12,43.14) v2(88.27,55.05) v2(89.59,191.93) v2(89.74,43.12) v2(89.77,0.77) v2(90,28.1) v2(90.13,38.16) v2(90.35,61.44) v2(90.37,51.18) v2(90.37,49.85) v2(90.38,33.43) v2(90.43,0.77) v2(90.46,48.29) v2(90.57,45.89) v2(90.64,43.17) v2(90.76,59.76) v2(90.96,68.26) v2(91.04,54.52) v2(91.43,54.04) v2(91.51,43.12) v2(91.57,57.84) v2(91.57,45.92) v2(91.72,55.22) v2(91.7,54.59) v2(91.88,98.85) v2(91.87,97) v2(91.86,94.91) v2(92.01,58.27) v2(92.13,191.93) v2(92.31,0.77) v2(92.61,3.51) v2(92.68,45.9) v2(93.1,43.06) v2(93.1,42.45) v2(93.28,55.33) v2(93.4,28.1) v2(93.94,66.91) v2(93.88,59.52) v2(93.99,61.14) v2(93.96,38.21) v2(94.27,49.6) v2(94.27,33.41) v2(94.37,50.61) v2(94.67,191.93) v2(94.67,45.88) v2(94.79,43.09) v2(94.85,0.77) v2(95.15,48.34) v2(95.26,55.2) v2(95.5,67) v2(95.53,50.64) v2(95.62,45.97) v2(95.66,54.74) v2(95.67,43.17) v2(95.89,180.47) v2(96.32,70.24) v2(96.32,69.63) v2(96.5,180.37) v2(96.81,99.63) v2(96.93,58.48) v2(96.93,57.87) v2(97.21,191.93) v2(97.39,0.77) v2(97.53,54.15) v2(97.63,55.33) v2(97.64,50.65) v2(97.69,70.38) v2(97.82,54.72) v2(98.38,46.79) v2(98.46,43.19) v2(98.46,42.58) v2(98.82,60.22) v2(98.81,45.87) v2(98.85,58.03) v2(99.07,51.54) v2(99.52,48.95) v2(99.66,192.93) v2(99.93,0.77) v2(100.01,46.08) v2(99.98,18.96) v2(100.11,58.2) v2(100.13,43.16) v2(100.44,66.85) v2(100.36,54.06) v2(100.93,51.29) v2(100.88,43.06) v2(101,55.33) v2(101,54.06) v2(101,46.08) v2(101.25,49.33) v2(101.63,54.5) v2(101.66,66.61) v2(101.83,58.48) v2(101.83,57.87) v2(101.9,43.13) v2(101.96,156.06) v2(101.99,46.11) v2(102.04,18.98) v2(102.15,46.71) v2(102.2,192.93) v2(102.22,192.13) v2(102.32,55.3) v2(102.47,0.77) v2(102.67,23.76) v2(103.15,46.04) v2(103.57,73) v2(103.58,72.28) v2(103.97,67.78) v2(104.02,55.33) v2(104.18,51.3) v2(104.39,46.07) v2(104.36,36.41) v2(104.5,192.13) v2(104.46,172.54) v2(104.45,66.71) v2(104.5,58.76) v2(104.52,46.68) v2(104.45,23.73) v2(104.74,192.93) v2(104.79,60.59) v2(104.81,47.68) v2(104.88,190.58) v2(104.88,49.23) v2(104.97,36.41) v2(105.01,0.77) v2(105.14,156.83) v2(105.14,156.19) v2(105.57,27.85) v2(105.77,156.83) v2(105.77,156.19) v2(105.8,58.17) v2(106.12,42.83) v2(106.28,182.99) v2(106.28,182.35) v2(106.28,181.72) v2(106.28,181.08) v2(106.53,186.93) v2(106.53,186.29) v2(106.51,18.98) v2(107.04,179.86) v2(106.97,42.83) v2(107.08,36.41) v2(107.28,192.93) v2(107.3,50.4) v2(107.35,27.85) v2(107.55,0.77) v2(107.67,54.04) v2(107.69,36.41) v2(107.75,67.09) v2(108.18,67.52) v2(108.16,66.58) v2(108.59,67.04) v2(108.79,75.99) v2(108.79,23.65) v2(108.77,18.96) v2(109.82,192.93) v2(109.96,99.14) v2(110.09,0.77) v2(110.39,98.71) v2(110.45,55.34) v2(110.6,187.18) v2(110.67,190.66) v2(110.88,98.33) v2(112.21,192.92) v2(112.48,5.54) v2(112.63,0.77) v2(113.06,179.89) v2(113.16,61.64) v2(113.16,61.03) v2(113.16,60.42) v2(113.16,59.79) v2(114,55.84) v2(114.9,192.93) v2(114.9,189.3) v2(114.87,55.81) v2(114.97,179.89) v2(115.2,60.33) v2(115.2,59.72) v2(115.2,5.57) v2(115.17,0.77) v2(115.47,54.46) v2(115.47,53.86) v2(115.47,53.25) v2(115.47,52.64) v2(115.47,49.51) v2(115.55,65.56) v2(115.55,64.95) v2(115.55,64.35) v2(115.55,63.74) v2(115.55,63.13) v2(115.7,55.84) v2(115.8,59.72) v2(116.47,18.73) v2(116.57,55.81) v2(116.82,42.55) v2(117.07,18.73) v2(117.34,47.25) v2(117.44,192.93) v2(117.43,179.89) v2(117.37,46.62) v2(117.37,45.17) v2(117.36,41.51) v2(117.48,42.55) v2(117.58,186.54) v2(117.68,18.73) v2(117.71,0.77) v2(118,47.25) v2(117.98,46.62) v2(117.98,45.14) v2(117.99,41.51) v2(118.22,186.54) v2(118.85,179.81) v2(118.95,107.8) v2(119.11,150.98) v2(119.11,150.35) v2(119.26,18.75) v2(119.74,76.21) v2(119.82,186.52) v2(119.82,180.37) v2(119.87,18.73) v2(119.98,192.93) v2(120.33,107.68) v2(120.25,0.77) v2(120.43,186.52) v2(120.35,76.82) v2(120.35,76.21) v2(120.48,18.73) v2(120.68,149.16) v2(120.66,123.32) v2(120.78,122.59) v2(120.76,106) v2(121.06,179.63) v2(121.24,166.3) v2(121.39,122.55) v2(121.67,166.73) v2(121.9,186.54) v2(122.03,180.22) v2(122,122.56) v2(122.15,166.3) v2(122.52,192.93) v2(122.56,166.76) v2(122.61,122.56) v2(122.63,35.41) v2(122.57,18.75) v2(122.79,179.74) v2(122.79,0.77) v2(123.04,166.3) v2(123.22,122.54) v2(123.18,18.75) v2(123.48,166.76) v2(123.79,18.75) v2(123.93,166.33) v2(124.29,179.92) v2(124.48,59.26) v2(124.69,58.53) v2(124.69,57.89) v2(124.69,57.26) v2(124.69,56.62) v2(124.9,8.9) v2(125.06,192.93) v2(125.33,58.53) v2(125.33,57.89) v2(125.33,57.26) v2(125.33,56.62) v2(125.33,0.77) v2(125.51,18.75) v2(125.92,123.74) v2(126.12,18.75) v2(126.73,18.75) v2(127.21,123.78) v2(127.6,192.93) v2(127.72,166.76) v2(127.87,0.77) v2(128.15,166.3) v2(128.3,83.67) v2(128.35,18.75) v2(128.73,8.9) v2(128.96,18.75) v2(129.57,18.75) v2(129.96,75.13) v2(129.96,74.52) v2(129.96,73.89) v2(129.96,73.25) v2(130.14,192.93) v2(130.41,0.77) v2(130.69,87.66) v2(130.69,85.81) v2(130.74,83.19) v2(130.81,18.75) v2(130.79,6.84) v2(131.02,153.3) v2(131.17,151.47) v2(131.42,18.75) v2(131.43,6.84) v2(132.03,18.75) v2(132.62,152.74) v2(132.65,18.75) v2(132.77,151.67) v2(132.95,0.77) v2(133.18,89.31) v2(133.2,87.46) v2(133.2,85.61) v2(134.47,91.4) v2(134.47,90.79) v2(134.48,18.75) v2(134.47,6.84) v2(135.09,18.75) v2(135.11,6.84) v2(135.17,81.54) v2(135.49,0.77) v2(135.7,18.75) v2(137.06,87.3) v2(137.12,83.47) v2(137.73,93.89) v2(137.67,87.3) v2(137.88,3.49) v2(138.03,0.77) v2(138.28,87.3) v2(138.89,87.3) v2(139,83.4) v2(139.35,84.21) v2(139.5,87.29) v2(139.55,76.65) v2(140.16,76.65) v2(140.3,192.93) v2(140.57,0.77) v2(141.03,84.74) v2(141.31,81.17) v2(141.92,81.15) v2(142.17,3.49) v2(142.27,165.72) v2(142.84,192.93) v2(143.11,0.77) v2(144.05,166.35) v2(145.38,192.93) v2(145.65,0.77) v2(146.13,3.54) v2(147.92,192.93) v2(148.19,0.77) v2(148.82,56.13) v2(150.04,56.45) v2(150.46,192.93) v2(150.73,0.77) v2(151.21,3.56) v2(151.54,7.2) v2(152.43,9.94) v2(153,192.93) v2(153.27,72.88) v2(153.27,72.24) v2(153.27,71.61) v2(153.27,70.97) v2(153.27,70.34) v2(153.27,0.77) v2(153.52,4.63) v2(155.54,192.93) v2(155.81,6.99) v2(155.81,0.77) v2(155.89,10.62) v2(156.7,165.72) v2(157.11,3.64) v2(158.08,192.93) v2(158.35,0.77) v2(158.48,166.35) v2(158.48,164.32) v2(160.62,192.93) v2(160.56,0.79) v2(160.74,5.52) v2(160.74,2.98) v2(160.81,8.06) v2(162.52,9.28) v2(163.16,192.93) v2(165.06,9.28) v2(165.49,14.26) v2(165.7,192.93) v2(167.6,9.28) v2(168.24,192.93) v2(168.36,14.18) v2(169.65,165.72) v2(170.14,9.28) v2(170.78,192.93) v2(171.43,166.35) v2(171.43,164.32) v2(172.68,9.28) v2(173.03,60.97) v2(173.01,59.04) v2(173.03,57.87) v2(172.95,56.42) v2(173.32,192.93) v2(174.3,120.15) v2(174.68,117.38) v2(174.8,46.43) v2(175.14,9.28) v2(175.86,192.93) v2(175.88,142.26) v2(176.21,120.25) v2(176.26,118.32) v2(178.06,9) v2(178.4,192.93) v2(180.07,7.07) v2(180.94,192.93) v2(181.72,164.95) v2(182.61,7.07) v2(183.48,192.93) v2(183.5,165.59) v2(183.5,163.56) v2(185.15,7.07) v2(187,44.62) v2(187.38,13.37) v2(187.69,7.07) v2(188.4,45.99) v2(190.23,7.07) v2(191.4,13.55) v2(192.77,7.07) v2(192.87,123.53) v2(193.64,192.93) v2(193.58,185.48) v2(194.42,20.38) v2(194.57,38.68) v2(194.7,123.53) v2(195,39.11) v2(195.08,184.64) v2(195.15,34.21) v2(195.31,7.07) v2(195.76,34.21) v2(196.12,75.17) v2(196.18,192.93) v2(196.32,20.38) v2(197.28,75.19) v2(197.85,7.07) v2(198.72,192.93) v2(199.24,75.17) v2(200.26,63.23) v2(200.39,7.07) v2(201.26,192.93) v2(201.35,66.48) v2(201.61,64.6) v2(202.62,67.9) v2(202.93,7.07) v2(203.8,192.93) v2(203.79,88.42) v2(203.84,61.02) v2(203.86,69.25) v2(203.86,58.6) v2(204.25,57.23) v2(204.45,55.2) v2(204.58,146.41) v2(205.09,70.62) v2(205.54,61.7) v2(205.47,7.07) v2(205.75,58.63) v2(206.13,57.24) v2(206.23,60.34) v2(206.34,192.93) v2(206.28,64.4) v2(206.38,55.2) v2(207.4,45.63) v2(207.55,49.08) v2(207.7,61.65) v2(207.65,39.45) v2(207.83,46.06) v2(208.01,7.07) v2(208.16,64.4) v2(208.88,192.93) v2(209.58,112.73) v2(209.58,111.93) v2(209.91,61.2) v2(210.55,7.07) v2(211.12,101.32) v2(211.1,99.3) v2(211.21,189.31) v2(211.21,186.77) v2(211.21,184.23) v2(211.21,181.69) v2(211.21,179.15) v2(211.21,176.61) v2(211.21,174.05) v2(211.21,171.53) v2(211.21,168.99) v2(211.21,166.45) v2(211.21,163.91) v2(211.21,161.37) v2(211.21,158.83) v2(211.21,156.29) v2(211.21,153.75) v2(211.21,151.21) v2(211.21,148.67) v2(211.21,146.13) v2(211.21,143.59) v2(211.21,141.05) v2(211.21,138.51) v2(211.21,135.97) v2(211.21,133.43) v2(211.21,130.89) v2(211.21,128.35) v2(211.36,125.81) v2(211.66,108.24) v2(211.8,105.6) v2(211.86,123.32) v2(212.43,110.09) v2(212.52,120.87) v2(212.66,97.82) v2(212.66,50.43) v2(212.96,103.72) v2(213.09,7.07) v2(213.34,118.46) v2(213.37,51.77) v2(213.52,54.13) v2(213.65,49.69) v2(213.93,28.3) v2(214.05,111.61) v2(214.08,73.77) v2(214.31,116.12) v2(214.28,98.53) v2(214.31,75.57) v2(214.28,65.34) v2(214.76,102.55) v2(214.84,56.8) v2(215.17,53.73) v2(215.17,50.6) v2(215.22,28.3) v2(215.43,113.84) v2(215.63,7.07) v2(216.06,65.06) v2(216.34,75.62) v2(216.39,70.54) v2(216.74,73.9) v2(216.9,48.11) v2(217.18,102.24) v2(218.17,7.07) v2(218.41,67.6) v2(218.49,70.72) v2(219.08,63.54) v2(219.06,61.32) v2(219.39,103.05) v2(219.92,67.6) v2(220.38,53.31) v2(220.53,67.6) v2(220.48,58.91) v2(220.63,50.2) v2(220.71,62.51) v2(220.71,7.07) v2(220.78,66.4) v2(220.81,52.05) v2(220.88,61.32) v2(221.12,60.13) v2(221.21,75.9) v2(221.29,50.45) v2(221.39,67.44) v2(221.39,66.4) v2(221.74,65.13) v2(221.85,60.11) v2(221.85,29.41) v2(222.1,52.79) v2(222.54,62.51) v2(222.48,53.88) v2(222.46,51.39) v2(222.46,29.41) v2(222.61,66.07) v2(222.79,18.07) v2(223.07,7.07) v2(223.44,72.83) v2(223.37,31.86) v2(223.6,68.1) v2(223.6,67.47) v2(223.55,65.16) v2(223.93,103) v2(223.88,7.07) v2(224.01,31.86) v2(224.64,70.26) v2(224.73,67.73) v2(224.73,67.11) v2(224.73,66.48) v2(224.73,65.87) v2(224.75,64.65) v2(224.69,63.66) v2(224.72,52.66) v2(224.72,52.05) v2(225.28,70.26) v2(225.79,7.07) v2(225.89,101.38) v2(225.86,68.1) v2(225.86,67.49) v2(225.86,66.88) v2(225.86,64.27) v2(225.86,63.66) v2(225.91,19.67) v2(226.55,19.67) v2(226.9,70.25) v2(227,67.14) v2(227,66.53) v2(227,64.5) v2(227.03,61.65) v2(227.01,60.1) v2(227.01,59.35) v2(226.97,52.11) v2(227.36,98.66) v2(227.82,60.1) v2(227.8,59.35) v2(227.97,99.88) v2(228.05,64.42) v2(228.06,67.97) v2(228.06,67.34) v2(228.2,63.66) v2(228.2,55.15) v2(228.2,53.75) v2(228.2,53.14) v2(228.2,52.53) v2(228.2,51.92) v2(228.33,7.07) v2(228.58,99.47) v2(229.34,98.99) v2(229.34,66.15) v2(229.34,63.66) v2(229.34,55.48) v2(229.34,54.14) v2(229.34,53.53) v2(229.34,51.37) v2(229.35,65.11) v2(230.1,98.54) v2(230.45,66.55) v2(230.38,64.55) v2(230.48,54.8) v2(230.48,54.19) v2(230.48,53.58) v2(230.48,51.87) v2(230.48,51.26) v2(230.87,7.07) v2(231.68,65.92) v2(231.68,65.31) v2(231.68,64.7) v2(231.74,52.44) v2(231.76,55.4) v2(231.78,54.38) v2(232.21,60.23) v2(232.26,62.51) v2(232.37,97.34) v2(232.64,58.96) v2(232.69,68.09) v2(232.72,65.23) v2(232.72,64.49) v2(232.76,54.39) v2(232.76,51.91) v2(232.77,15.35) v2(232.9,62.51) v2(233.03,60.23) v2(233.03,56.67) v2(233.28,58.96) v2(233.41,15.35) v2(233.41,7.07) v2(233.62,53.48) v2(233.62,52.87) v2(233.66,60.23) v2(233.79,95.79) v2(233.85,66.63) v2(233.81,65.56) v2(233.79,64.49) v2(233.91,58.96) v2(234.04,15.35) v2(234.42,95.71) v2(234.45,65.56) v2(234.68,96.29) v2(234.73,67.47) v2(234.73,66.63) v2(234.78,52.82) v2(235.1,57.75) v2(235.24,77.91) v2(235.26,56.74) v2(235.34,51.49) v2(235.36,67.47) v2(235.36,65.56) v2(235.46,95.97) v2(235.64,95) v2(235.67,66.63) v2(235.95,51.49) v2(235.95,7.07) v2(236.25,95.66) v2(236.28,94.98) v2(236.3,66.63) v2(236.47,64.47) v2(236.58,65.56) v2(236.56,10.85) v2(236.99,95.43) v2(237.23,25.21) v2(237.75,71.51) v2(237.75,70.9) v2(237.88,95.13) v2(237.9,77.38) v2(237.93,25.22) v2(237.98,12.61) v2(238.49,7.07) v2(238.61,94.93) v2(239.1,10.88) v2(239.33,94.73) v2(239.99,94.56) v2(240.72,94.39) v2(241.03,7.07) v2(241.89,94.14) v2(242.07,39.71) v2(242.22,11.03) v2(242.22,8.52) v2(242.61,38.99) v2(243.57,12.67) v2(243.74,38.41) v2(244.43,39.96) v2(244.58,91.29) v2(244.76,93.65) v2(244.99,93.07) v2(244.96,90.79) v2(245.17,92.49) v2(245.34,91.88) v2(245.57,91.3) v2(245.95,90.79) v2(245.95,38.44) v2(246.11,12.67) v2(246.26,39.96) v2(246.67,90.38) v2(247.58,90.28) v2(247.86,71.91) v2(248.24,90.25) v2(248.65,12.67) v2(250.27,90.23) v2(250.77,88.2) v2(251.19,12.67) v2(251.69,90.28) v2(252.79,90.35) v2(253.02,43.21) v2(253.19,61.78) v2(253.73,12.67) v2(255.25,90.63) v2(255.94,75.09) v2(256.22,49.31) v2(256.34,53.52) v2(256.27,12.67) v2(256.36,50.83) v2(256.5,81.34) v2(256.57,73.08) v2(256.57,72.47) v2(256.65,45.96) v2(257.03,12.67) v2(257.33,84.41) v2(257.57,91.95) v2(257.7,52.5) v2(257.77,94.49) v2(257.83,12.68) v2(258.81,12.67) v2(260.17,95.23) v2(260.84,76.84) v2(261.35,12.67) v2(262.21,73.31) v2(262.21,72.63) v2(262.36,80.5) v2(262.53,96.08) v2(263.89,12.67) v2(264.87,97.09) v2(266.43,12.67) v2(266.6,48.38) v2(266.6,47.72) v2(266.59,46.76) v2(267.12,98.25) v2(268.97,12.67) v2(269.3,99.56) v2(271.38,101.02) v2(271.51,12.67) v2(272.78,19.29) v2(273.11,98.74) v2(273.34,96.93) v2(273.36,102.62) v2(273.41,19.29) v2(274.05,19.29) v2(274.05,12.67) v2(275.22,104.34) v2(275.32,17.28) v2(275.95,17.28) v2(276.46,96.45) v2(276.59,17.28) v2(276.59,12.67) v2(276.76,106.05) v2(278.12,45.3) v2(278.43,108.27) v2(278.47,105.79) v2(278.49,92.56) v2(278.49,91.93) v2(279.13,92.56) v2(279.13,91.93) v2(279.13,12.67) v2(279.89,110.47) v2(280.4,44.05) v2(281.03,44.05) v2(281.08,38.99) v2(281.36,106.28) v2(281.43,38.47) v2(281.67,12.67) v2(282.25,44.05) v2(282.73,20.05) v2(282.86,44.05) v2(282.95,117.33) v2(283.34,20.02) v2(283.39,84.84) v2(283.67,119.77) v2(284.08,37.78) v2(284.21,122.25) v2(284.21,12.67) v2(284.77,163.59) v2(284.77,161.05) v2(284.77,158.51) v2(284.77,155.97) v2(284.77,153.43) v2(284.77,150.89) v2(284.77,148.35) v2(284.77,134.92) v2(284.77,132.38) v2(284.75,127.3) v2(284.92,166.02) v2(285.2,80.3) v2(285.4,64.45) v2(285.68,111.56) v2(285.68,108.06) v2(285.98,112.17) v2(286.14,60.59) v2(286.16,94.77) v2(286.42,148.95) v2(286.42,111.46) v2(286.47,155.81) v2(286.47,153.47) v2(286.59,81.16) v2(286.62,79.74) v2(286.75,60.59) v2(286.75,12.67) v2(286.95,147.06) v2(287,94.77) v2(287.1,115.2) v2(287.22,135.53) v2(287.31,113.06) v2(287.25,79.74) v2(287.38,60.59) v2(287.51,82.38) v2(287.56,106.2) v2(287.92,114) v2(287.94,27.67) v2(287.99,166.12) v2(288.25,80.63) v2(288.27,159.92) v2(288.65,13.32) v2(288.8,83.6) v2(288.86,86.49) v2(289.06,114.94) v2(289.06,114.31) v2(289.26,155.84) v2(289.26,153.58) v2(289.29,13.32) v2(289.29,12.67) v2(289.44,146.52) v2(289.44,83.6) v2(289.46,151.39) v2(289.52,149.03) v2(289.49,60) v2(289.69,136.2) v2(289.67,32.02) v2(289.82,124.47) v2(289.85,27.67) v2(289.92,13.32) v2(289.97,90.41) v2(290.56,88.75) v2(290.56,13.32) v2(291.06,126.37) v2(291.19,13.32) v2(291.29,122.28) v2(291.45,133.92) v2(291.45,144.97) v2(291.62,137.85) v2(291.83,13.32) v2(291.83,12.67) v2(292.16,130.97) v2(292.33,159.92) v2(292.26,148.98) v2(292.41,166.1) v2(292.37,120.54) v2(292.46,153.55) v2(292.46,151.42) v2(292.47,143.14) v2(292.72,144.58) v2(292.66,140.16) v2(293.02,97.69) v2(293.08,146.98) v2(293.06,31.34) v2(293.19,152.4) v2(293.23,149.21) v2(293.29,150.88) v2(293.43,153.99) v2(293.4,145.6) v2(293.58,109.38) v2(293.58,108.54) v2(293.58,107.7) v2(293.72,148.23) v2(293.73,136.3) v2(293.78,31.34) v2(294.09,129.22) v2(294.06,97.04) v2(294.21,98.81) v2(294.37,12.67) v2(295.1,32.39) v2(295.16,168.06) v2(295.41,27.71) v2(295.66,136.41) v2(295.94,67.93) v2(296.02,142.73) v2(296.02,141.97) v2(296.02,141.21) v2(296.02,140.44) v2(295.97,103.69) v2(296.07,63.02) v2(296.07,27.72) v2(296.58,103.69) v2(296.7,32.44) v2(296.91,27.78) v2(296.91,12.67) v2(297.19,136.41) v2(297.29,165.64) v2(297.29,159.92) v2(297.29,156.19) v2(297.29,155.3) v2(297.29,154.41) v2(297.54,143.24) v2(297.54,142.6) v2(297.54,141.97) v2(297.49,140.39) v2(297.49,139.76) v2(297.49,139.12) v2(297.47,131.12) v2(297.57,27.81) v2(297.7,168.06) v2(297.67,149.84) v2(297.67,149.21) v2(297.67,148.57) v2(297.92,153.14) v2(298.05,156.19) v2(298.25,31.12) v2(298.43,155.43) v2(298.43,154.67) v2(298.43,153.78) v2(298.43,152.51) v2(298.43,151.87) v2(298.94,166.73) v2(299.19,142.73) v2(299.26,58.25) v2(299.45,12.67) v2(299.6,88.88) v2(299.68,72.47) v2(299.65,69.43) v2(299.9,56.65) v2(300.06,55.61) v2(300.08,41.49) v2(300.08,40.82) v2(300.24,168.06) v2(300.18,136.25) v2(300.22,94.09) v2(300.21,88.88) v2(300.34,139.55) v2(300.34,131.36) v2(300.34,62.59) v2(300.39,46.43) v2(300.39,45.81) v2(300.59,142.09) v2(300.79,75.27) v2(300.89,123.02) v2(300.92,78.11) v2(301.1,139.55) v2(301.07,35.37) v2(301.22,165.64) v2(301.2,127.21) v2(301.2,108.03) v2(301.33,125.1) v2(301.35,159.92) v2(301.73,162.41) v2(301.71,35.37) v2(301.76,94.7) v2(301.99,140.32) v2(301.99,12.67) v2(302.11,142.09) v2(302.06,108.03) v2(302.37,45.7) v2(302.52,41.66) v2(302.62,140.32) v2(302.78,168.06) v2(302.88,108.03) v2(303.13,41.56) v2(303.33,123.78) v2(303.26,88.55) v2(303.41,51.11) v2(303.51,142.09) v2(303.66,120.94) v2(303.69,108.03) v2(303.71,67.42) v2(303.89,82.15) v2(303.97,127.24) v2(304.34,45.7) v2(304.4,158.1) v2(304.4,141.33) v2(304.4,140.19) v2(304.53,82.15) v2(304.48,55.05) v2(304.53,12.67) v2(304.63,119.77) v2(304.91,32.66) v2(304.98,136.3) v2(304.96,121.55) v2(304.98,104.76) v2(305.09,64.27) v2(305.16,59.24) v2(305.42,140.95) v2(305.46,33.99) v2(305.67,55.53) v2(305.78,45.8) v2(305.77,18.83) v2(305.8,18.04) v2(305.94,57.55) v2(306.03,129.12) v2(306.13,89.36) v2(306.48,67.04) v2(306.56,139.94) v2(306.61,104.73) v2(306.77,39.49) v2(307.07,12.67) v2(307.32,158.99) v2(307.29,37.91) v2(307.45,76.26) v2(307.63,82.53) v2(307.75,134.75) v2(307.67,89.87) v2(307.83,138.67) v2(307.96,107.53) v2(308.08,75.85) v2(308.39,117.41) v2(308.97,137.4) v2(309.05,116.92) v2(309.02,116.21) v2(309,115.6) v2(309.23,127.45) v2(309.23,90.74) v2(309.34,104.29) v2(309.34,102.22) v2(309.25,92.84) v2(309.25,64.09) v2(309.28,63.48) v2(309.37,107.23) v2(309.35,104.94) v2(309.43,76) v2(309.48,157.84) v2(309.48,136.89) v2(309.48,136.13) v2(309.48,135.36) v2(309.48,69.45) v2(309.48,68.82) v2(309.48,68.18) v2(309.48,67.55) v2(309.61,12.67) v2(309.73,108.19) v2(309.81,79.74) v2(309.87,93.66) v2(310.11,107.3) v2(310.13,95.75) v2(310.28,127.52) v2(310.37,136.13) v2(310.37,135.24) v2(310.62,131.55) v2(310.75,158.99) v2(310.75,110.47) v2(310.83,43.48) v2(311,109.46) v2(311,108.82) v2(311,108.19) v2(311,84.94) v2(311.13,133.71) v2(311.64,109.46) v2(311.64,108.82) v2(311.64,108.19) v2(311.77,113.52) v2(311.77,71.99) v2(311.89,134.86) v2(312.02,157.84) v2(312.15,110.47) v2(312.15,106.92) v2(312.15,12.67) v2(312.53,133.71) v2(312.53,114.15) v2(312.65,108.19) v2(312.78,60.88) v2(312.85,33.65) v2(312.91,32.41) v2(313.16,113.52) v2(313.54,134.86) v2(313.54,109.2) v2(313.54,108.19) v2(313.47,84.74) v2(313.47,57.54) v2(313.56,110.45) v2(313.62,44.84) v2(313.67,158.99) v2(313.73,130.03) v2(313.75,124.48) v2(313.72,121.5) v2(313.72,114.29) v2(313.67,106.92) v2(313.78,131.07) v2(313.77,127.5) v2(313.78,118.58) v2(313.77,116.82) v2(313.8,71.99) v2(314.2,60.91) v2(314.18,37.7) v2(314.23,13.82) v2(314.43,16.75) v2(314.49,108.03) v2(314.59,87.61) v2(314.59,37.17) v2(314.74,92.77) v2(314.92,60.21) v2(314.97,37.7) v2(315.02,36.66) v2(315.19,157.84) v2(315.42,37.19) v2(315.83,113.65) v2(315.78,37.75) v2(315.93,44.67) v2(315.86,36.66) v2(316,72.07) v2(316.08,134.86) v2(316.13,133.37) v2(316.24,37.24) v2(316.46,158.99) v2(316.49,114.51) v2(316.59,43.67) v2(316.71,60.86) v2(316.85,113.65) v2(316.77,70.87) v2(316.87,87.11) v2(317.23,59.72) v2(317.28,72.07) v2(317.53,110.45) v2(317.5,109.44) v2(317.48,92.25) v2(317.61,157.84) v2(318.2,133.39) v2(318.44,110.51) v2(318.42,37.5) v2(318.62,158.99) v2(318.96,114.51) v2(319.12,109.42) v2(319.16,110.5) v2(319.26,92.26) v2(319.89,157.84) v2(320.56,168.06) v2(320.74,133.39) v2(320.68,36.33) v2(321.04,157.87) v2(321.13,42.15) v2(321.47,32.11) v2(321.49,31.1) v2(321.47,30.11) v2(321.64,114.5) v2(321.7,90.81) v2(321.85,87.61) v2(322,39.25) v2(322.03,32.62) v2(322,31.6) v2(322,30.56) v2(322,29.67) v2(322.05,35.74) v2(322.13,34.63) v2(322.08,33.61) v2(322.54,36.25) v2(322.54,34.12) v2(322.54,33.15) v2(322.51,32.14) v2(322.54,31.12) v2(322.56,35.16) v2(322.56,30.13) v2(322.92,35.72) v2(322.94,34.65) v2(322.94,33.64) v2(322.94,32.67) v2(322.94,31.63) v2(322.94,30.64) v2(322.94,29.65) v2(323.74,38.55) v2(323.74,36.01) v2(323.74,33.47) v2(323.74,30.93) v2(323.7,27.91) v3(70.76,107.04) v3(71.94,129.19) v3(72.27,108.26) v3(72.38,128.75) v3(72.4,105.09) v3(72.79,110.78) v3(73.42,110.8) v3(73.68,121.7) v3(73.74,106.28) v3(73.75,129.01) v3(73.8,128.39) v3(75.36,118.1) v3(75.36,117.32) v3(75.36,107.87) v3(76.01,123.62) v3(76.01,112.59) v3(76.45,106.94) v3(76.6,101.59) v3(76.66,123.62) v3(76.66,119.68) v3(76.66,118.1) v3(76.66,114.95) v3(76.66,110.23) v3(76.66,109.44) v3(77.12,105.45) v3(77.31,123.62) v3(77.31,117.32) v3(77.31,111.02) v3(78.11,110.8) v3(78.06,100.58) v3(78.16,125.13) v3(78.46,100.98) v3(78.89,101.42) v3(78.97,110.24) v3(79.79,102.38) v3(79.93,110.24) v3(79.9,109.62) v3(79.89,108.99) v3(79.89,108.35) v3(80.03,118.5) v3(80.15,112.53) v3(80.73,100.54) v3(81.77,102.63) v3(82.06,122.71) v3(82.06,121.95) v3(82.06,121.19) v3(82.06,120.43) v3(82.08,115.09) v3(82.08,114.46) v3(82.08,113.82) v3(82.08,113.19) v3(82.19,117.63) v3(82.19,117) v3(82.23,101.3) v3(82.64,110.24) v3(82.64,109.62) v3(82.64,108.99) v3(82.64,108.35) v3(82.69,115.09) v3(82.69,114.46) v3(82.69,113.82) v3(82.69,113.19) v3(82.67,111.54) v3(82.67,110.89) v3(82.82,117.63) v3(82.82,117) v3(83.55,110.87) v3(83.84,104.36) v3(83.86,106.33) v3(83.99,102.37) v3(83.95,101.81) v3(84.47,110.9) v3(85.36,110.9) v3(85.36,110.24) v3(85.38,109.62) v3(85.38,108.99) v3(85.38,108.35) v3(86.38,122.71) v3(86.38,121.95) v3(86.38,121.19) v3(86.38,120.43) v3(87.01,115.09) v3(87.01,114.46) v3(87.01,113.82) v3(87.01,113.19) v3(88.12,109.62) v3(88.12,108.94) v3(88.11,108.33) v3(88.28,115.09) v3(88.28,114.46) v3(88.28,113.82) v3(88.28,113.19) v3(88.35,101.89) v3(88.42,102.45) v3(89.93,110.85) v3(89.95,111.52) v3(90.85,110.89) v3(90.85,110.24) v3(90.87,109.62) v3(90.86,108.99) v3(90.86,108.35) v3(91.08,122.71) v3(91.08,121.95) v3(91.08,121.19) v3(91.08,120.43) v3(91.84,115.09) v3(91.84,114.46) v3(91.84,113.82) v3(91.84,113.19) v3(91.78,110.87) v3(91.82,102.77) v3(91.86,100.86) v3(92.68,110.87) v3(93.59,111.53) v3(93.61,109.62) v3(93.61,108.99) v3(93.61,108.35) v3(94.38,115.35) v3(94.38,114.71) v3(94.38,114.08) v3(94.38,113.44) v3(94.53,102.75) v3(94.53,102.19) v3(96.35,109.51) v3(96.35,108.29) v3(96.54,120.81) v3(96.54,120.17) v3(96.54,119.54) v3(96.54,118.9) v3(96.54,118.27) v3(96.54,117.63) v3(96.54,117) v3(96.94,115.35) v3(96.94,114.59) v3(96.94,113.82) v3(96.92,113.19) v3(96.92,112.55) v3(96.86,102.77) v3(99.08,110.9) v3(99.08,110.27) v3(99.1,109.62) v3(99.09,108.99) v3(99.41,102.78) v3(99.42,102.22) v3(99.78,100.44) v3(100.02,110.9) v3(100.47,121.06) v3(100.47,120.5) v3(100.47,119.72) v3(100.47,119.16) v3(100.47,118.52) v3(100.47,117.96) v3(100.47,117.26) v3(100.47,116.7) v3(100.6,115.35) v3(100.6,114.59) v3(100.6,113.82) v3(100.6,113.19) v3(100.6,112.55) v3(100.91,110.9) v3(101.43,104.34) v3(101.81,111.52) v3(101.82,110.85) v3(101.84,109.62) v3(101.84,108.97) v3(101.84,108.31) v3(102.71,121.11) v3(102.71,120.55) v3(102.71,119.77) v3(102.71,119.21) v3(102.71,118.57) v3(102.71,118.01) v3(102.71,117.38) v3(102.71,116.82) v3(102.76,110.9) v3(103.65,110.9) v3(103.69,111.52) v3(104.03,115.35) v3(104.03,114.59) v3(104.03,113.82) v3(104.03,113.19) v3(104.03,112.55) v3(104.28,102.66) v3(104.54,110.85) v3(104.52,102.15) v3(104.51,101.42) v3(104.56,110.19) v3(104.59,109.62) v3(104.58,108.92) v3(105.5,110.9) v3(106.42,110.9) v3(106.46,101.66) v3(106.85,121.62) v3(106.85,121.06) v3(106.85,120.28) v3(106.85,119.72) v3(106.85,118.83) v3(106.85,118.27) v3(106.85,117.64) v3(106.85,117.08) v3(107.04,123.55) v3(107.04,122.92) v3(107.04,122.28) v3(107.08,114.59) v3(107.08,113.82) v3(107.08,113.19) v3(107.08,112.55) v3(107.07,100.11) v3(107.29,128.38) v3(107.29,127.73) v3(107.29,127.08) v3(107.29,126.43) v3(107.33,111.54) v3(107.33,110.9) v3(107.31,110.22) v3(107.33,109.56) v3(107.32,108.99) v3(108.17,102.17) v3(108.97,104.33) v3(109.4,100.97) v3(109.93,107.55) v3(109.97,109.61) v3(110.67,105.66) v3(110.79,110.46) v3(111.23,128.38) v3(111.77,130.51) v3(112.02,129.03) v3(112.07,127.01) v3(112.09,115.97) v3(112.09,109.67) v3(112.09,108.1) v3(112.5,130.51) v3(113.3,130.54) v3(113.39,127) v3(114.04,125.42) v3(114.04,123.85) v3(114.04,122.27) v3(114.04,114.4) v3(114.04,112.82) v3(114.04,111.25) v3(114.04,109.67) v3(114.04,108.1) v3(115.25,103.99) v3(115.65,114) v3(115.66,129.32) v3(115.68,128.12) v3(115.65,112.43) v3(115.8,105.14) v3(115.8,103.99) v3(116.07,107.31) v3(116.36,105.14) v3(116.36,103.99) v3(141.84,91.07) v3(145.47,105.14) v3(146.87,92.54) v3(148.2,72.97) v3(148.29,103.69) v3(148.29,100.92) v3(148.6,72.55) v3(149.87,80.43) v3(153.2,102.3) v3(153.2,100.19) v3(153.19,98.8) v3(153.2,97.4) v3(153.2,96) v3(153.21,95.31) v3(153.19,93.91) v3(153.2,92.5) v3(153.2,91.8) v3(153.19,90.41) v3(153.19,88.99) v3(153.2,87.6) v3(153.2,86.2) v3(153.19,85.5) v3(154.59,102.29) v3(154.59,100.21) v3(154.6,96) v3(154.59,95.31) v3(154.59,93.91) v3(154.61,92.49) v3(154.59,91.8) v3(154.59,90.41) v3(154.59,88.99) v3(154.6,87.6) v3(154.59,86.19) v3(154.6,85.5) v3(156.01,102.3) v3(155.99,100.21) v3(156.01,96) v3(156,95.3) v3(156,93.9) v3(156,92.5) v3(155.99,91.8) v3(156,90.4) v3(155.99,89) v3(156,87.6) v3(155.99,86.2) v3(156.01,85.5) v3(157.4,102.3) v3(157.4,101.6) v3(157.38,100.2) v3(157.38,98.8) v3(157.38,97.4) v3(157.39,95.99) v3(157.39,95.31) v3(157.38,93.9) v3(157.41,92.49) v3(157.41,91.8) v3(157.41,90.41) v3(157.39,89) v3(157.4,87.61) v3(157.41,86.19) v3(157.38,85.5) v3(158.81,102.29) v3(158.81,101.61) v3(158.81,100.21) v3(158.81,98.79) v3(158.81,97.39) v3(158.81,95.99) v3(158.81,95.31) v3(158.8,93.91) v3(158.81,92.49) v3(158.81,91.8) v3(158.81,90.41) v3(158.81,89.01) v3(158.81,87.59) v3(158.79,86.2) v3(158.81,85.5) v3(160.21,102.3) v3(160.2,101.61) v3(160.2,100.21) v3(160.18,98.8) v3(160.18,97.4) v3(160.2,95.99) v3(160.19,95.29) v3(160.2,93.9) v3(160.19,92.5) v3(160.2,91.81) v3(160.2,90.4) v3(160.2,89) v3(160.2,86.19) v3(160.19,85.49) v3(160.92,98.1) v3(160.9,87.6) v3(160.9,86.2) v3(161.6,95.99) v3(161.59,93.89) v3(161.6,91.8) v3(162.28,103) v3(162.3,101.61) v3(162.29,100.2) v3(162.28,89.7) v3(163,102.3) v3(163,100.2) v3(163,98.81) v3(162.99,97.39) v3(163,96) v3(163,95.31) v3(162.99,93.91) v3(162.99,92.49) v3(163,91.8) v3(163,90.39) v3(163.01,89.7) v3(163.01,89) v3(163.01,87.6) v3(163,86.19) v3(163,85.5) v3(164.4,102.3) v3(164.4,101.6) v3(164.41,100.21) v3(164.4,98.79) v3(164.41,97.41) v3(164.41,96.01) v3(164.4,95.3) v3(164.4,93.9) v3(164.4,92.5) v3(164.4,91.8) v3(164.41,90.39) v3(164.4,89.01) v3(164.4,87.6) v3(164.39,86.19) v3(164.4,85.5) v3(165.81,102.31) v3(165.79,101.61) v3(165.8,100.2) v3(165.8,98.8) v3(165.8,97.4) v3(165.79,95.99) v3(165.79,95.31) v3(165.8,93.9) v3(165.8,92.5) v3(165.81,91.79) v3(165.8,90.4) v3(165.8,89) v3(165.8,87.6) v3(165.8,86.2) v3(165.8,85.5) v3(167.2,102.3) v3(167.2,101.6) v3(167.2,100.2) v3(167.21,98.8) v3(167.21,97.39) v3(167.2,96.01) v3(167.2,95.3) v3(167.21,93.9) v3(167.2,92.5) v3(167.19,91.8) v3(167.2,87.6) v3(167.2,86.2) v3(167.19,85.5) v3(168.61,102.29) v3(168.61,101.61) v3(168.61,100.2) v3(168.6,98.8) v3(168.61,97.41) v3(168.61,95.99) v3(168.61,95.31) v3(168.61,93.9) v3(168.6,92.5) v3(168.6,91.8) v3(168.6,87.6) v3(168.59,86.19) v3(168.6,85.5) v3(170.01,102.3) v3(170.01,101.6) v3(170.01,100.2) v3(170.01,98.8) v3(170.01,97.4) v3(170.01,96) v3(170.01,95.3) v3(170.01,93.9) v3(170.01,92.5) v3(170.01,91.8) v3(170.02,90.4) v3(170.02,89) v3(170.01,87.6) v3(170.01,86.2) v3(170.01,85.5) v4(14.18,75.98) v4(14.18,75.09) v4(14.18,74.2) v4(15.07,75.98) v4(15.07,75.09) v4(15.6,74.25) v4(15.98,75.98) v4(15.98,75.09) v4(17,75.8) v4(17,74.78) v4(17.35,73.84) v4(17.35,72.83) v4(17.35,71.81) v4(17.89,75.8) v4(17.89,74.78) v4(18.24,73.84) v4(18.24,72.83) v4(18.24,71.81) v4(19.51,66.78) v4(19.54,65.89) v4(19.54,65.01) v4(20.43,66.78) v4(20.43,65.89) v4(20.43,65.01) v4(22.92,65.31) v4(22.97,50.48) v4(22.97,49.61) v4(23.81,65.31) v4(24.69,67.16) v4(24.72,66.3) v4(24.72,65.41) v4(25,85.33) v4(25.58,67.16) v4(25.61,66.3) v4(25.61,65.41) v4(25.89,85.33) v4(25.97,89.26) v4(26.5,66.56) v4(26.5,65.67) v4(27.03,90.69) v4(27.39,66.56) v4(27.39,65.67) v4(27.92,90.69) v4(28.3,89.9) v4(28.28,66.56) v4(28.28,65.67) v4(28.81,90.69) v4(32.11,97.26) v4(32.59,101.68) v4(33,98.15) v4(33,97.26) v4(33.28,102.39) v4(33.94,103.05) v4(33.89,99.04) v4(33.89,98.15) v4(33.89,97.26) v4(34.22,103.99) v4(46.59,153.78) v4(46.59,152.89) v4(46.64,151.98) v4(47.48,153.78) v4(47.48,152.89) v4(47.62,151.92) v4(47.62,151.01) v4(48.49,151.87) v4(48.49,150.98) v4(48.49,150.1) v4(48.49,116.57) v4(48.49,115.68) v4(48.72,114.76) v4(49.38,151.87) v4(49.38,150.98) v4(49.38,150.1) v4(49.38,117.15) v4(49.38,116.26) v4(49.38,115.37) v4(50.02,173.21) v4(50.02,172.32) v4(50.27,151.87) v4(50.27,150.98) v4(50.27,150.1) v4(50.27,149.21) v4(50.27,148.32) v4(50.81,173.59) v4(50.81,172.7) v4(50.81,171.81) v4(50.81,170.92) v4(51.16,151.87) v4(51.16,150.98) v4(51.16,150.1) v4(51.16,149.21) v4(51.16,148.32) v4(51.67,174.07) v4(51.67,173.21) v4(51.67,172.35) v4(51.67,171.48) v4(52.05,151.87) v4(52.05,150.98) v4(52.05,150.1) v4(52.05,149.21) v4(52.05,148.32) v4(52.3,116.57) v4(52.3,115.68) v4(52.3,114.79) v4(56.75,103.23) v4(57.64,103.23) v4(58.53,103.23) v4(58.53,102.34) v4(58.53,101.45) v4(58.68,169.02) v4(58.68,168.13) v4(58.68,167.24) v4(58.68,166.35) v4(59.54,168.13) v4(59.54,167.24) v4(59.54,166.35) v4(60.43,167.24) v4(60.43,166.35) v4(62.46,157.46) v4(63.35,157.46) v4(63.35,156.57) v4(63.35,155.68) v4(63.46,151.87) v4(64.24,157.46) v4(64.24,156.57) v4(64.24,155.68) v4(64.32,151.87) v4(65.13,157.46) v4(65.13,156.57) v4(65.13,155.68) v4(65.13,150.98) v4(65.18,151.87) v4(66.02,157.46) v4(66.02,156.57) v4(66.02,155.68) v4(66.05,151.87) v4(66.02,150.98) v4(66.91,157.46) v4(66.91,156.57) v4(66.91,155.68) v4(66.91,151.87) v4(66.91,150.98) v4(67.42,141.59) v4(67.42,140.7) v4(67.42,139.81) v4(68.31,141.59) v4(68.31,140.7) v4(68.31,139.81) v4(69.2,141.59) v4(69.2,140.7) v4(69.2,139.81) v4(70.08,141.59) v4(70.08,140.7) v4(70.08,139.81) v4(70.97,141.59) v4(70.97,140.7) v4(70.97,139.81) v4(72.75,158.99) v4(72.75,155.56) v4(73.26,175.37) v4(73.26,174.48) v4(73.26,173.59) v4(73.26,172.7) v4(73.26,171.81) v4(73.26,140.57) v4(73.26,139.68) v4(73.26,138.79) v4(73.64,160.38) v4(73.64,159.49) v4(73.64,158.6) v4(73.64,157.72) v4(73.64,156.83) v4(73.64,155.94) v4(73.64,153.52) v4(73.64,152.64) v4(74.15,175.37) v4(74.15,174.48) v4(74.15,173.59) v4(74.15,172.7) v4(74.15,171.81) v4(74.15,140.57) v4(74.15,139.68) v4(74.15,138.79) v4(75.04,140.57) v4(75.04,139.68) v4(75.04,138.79) v4(75.93,140.57) v4(75.93,139.68) v4(75.93,138.79) v4(76.69,146.92) v4(76.69,146.03) v4(76.69,145.14) v4(76.69,144.25) v4(76.69,143.36) v4(76.82,140.57) v4(76.82,139.68) v4(76.82,138.79) v4(77.58,146.92) v4(77.58,146.03) v4(77.58,145.14) v4(77.58,144.25) v4(77.58,143.36) v4(77.7,140.57) v4(77.7,139.68) v4(77.7,138.79) v4(78.47,146.92) v4(78.47,146.03) v4(78.47,145.14) v4(78.47,144.25) v4(78.47,143.36) v4(78.59,140.57) v4(78.59,139.68) v4(78.59,138.79) v4(79.36,146.92) v4(79.36,146.03) v4(79.36,145.14) v4(79.36,144.25) v4(79.36,143.36) v4(79.48,140.57) v4(79.48,139.68) v4(79.48,138.79) v4(80.24,146.92) v4(80.24,146.03) v4(80.24,145.14) v4(80.24,144.25) v4(80.24,143.36) v4(81.13,146.92) v4(81.13,146.03) v4(81.13,145.14) v4(81.13,144.25) v4(81.13,143.36) v4(81.13,140.57) v4(81.13,139.68) v4(81.13,138.79) v4(82.02,146.92) v4(82.02,146.03) v4(82.02,145.14) v4(82.02,144.25) v4(82.02,143.36) v4(82.02,140.57) v4(82.02,139.68) v4(82.02,138.79) v4(82.91,145.14) v4(82.91,144.25) v4(82.91,143.36) v4(82.91,140.57) v4(82.91,139.68) v4(82.91,138.79) v4(83.55,3.66) v4(83.8,140.57) v4(83.8,139.68) v4(83.8,138.79) v4(84.44,3.66) v4(84.69,139.68) v4(84.69,138.79) v4(85.32,3.66) v4(85.58,139.68) v4(85.58,138.79) v4(85.96,176.18) v4(86.21,3.66) v4(86.85,176.18) v4(86.85,175.29) v4(87.1,3.66) v4(87.74,176.18) v4(87.74,175.29) v4(88.63,176.18) v4(88.63,175.29) v4(88.75,158.1) v4(88.75,157.21) v4(88.75,156.32) v4(88.88,166.48) v4(88.88,165.59) v4(88.88,164.7) v4(88.88,163.81) v4(88.88,162.92) v4(88.88,162.03) v4(88.88,161.14) v4(88.88,160.26) v4(89.52,176.18) v4(89.52,175.29) v4(89.64,158.1) v4(89.64,157.21) v4(89.64,156.32) v4(92.18,145.78) v4(92.18,144.89) v4(92.18,144) v4(92.18,143.11) v4(93.12,146.67) v4(93.07,145.78) v4(93.07,144.89) v4(93.07,144) v4(93.07,143.11) v4(93.99,146.67) v4(93.96,145.78) v4(93.96,144.89) v4(93.96,144) v4(93.96,143.11) v4(94.85,146.67) v4(94.85,145.78) v4(94.85,144.89) v4(94.85,144) v4(94.85,143.11) v4(95.74,145.78) v4(95.74,144.89) v4(95.74,144) v4(95.74,143.11) v4(96.83,173.69) v4(96.86,172.8) v4(96.88,171.91) v4(96.93,171.05) v4(97.72,173.72) v4(97.8,172.83) v4(97.77,171.91) v4(97.82,171.05) v4(99.17,146.16) v4(99.17,145.27) v4(99.17,144.38) v4(99.17,143.49) v4(100.29,140.19) v4(101.3,140.19) v4(102.22,155.18) v4(102.32,140.19) v4(103.1,156.57) v4(103.1,155.56) v4(103.33,140.19) v4(103.61,159.49) v4(103.61,158.6) v4(103.74,160.89) v4(103.99,156.57) v4(103.99,155.56) v4(104.12,13.82) v4(104.35,140.19) v4(104.6,6.66) v4(105.01,160.89) v4(105.01,13.82) v4(105.09,159.49) v4(105.09,158.6) v4(105.9,13.82) v4(106.28,137.68) v4(106.28,136.79) v4(106.28,135.9) v4(106.28,135.01) v4(106.28,134.12) v4(106.28,133.23) v4(106.28,132.34) v4(106.46,6.66) v4(106.79,13.82) v4(107.35,6.66) v4(108.24,6.66) v4(109.12,6.66) v4(110.01,6.66) v4(114.38,135.67) v4(114.38,134.78) v4(114.38,133.89) v4(114.38,133) v4(115.27,134.78) v4(115.27,133.89) v4(115.27,133) v4(116.19,131.93) v4(116.57,159.11) v4(116.57,158.22) v4(116.95,166.99) v4(117.07,132.47) v4(117.07,131.58) v4(117.07,130.69) v4(117.07,12.94) v4(117.07,12.05) v4(117.58,166.22) v4(117.96,132.47) v4(117.96,131.58) v4(117.96,130.69) v4(117.96,12.05) v4(119.31,149.61) v4(120,151.04) v4(120,150.15) v4(120.12,73.82) v4(120.12,72.96) v4(120.3,129.52) v4(120.33,128.21) v4(120.28,126.91) v4(120.88,151.09) v4(120.88,150.2) v4(121.39,123.29) v4(122.26,123.29) v4(122.82,83.65) v4(123.12,123.29) v4(126.09,132.7) v4(126.98,132.7) v4(130.66,183.75) v4(131.55,183.75) v4(132.44,183.75) v4(133.33,183.75) v4(134.22,183.75) v4(134.88,152.58) v4(134.88,151.7) v4(134.88,150.81) v4(135.01,126.1) v4(135.01,125.21) v4(135.01,124.35) v4(135.01,123.49) v4(135.11,183.75) v4(135.77,152.58) v4(135.77,151.7) v4(135.77,150.81) v4(135.91,127.01) v4(135.89,126.13) v4(135.89,125.24) v4(135.89,124.37) v4(135.89,123.51) v4(135.88,122.64) v4(136,183.75) v4(136.66,152.58) v4(136.66,151.7) v4(136.66,150.81) v4(136.76,126.14) v4(136.76,125.2) v4(136.76,124.31) v4(136.76,123.45) v4(136.76,122.59) v4(136.89,183.75) v4(137.55,152.58) v4(137.55,151.7) v4(137.55,150.81) v4(138.41,152.56) v4(138.41,151.65) v4(138.44,150.78) v4(139.3,152.58) v4(139.27,151.7) v4(139.33,150.81) v4(140.14,151.7) v4(140.19,152.58) v4(140.21,150.81) v4(140.54,79.81) v4(140.7,145.78) v4(140.7,144.89) v4(141.33,191.5) v4(141.33,190.61) v4(142.22,191.5) v4(142.22,190.61) v4(143.11,191.5) v4(143.11,190.61) v4(146.41,191.53) v4(147.43,191.5) v4(147.43,190.61) v4(148.32,191.5) v4(148.32,190.61) v4(149.21,191.5) v4(149.21,190.61) v4(150.09,191.5) v4(150.09,190.61) v4(150.98,191.5) v4(150.98,190.61) v4(151.87,191.5) v4(151.87,190.61) v4(152.76,191.5) v4(152.76,190.61) v4(153.65,191.5) v4(153.65,190.61) v4(154.51,191.55) v4(157.49,191.55) v4(158.43,191.37) v4(158.43,190.48) v4(158.63,152.76) v4(158.63,151.87) v4(158.63,150.98) v4(158.73,146.29) v4(159.11,189.59) v4(159.32,191.37) v4(159.32,190.48) v4(159.52,152.76) v4(159.52,151.87) v4(159.52,150.98) v4(159.62,146.29) v4(159.62,145.4) v4(160,189.59) v4(160.2,191.37) v4(160.2,190.48) v4(160.41,152.76) v4(160.41,151.87) v4(160.41,150.98) v4(160.51,146.29) v4(160.51,145.4) v4(161.09,191.37) v4(161.09,190.48) v4(161.3,152.76) v4(161.3,151.87) v4(161.3,150.98) v4(161.4,146.29) v4(161.4,145.4) v4(161.98,191.37) v4(161.98,190.48) v4(162.19,152.76) v4(162.19,151.87) v4(162.19,150.98) v4(162.29,146.29) v4(162.87,191.37) v4(162.87,190.48) v4(163.56,146.54) v4(163.76,191.37) v4(163.76,190.48) v4(163.84,152.76) v4(163.84,151.87) v4(163.84,150.98) v4(164.45,189.59) v4(164.45,146.54) v4(164.45,145.65) v4(164.65,191.37) v4(164.65,190.48) v4(164.73,152.76) v4(164.73,151.87) v4(164.73,150.98) v4(165.33,189.59) v4(165.33,146.54) v4(165.33,145.65) v4(165.54,191.37) v4(165.54,190.48) v4(165.61,152.76) v4(165.61,151.87) v4(165.61,150.98) v4(166.22,146.54) v4(166.22,145.65) v4(166.5,152.76) v4(166.5,151.87) v4(166.5,150.98) v4(168.76,191.37) v4(168.76,190.48) v4(169.65,191.37) v4(169.65,190.48) v4(170.54,191.37) v4(170.54,190.48) v4(170.54,189.59) v4(171.43,191.37) v4(171.43,190.48) v4(171.43,189.59) v4(172.32,191.37) v4(172.32,190.48) v4(173.21,191.37) v4(173.21,190.48) v4(174.1,191.37) v4(174.1,190.48) v4(174.99,191.37) v4(174.99,190.48) v4(175.88,191.37) v4(175.88,190.48) v4(175.88,189.59) v4(176.76,191.37) v4(176.76,190.48) v4(176.76,189.59) v4(179.81,191.37) v4(179.81,190.48) v4(180.7,191.37) v4(180.7,190.48) v4(181.59,191.37) v4(181.59,190.48) v4(181.59,189.59) v4(182.02,151.47) v4(182.12,150.6) v4(182.1,149.71) v4(182.23,148.83) v4(182.23,147.94) v4(182.23,147.05) v4(182.23,146.16) v4(182.23,145.27) v4(182.48,191.37) v4(182.48,190.48) v4(182.48,189.59) v4(182.89,151.47) v4(182.99,150.6) v4(182.99,149.71) v4(183.11,148.83) v4(183.11,147.94) v4(183.11,147.05) v4(183.11,146.16) v4(183.11,145.27) v4(183.88,150.6) v4(183.88,149.71) v4(184,148.83) v4(184,147.94) v4(184,147.05) v4(184,146.16) v4(184,145.27) v4(184.77,150.6) v4(184.77,149.71) v4(184.87,148.8) v4(184.87,147.91) v4(184.87,147.02) v4(184.87,146.16) v4(184.87,145.27) v4(185.73,147.02) v4(185.73,146.16) v4(185.73,145.27) v4(186.59,147.02) v4(186.59,146.16) v4(186.59,145.27) v4(186.92,178.04) v4(186.92,177.15) v4(186.92,176.26) v4(187.81,178.04) v4(187.81,177.15) v4(187.81,176.26) v4(187.81,175.24) v4(188.19,146.18) v4(188.7,178.04) v4(188.7,177.15) v4(188.7,176.26) v4(188.7,175.24) v4(189.06,146.18) v4(189.59,178.04) v4(189.59,177.15) v4(189.59,176.26) v4(189.59,175.24) v4(202.16,10.01) v4(203.05,10.01) v4(203.66,142.07) v4(203.66,141.18) v4(203.94,10.01) v4(204.55,142.07) v4(204.55,141.18) v4(204.7,147.17) v4(204.83,10.01) v4(205.59,147.17) v4(205.72,10.01) v4(206.48,147.17) v4(206.61,10.01) v4(207.37,148.06) v4(207.37,147.17) v4(207.5,10.01) v4(207.63,151.62) v4(207.63,150.73) v4(207.63,149.84) v4(207.63,148.95) v4(207.75,146.29) v4(207.75,145.4) v4(207.75,144.51) v4(207.75,143.62) v4(208.39,10.01) v4(208.51,181.46) v4(208.51,180.58) v4(208.51,179.69) v4(208.51,178.8) v4(208.51,177.91) v4(208.51,177.02) v4(208.51,176.13) v4(208.51,151.62) v4(208.51,150.73) v4(208.51,149.84) v4(208.51,148.95) v4(208.64,146.29) v4(208.64,145.4) v4(208.64,144.51) v4(208.64,143.62) v4(209.4,181.46) v4(209.4,180.58) v4(209.4,179.69) v4(209.4,178.8) v4(209.4,177.91) v4(209.4,177.02) v4(209.4,176.13) v4(210.29,181.46) v4(210.29,180.58) v4(210.29,179.69) v4(210.29,178.8) v4(210.29,177.91) v4(210.29,177.02) v4(210.29,176.13) v4(215.88,98.58) v4(215.9,97.7) v4(215.95,96.6) v4(215.95,95.59) v4(216.77,98.51) v4(216.79,97.62) v4(216.82,96.63) v4(216.82,95.61) v4(217.66,98.56) v4(217.66,97.64) v4(217.68,96.76) v4(217.69,95.74) v4(218.54,98.53) v4(218.55,97.64) v4(218.55,96.76) v4(218.54,95.87) v4(221.88,81.64) v4(222.79,81.63) v4(223.68,81.63) v4(224.57,81.63) v4(224.77,101.2) v4(225.53,100.69) v4(225.46,81.63) v4(226.55,99.93) v4(227.31,99.4) v4(228.07,98.89) v4(228.81,98.43) v4(228.83,14.71) v4(229.72,14.71) v4(229.72,13.82) v4(229.72,12.94) v4(229.72,12.05) v4(230.41,97.49) v4(233.99,95.08) v4(234.85,95.08) v4(240.77,20.43) v4(240.93,16.87) v4(242.68,93.2) v4(243.41,92.56) v4(244.2,92.95) v4(244.33,92.06) v4(257.86,84.95) v4(258.02,27.74) v4(258.02,26.85) v4(258.91,28.63) v4(258.91,27.74) v4(258.91,26.85) v4(258.91,25.97) v4(259.8,28.63) v4(259.8,27.74) v4(259.8,26.85) v4(259.8,25.97) v4(260.69,27.74) v4(260.69,26.85) v4(260.69,25.97) v4(261.6,80.5) v4(261.58,26.85) v4(261.58,25.97) v4(262.59,64.02) v4(262.59,63.13) v4(263.48,64.9) v4(263.48,64.02) v4(263.48,63.13) v4(264.37,64.9) v4(264.37,64.02) v4(264.37,63.13) v4(264.37,62.26) v4(265.26,64.9) v4(265.26,64.02) v4(265.26,63.13) v4(265.26,62.26) v4(274.55,18.4) v4(274.55,17.51) v4(274.55,16.52) v4(274.55,15.65) v4(275.44,16.52) v4(275.44,15.65) v4(276.33,16.52) v4(276.33,15.65) v4(277.22,16.52) v4(277.22,15.65) v4(278.11,16.52) v4(278.11,15.65) v4(278.7,83.93) v4(278.7,83.04) v4(278.7,82.15) v4(278.7,81.26) v4(278.7,80.37) v4(279.56,83.93) v4(279.56,83.04) v4(279.56,82.15) v4(279.56,81.26) v4(279.56,80.37) v4(280.42,83.93) v4(280.42,83.04) v4(280.42,82.15) v4(280.42,81.26) v4(280.42,80.37) v4(300.16,26.94) v4(300.16,25.92) v4(301.05,26.94) v4(301.05,25.92) v4(300.97,13.57) v4(301.83,13.6) v4(301.94,26.94) v4(301.94,25.92) v4(302.75,13.57) v4(302.83,26.94) v4(302.83,25.92) v4(303.64,13.57) v4(303.71,26.94) v4(303.71,25.92) v4(304.53,13.57) v4(305.42,13.57) v4(306.3,13.57) v4(307.09,26.04) v4(307.19,13.57) v4(307.5,64.35) v4(307.78,26.63) v4(308.08,13.57) v4(309.86,42.63) v4(309.96,57.86) v4(309.96,56.97) v4(310.75,42.66) v5(143.39,126.94) v5(143.63,140.28) v5(144.32,139.58) v5(144.32,138.28) v5(148.1,134.32) v5(148.1,133.73) v5(149.51,113.9) v5(149.83,126.98) v5(150.52,114.44) v5(150.58,127.38) v5(150.93,113.01) v5(151.03,114.56) v5(151.11,112.17) v5(151.11,110.69) v5(151.82,110.7) v5(151.97,114.7) v5(152.66,133.15) v5(152.76,114.73) v5(152.85,114.16) v5(154.68,114.57) v5(155.69,114.01) v5(155.71,61.65) v5(155.71,46.28) v5(156.56,46.18) v5(157.08,61.25) v5(158.17,46.18) v5(158.6,60.85) v5(158.83,58.62) v5(158.83,57.32) v5(158.83,56.02) v5(158.83,51.47) v5(158.83,49.52) v5(158.83,48.22) v5(158.92,73.64) v5(158.92,72.71) v5(159.2,74.45) v5(159.16,70) v5(160.33,132.96) v5(161.06,46.55) v5(161.17,112.71) v5(161.82,127.31) v5(161.93,73.96) v5(161.86,46.55) v5(162.45,53.63) v5(162.66,46.55) v5(163.2,126.62) v5(163.62,138.93) v5(163.62,136.33) v5(163.62,131.13) v5(164.03,56.67) v5(164.03,51.47) v5(164.03,48.87) v5(164.18,141.32) v5(164.44,61.1) v5(164.68,47.48) v5(165,141.25) v5(165.8,141.25) v5(165.83,46.55) v5(165.98,60.51) v5(166.6,141.25) v5(166.88,136.16) v5(167.31,116.62) v5(167.41,55.13) v5(167.46,62.45) v5(167.46,61.65) v5(167.7,115.02) v5(167.99,113.46) v5(168.82,139.58) v5(168.82,136.33) v5(168.82,131.78) v5(168.82,130.48) v5(169.99,115.72) v5(170.6,127.36) v5(171.03,141.38) v5(171.9,132.27) v5(171.92,130.09) v5(171.92,126.89) v5(171.92,126.09) v5(172.45,84.45) v5(173.06,113.1) v5(173.28,114.28) v5(173.57,115.31) v5(173.73,73.36) v5(173.82,74.4) v5(173.9,113.7) v5(174.81,61.14) v5(174.83,54.77) v5(174.86,60.64) v5(175.3,75.55) v5(175.48,114.41) v5(175.54,46.43) v5(176.32,60.64) v5(176.91,74.64) v5(176.9,73.35) v5(177.7,77.1) v5(178.05,60.92) v5(178.31,140.35) v5(178.39,77.77) v5(178.58,46.64) v5(178.97,139.63) v5(178.97,131.18) v5(179.5,127.42) v5(179.62,53.44) v5(180.31,78.26) v5(180.88,136.91) v5(181,95.29) v5(180.96,75.73) v5(181.13,80.2) v5(181.47,77.86) v5(181.75,97.62) v5(181.8,79.58) v5(182.09,46.78) v5(182.3,95.24) v5(182.73,98.61) v5(182.81,134.41) v5(182.83,97.6) v5(182.91,60.46) v5(183.46,48.22) v5(183.64,95.25) v5(183.87,97.6) v5(184.12,47.53) v5(184.17,131.83) v5(184.17,127.17) v5(184.23,98.71) v5(184.88,98.07) v5(185.38,98.56) v5(185.53,60.54) v5(185.99,127.26) v5(186.28,60.59) v5(186.28,59.79) v5(186.31,52.1) v5(186.4,98.91) v5(187.54,127.03) v5(187.57,133.01) v5(187.81,131.2) v5(193.86,87.18) v5(194.32,84.78) v5(194.25,83.95) v5(194.71,112.3) v5(194.75,97.61) v5(194.67,87.21) v5(194.98,95.66) v5(194.98,85.48) v5(195.27,120.41) v5(196.4,94.04) v5(196.88,78.33) v5(198.18,78.33) v5(198.43,113.39) v5(198.83,83.53) v5(199.08,118.59) v5(199.48,97.46) v5(199.48,78.33) v5(199.73,113.39) v5(200.69,87.1) v5(201.21,121.99) v5(201.56,81.69) v5(202.06,98.82) v5(202.06,82.15) v5(202.3,117.22) v5(204.03,83.53) v5(204.03,78.33) v5(204.28,118.59) v5(204.28,113.39) v5(206.63,83.53) v5(206.88,118.59) v5(207.28,102.66) v5(207.28,78.33) v5(207.53,113.39) v5(208.15,84.25) v5(208.86,98.01) v5(208.92,84.26) v5(208.92,81.86) v5(209.02,76.89) v5(209.02,76.08) v5(209.49,116.91) v5(209.49,115.87) v5(209.49,115.13) v5(290.23,43.7) v5(290.23,42.35) v5(290.23,39.13) v5(290.26,37.82) v5(291.52,43.67) v5(291.52,43.02) v5(291.52,38.47) v5(291.52,36.56) v5(292.17,43.67) v5(292.17,43.02) v5(292.17,42.37) v5(292.17,39.76) v5(292.82,36.53) v5(293.47,39.77) v5(293.73,59.59) v5(294.12,42.37) v5(294.11,41.72) v5(294.24,59.6) v5(294.75,59.6) v5(294.77,43.67) v5(294.77,36.56) v5(294.95,56.66) v5(295.45,59.2) v5(295.44,40.43) v5(295.45,39.77) v5(295.52,58.19) v5(295.51,57.68) v5(295.46,57.17) v5(295.52,56.66) v5(295.46,37.17) v5(296.04,37.83) v5(296.07,42.37) v5(296.08,39.12) v5(296.07,37.19) v5(296.07,36.53) v5(296.74,43.67) v5(297.37,39.12) v5(297.38,36.55) v5(298.02,41.69) v5(298.02,41.07) v5(298.03,40.42) v5(298.02,39.12) v5(298,38.49) v5(298.65,43.68) v5(300.07,40.24)
