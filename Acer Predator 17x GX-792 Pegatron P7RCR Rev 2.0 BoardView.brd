# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB_DATA_RESUME: length 381.7
  TOP w0.121: R3108.1 210.83,39.89 v2(210.83,39.45) 210.83,38.87 210.56,38.6 Q3101.6 ; v2(238.57,38.34) 238.74,38.51 238.74,40.09 238.89,40.24 R2328.2 238.67,40.81 238.67,42.88 C2305.1 238.22,43.33 238.22,44.76 237.07,45.91 237.07,48.3 v2(237.38,48.61) ; v2(49.33,127.87) R3113.1 48.67,127.26 48.54,127.13 Q3102.6
  IN1 w0.083: v2(46.01,94.37) 45.85,94.37 45.19,95.03 45.19,100.31 57.41,112.53 59.92,112.53 62.31,114.92 v2(63.99,114.92) ; v2(64.88,129.19) 64.3,128.61 58.75,128.61 57.96,129.4 57.2,129.4 55.98,130.62 53.08,130.62 50.33,127.87 v2(49.33,127.87)
  IN2 w0.083: v2(63.99,114.92) 64.92,115.85 64.92,120.87 65.91,121.86 65.91,123.89 65.11,124.7 65.11,127.87 64.73,128.25 64.73,129.04 v2(64.88,129.19)
  IN3 w0.083: v2(46.01,94.37) 46.31,94.37 48.51,92.17 48.51,86.37 33.41,71.26 33.41,60.03 32.8,59.42 32.8,54.1 33.79,53.12 33.79,49.05 33.23,48.49 33.23,44.46 32.7,43.92 32.7,40.42 35.13,37.99 35.13,32.86 38.66,29.33 38.66,26.08 38.66,25.7 41.84,22.51 60.05,22.51 62.84,25.3 98.59,25.3 104.29,31 112.53,31 113.49,31.96 119.66,31.96 122.23,34.53 126.14,34.53 126.82,33.86 131.96,33.86 134.16,36.05 138.54,36.05 138.71,35.87 144.01,35.87 147.71,32.18 160.42,32.18 161.77,30.83 166.79,30.83 167.49,31.53 171.44,31.53 171.81,31.16 186.17,31.16 186.44,30.9 187.5,30.9 188.05,30.35 195.25,30.35 198.6,33.69 199.18,33.69 205.55,40.06 208.08,40.06 208.26,39.89 210.39,39.89 v2(210.83,39.45)
  BOTTOM w0.121: v2(237.38,48.61) 237.49,48.72 U2000.BB43 ; v2(210.83,39.45) 210.83,39.45 214.07,36.2 218.24,36.2 v1(220.63,33.81) 221.44,33 226.7,33 230.59,36.89 233.84,36.89 234.65,37.7 238,37.7 238.57,38.26 v2(238.57,38.34)
SMBALERT#_PCHHOT#: length 16.3
  TOP w0.102: v2(234.5,56.73) 234.92,56.3 236.58,56.3 236.93,55.95 238.49,55.95 239.22,55.22 240.76,55.22 241.2,54.78 244.41,54.78 244.76,55.13 244.76,55.79 245.22,56.24 245.73,56.24 R2349.2 246.54,57.05 v1(247.2,57.05) R2335.2
  BOTTOM w0.102: U2000.AT27 v2(234.5,56.73)
SMBALERT#_TLS: length 8.5
  TOP w0.102: v2(238.02,49.16) 238.1,49.07 238.1,48.19 v1(240.14,46.16) 240.14,45.32 R2348.2 R2334.2
  BOTTOM w0.102: U2000.BB41 237.8,49.38 v2(238.02,49.16)
SMBCLKCPUXDP: length 5.4
  BOTTOM w0.121: XDP4400.53 63.11,133.45 63.44,133.12 SR4409.2 63.44,132.16 63.62,131.99 v1(65.28,131.99)
SMBDATACPUXDP: length 4.7
  BOTTOM w0.121: XDP4400.51 SR4408.2 63.44,134.35 63.62,134.53 v1(65.18,134.53)
SMCLK0: length 5
  TOP w0.121: U3002.110 163.24,26.31 164.05,25.49 164.72,25.49 164.97,25.24 SR3010.2 165.37,24.81 165.59,24.59 166.18,24.59 v1(166.48,24.29)
SMDAT0: length 3.1
  TOP w0.121: U3002.111 163.32,26.71 163.73,26.3 v1(164.24,26.3) 164.45,26.09 SR3011.2
SML0_CLK: length 10.1
  TOP w0.121: R2329.2 240.06,41.7 239.9,41.87 239.9,43.35 C2306.1 239.76,44.06 239.76,44.65 239.25,45.17 238.57,45.17 v1(237.64,46.1) 237.59,46.14 v2(237.59,46.78)
  BOTTOM w0.121: v2(237.59,46.78) 236.37,48 236.37,48.39 236.58,48.6 U2000.AY44
SML0_DATA: length 12
  TOP w0.121: R2330.2 240.9,41.61 240.4,42.11 240.4,43.32 C2307.1 240.26,44.36 240.26,44.86 239.45,45.67 239.2,45.67 238.79,46.08 238.79,46.99 238.39,47.39 238.22,47.39 v1(237.65,47.96) 237.65,48.2 237.87,48.42 237.87,48.72 237.42,49.17 v2(237.42,50.14)
  BOTTOM w0.121: U2000.BB39 237.42,50.53 v2(237.42,50.14)
SML1_CLK: length 6.7
  TOP w0.121: v2(164.22,30.39) 164.22,29.7 R3034.2 163.95,28.69 163.56,28.31 U3002.115
  BOTTOM w0.121: v1(164.9,31.07) 164.9,31.07 v2(164.22,30.39) 164.34,30.27 SR3004.2
SML1_DATA: length 7
  TOP w0.121: R3035.2 164.83,30 v2(164.83,30.39) 164.83,30.46 164.46,30.83 164.05,30.83 163.66,30.44 163.66,29.02 163.35,28.71 U3002.116
  BOTTOM w0.121: v1(166.22,29.7) 166.21,29.69 SR3003.2 165.26,29.97 v2(164.83,30.39)
SPI_CLK: length 120
  TOP w0.121: v2(168.64,22.21) 168.58,22.21 167.8,23 166.67,23 R3043.1 ; v2(173.79,22.3) 173.79,22.67 173.38,23.09 R3157.2
  IN1 w0.083: v2(168.64,22.21) 169.1,21.75 169.23,21.75 169.23,21.75 169.36,21.75 169.75,21.36 171.22,21.36 171.34,21.47 173.37,21.47 173.79,21.9 v2(173.79,22.3)
  IN4 w0.083: v2(173.79,22.3) 173.79,21.8 174.67,20.92 176.35,20.92 176.83,20.44 184.58,20.44 185.63,21.49 201.38,21.49 207.65,27.76 210.27,27.76 211.65,29.14 212.85,29.14 214.5,30.79 227.73,30.79 231.03,34.09 244.81,34.09 v2(244.91,34.2)
  BOTTOM w0.121: SR2213.1 244.63,53.87 245.38,53.87 C2204.1 246.02,53.23 247.68,53.23 247.76,53.3 249.2,53.3 249.36,53.14 249.97,53.14 251.12,51.99 251.12,48.98 249.05,46.91 249.05,46.67 248.49,46.12 248.49,41.83 248.7,41.62 248.7,37.98 v2(244.91,34.2) ; CON4402.7 175.5,21.06 174.84,21.72 174.38,21.72 173.8,22.3 v2(173.79,22.3) 173.79,22.61 v1(174.07,22.89)
SPI_CLK_L500MIL: length 5.8
  BOTTOM w0.102: U2000.BC31 238.35,54.76 238.62,54.76 238.73,54.66 239.93,54.66
  BOTTOM w0.121: SR2213.2 v1(242.45,54.21) 241.91,54.21 241.85,54.14 240.45,54.14 239.93,54.66
SPI_CLK_R: length 5.2
  TOP w0.121: R3157.1 172.83,24.94 U3101.6 v2(172.83,27.58)
  BOTTOM w0.121: v2(172.83,27.58) 173.73,28.48 v1(174.28,28.48)
SPI_CS0#: length 133.1
  TOP w0.121: v2(173.18,22.3) 173.18,22.57 172.88,22.88 172.88,24.18 172.31,24.75 172.31,28.22 175.37,31.27 U3101.1 ; R3041.1 166.55,20.78 166.92,21.15 168.37,21.15 v2(169.42,22.21)
  IN1 w0.083: v2(169.42,22.21) 169.56,22.21 169.95,21.82 171.03,21.82 171.14,21.94 172.82,21.94 v2(173.18,22.3)
  IN4 w0.083: v2(173.18,22.3) 173.18,21.39 174.12,20.45 176.16,20.45 176.65,19.96 184.77,19.96 185.83,21.02 201.82,21.02 203.46,22.67 203.64,22.67 203.64,22.67 203.84,22.67 206.57,25.4 206.57,25.74 208.13,27.3 210.46,27.3 211.84,28.68 213.05,28.68 214.69,30.33 227.92,30.33 231.22,33.62 245.76,33.62 v2(246.36,34.22)
  BOTTOM w0.121: R3117.1 174.82,22.96 175.31,22.96 175.9,22.37 175.9,22.08 176.5,21.48 CON4402.5 ; R3117.1 173.92,24.65 v1(174.28,25) ; R3117.1 173.18,23.12 v2(173.18,22.3) ; v2(246.36,34.22) 246.36,34.88 249.2,37.72 249.2,41.83 249,42.04 249,45.91 249.56,46.47 249.56,46.72 251.62,48.78 251.62,52.23 249.73,54.11 249.36,54.11 SR2210.1
SPI_CS0#_L500MIL: length 13.8
  BOTTOM w0.121: U2000.BD31 238.64,54.97 238.71,54.97 238.77,54.92 240.52,54.92 240.72,54.72 244.63,54.72 244.98,54.37 246.65,54.37 246.83,54.19 247.88,54.19 SR2210.2 248.24,54.16 248.5,54.42 249.91,54.42 250.76,53.58 v1(251.11,53.58)
SPI_IO2: length 419.2
  TOP w0.121: v2(175.04,22.3) 175.04,22.49 174.13,23.4 174.13,24.72 173.62,25.23 173.62,28.08 176.26,30.72 176.26,33.76 176.75,34.26 176.75,35.47 176.17,36.05 174.94,36.05 174.76,36.23 R3159.1
  IN1 w0.083: v2(175.04,22.3) 174.18,23.15 171.63,23.15 171.54,23.06 167.41,23.06 167.36,23 164.45,23 164.31,22.87 157.39,22.87 157.04,23.22 134.42,23.22 131.95,25.68 118.04,25.68 116.25,23.89 114.73,23.89 113.13,22.29 41.23,22.29 39.7,23.83 34.15,23.83 32.61,25.36 32,25.36 29.48,27.89 29.48,29.38 30.84,30.74 30.84,37.3 30,38.14 30,44.28 26.04,48.24 25.23,48.24 24.25,49.22 24.25,50.39 17.22,57.41 17.22,59.71 17.74,60.23 17.74,63.99 18.35,64.59 18.35,69.11 20.34,71.1 31.2,71.1 33.53,73.43 33.53,75.65 33.04,76.15 33.04,86.64 39.78,93.39 39.78,102.68 50.37,113.27 50.37,117.69 48.93,119.13 47.25,119.13 44.3,122.08 44.3,124.78 48.85,129.32 48.85,130.16 49.75,131.06 v2(49.83,131.06)
  IN4 w0.083: v2(249.43,35.01) 244.26,35.01 244.03,34.78 230.77,34.78 227.45,31.46 214.22,31.46 212.58,29.81 211.37,29.81 209.99,28.43 207.37,28.43 201.1,22.16 184.62,22.16 184.06,21.6 175.73,21.6 v2(175.04,22.3)
  BOTTOM w0.121: v2(49.83,131.06) 50.81,130.08 v1(50.81,129.24) 50.81,128.42 52.92,126.31 R4425.2 ; SR2215.1 249.17,55.82 252.21,55.82 254.06,53.96 254.06,49.24 252.19,47.36 251.78,47.36 250.55,46.14 250.55,46.06 250.11,45.62 250.11,42.32 250.19,42.24 250.19,37.22 249.43,36.46 v2(249.43,35.01)
SPI_IO2_L500MIL: length 10.8
  BOTTOM w0.102: U2000.BC29 238.44,55.89 239.16,55.89
  BOTTOM w0.121: 239.16,55.89 239.19,55.86 240.87,55.86 241.02,55.71 244.98,55.71 245.04,55.77 246.34,55.77 247.15,56.58 247.57,56.58 SR2215.2
SPI_IO2_R: length 3.8
  TOP w0.121: R3159.2 R3116.2 ; R3116.2 172.04,35.36 v1(171.84,35.57) ; R3116.2 U3101.3
SPI_IO3: length 120
  TOP w0.121: R3158.2 175.47,22.75 175.47,22.14 175.18,21.85 172.45,21.85 v2(171.96,22.33)
  IN4 w0.083: v2(247.58,34.22) 246.56,33.2 231.4,33.2 228.1,29.91 214.87,29.91 213.22,28.26 212.02,28.26 210.64,26.88 208.31,26.88 206.99,25.56 206.99,25.23 204.01,22.25 203.64,22.25 201.16,19.77 185.27,19.77 185.04,19.54 176.28,19.54 175.78,20.04 173.6,20.04 171.96,21.67 v2(171.96,22.33)
  BOTTOM w0.121: v2(247.58,34.22) 247.58,35.36 249.7,37.48 249.7,42.03 249.56,42.18 249.56,45.77 250.06,46.27 250.06,46.51 252.14,48.6 252.66,48.6 253.57,49.51 253.57,53.76 252,55.32 250.07,55.32 249.88,55.14 SR2214.1 ; v2(171.96,22.33) v1(171.96,21.57) 172.35,21.19 173.79,21.19 174,20.98 CON4402.10
SPI_IO3_L500MIL: length 10.7
  BOTTOM w0.102: U2000.BD30 238.68,55.48 238.73,55.48 238.95,55.36 239.96,55.36
  BOTTOM w0.121: 239.96,55.36 240.7,55.36 240.85,55.21 244.83,55.21 245.15,54.9 246.56,54.9 246.98,55.32 248.09,55.32 248.28,55.14 SR2214.2
SPI_IO3_R: length 8.3
  TOP w0.121: v1(177.04,29.22) 175.29,29.22 174.1,28.02 U3101.7 174.1,25.64 174.54,25.19 R3158.1 175.01,24.07 175.01,24.04 R3124.2
SPI_MISO: length 137.8
  TOP w0.121: R3099.1 166.63,22.21 v2(167.06,22.21) ; R3160.1 175.93,34.86 175.93,30.89 173.37,28.34 173.37,25.12 173.88,24.61 173.88,23.29 174.4,22.77 v2(174.4,22.3)
  IN1 w0.083: v2(174.4,22.3) 174.4,22.63 174.1,22.94 171.72,22.94 171.62,22.85 167.86,22.85 167.62,22.61 167.61,22.61 167.21,22.21 v2(167.06,22.21)
  IN4 w0.083: v2(248.24,34.22) 247.71,34.75 244.41,34.75 244.21,34.55 230.83,34.55 227.54,31.25 214.31,31.25 212.66,29.6 211.46,29.6 210.08,28.22 207.46,28.22 201.19,21.95 184.71,21.95 184.15,21.39 175.31,21.39 v2(174.4,22.3)
  BOTTOM w0.121: CON4402.6 176,21.32 v1(175.52,21.8) 175.47,21.85 175.47,22.45 175.21,22.71 174.82,22.71 v2(174.4,22.3) ; v2(248.24,34.22) 248.24,35.64 249.95,37.35 249.95,42.14 249.86,42.22 249.86,45.72 250.3,46.17 250.3,46.24 251.67,47.61 252.03,47.61 253.82,49.4 253.82,53.86 252.11,55.57 246.75,55.57 246.51,55.33 SR2212.1
SPI_MISO_EC: length 3.4
  TOP w0.121: U3002.103 163.22,23.51 164.01,22.71 v1(164.19,22.71) 164.26,22.78 165.19,22.78 R3099.2
SPI_MISO_L500MIL: length 6.5
  BOTTOM w0.121: SR2212.2 245.14,55.33 245,55.46 240.92,55.46 240.79,55.59 239.06,55.59 U2000.BE30
SPI_MISO_R: length 4.2
  TOP w0.121: U3101.2 174.1,34.91 R3160.2 175,35.81 175.79,35.81 v1(176.31,35.29)
SPI_MOSI: length 403.6
  TOP w0.121: v2(60.31,116.31) 59.67,116.31 58.02,114.66 v1(54.97,114.66) 54.31,114 48.46,114 v2(47.59,114.87) ; v2(167.77,22.21) 167.21,21.65 R3044.1 ; R3156.2 172.57,22.82 v2(172.57,22.33)
  IN1 w0.083: v2(172.57,22.33) 172.57,22.54 172.38,22.73 171.8,22.73 171.71,22.64 168.13,22.64 167.77,22.28 v2(167.77,22.21) 167.38,21.81 166.9,21.81 165.95,22.76 164.5,22.76 163.94,22.2 153.64,22.2 152.85,22.99 134.35,22.99 131.9,25.44 118.1,25.44 116.33,23.68 114.81,23.68 113,21.87 89.32,21.87 89.11,22.08 41.15,22.08 39.61,23.62 34.03,23.62 32.49,25.15 31.92,25.15 29.27,27.8 29.27,29.47 30.63,30.83 30.63,37.21 29.79,38.05 29.79,44.15 25.95,47.99 25.19,47.99 24.02,49.15 24.02,50.31 17.01,57.32 17.01,59.8 17.54,60.32 17.54,64.07 18.14,64.68 18.14,69.2 20.25,71.31 31.12,71.31 33.3,73.49 33.3,75.59 32.83,76.06 32.83,86.73 39.53,93.43 39.53,103.28 46.97,110.73 46.97,114.26 v2(47.59,114.87)
  IN4 w0.083: v2(172.57,22.33) 172.57,21.5 173.82,20.24 175.87,20.24 176.36,19.75 184.95,19.75 185.18,19.98 201.07,19.98 203.55,22.46 203.93,22.46 206.78,25.32 206.78,25.65 208.22,27.09 210.55,27.09 211.93,28.47 213.13,28.47 214.78,30.12 228.01,30.12 231.31,33.41 246.16,33.41 v2(246.97,34.22)
  BOTTOM w0.121: CON4402.8 175,21.15 174.65,21.5 173.34,21.5 172.57,22.26 v2(172.57,22.33) ; v2(246.97,34.22) 246.97,35.11 249.45,37.59 249.45,41.93 249.24,42.14 249.24,45.81 249.81,46.37 249.81,46.61 251.87,48.67 251.87,52.49 251.69,52.66 251.69,54.44 251.16,54.97 250.17,54.97 249.87,54.67 SR2211.1 ; v2(60.31,116.31) 60.41,116.31 61.65,117.56 61.65,122.16 63.58,124.08 R4414.2 ; v2(167.77,22.21) 167.77,22.28 167.21,22.84 166.71,22.84 R3004.1
SPI_MOSI_L500MIL: length 10.1
  BOTTOM w0.102: U2000.BB29 238.13,55.66 238.13,55.62 238.47,55.27 238.68,55.27 238.77,55.23 238.86,55.14 239.26,55.14
  BOTTOM w0.121: 239.26,55.14 240.61,55.14 240.79,54.96 240.8,54.97 244.73,54.97 245.05,54.65 246.72,54.65 246.74,54.67 SR2211.2
SPI_MOSI_R: length 15.7
  TOP w0.121: R3101.2 171.68,22.77 171.94,23.02 171.94,23.35 R3156.1 172.42,24.27 172.06,24.63 172.06,24.78 171.56,25.28 U3101.5 171.56,26.93 171.96,27.34 171.96,32.11 172.19,32.34 172.19,34.4 171.02,35.57 v1(170.06,35.57)
SRTCRST#: length 269.6
  TOP w0.121: v2(255.1,69.1) 255.52,68.68 259.76,68.68 260.88,69.79 265.07,69.79 v1(267.64,67.22) 268.63,67.22 271.66,64.19 272.55,64.19 v2(273.01,64.65) 273.01,63.94 272.41,63.34 272.41,62.81 271.49,61.89 271.49,54.23 v2(272.29,53.42)
  IN2 w0.083: v2(275.04,42.96) 272.09,40.01 272.09,38.97 268.05,34.93 268.05,30.54 266.6,29.09 263.27,29.09 261.13,31.22 254.88,31.22 253.71,30.05 248.23,30.05 241.27,23.09 239.75,23.09 239.04,22.38 235.26,22.38 235.18,22.46 227.23,22.46 226.22,21.45 216.81,21.45 215.19,19.83 210.48,19.83 210.11,19.45 210.11,18.96 207.95,16.8 196.62,16.8 194.97,18.45 166.82,18.45 165.68,17.32 165.19,16.83 146.75,16.83 144.23,14.31 125.96,14.31 124.42,15.86 108.57,15.86 108.19,16.23 99.61,16.23 98.28,14.91 v2(98.28,14.84)
  IN3 w0.083: v2(275.04,42.96) 276.31,44.23 276.31,46.27 277.43,47.39 277.43,50.42 277.12,50.73 277.12,51.06 275.22,52.96 272.76,52.96 v2(272.29,53.42)
  BOTTOM w0.089: U2000.BB10 237.77,65.27 238.08,64.95 238.86,64.95 238.89,64.98 239.58,64.98 239.61,64.95 240.56,64.95
  BOTTOM w0.102: 240.85,65.23 240.85,65.23
  BOTTOM w0.121: v2(255.1,69.1) 254.77,69.1 253.14,67.47 252.04,67.47 251.25,68.26 247.33,68.26 247.18,68.11 246.5,68.11 244.72,66.34 244.1,66.34 243.9,66.13 242.38,66.13 241.48,65.23 240.85,65.23 ; R2802.1 97.46,15.66 v2(98.28,14.84) ; 240.56,64.95 240.85,65.23 ; v2(273.01,64.65) 273.27,64.38 273.27,64.28 C2827.1 273.82,64.35 273.82,64.93 R2810.2
SSD_PRESENT: length 3.8
  TOP w0.102: T5102.1 22.54,37.9 v2(22.21,37.57)
  BOTTOM w0.102: v2(22.21,37.57) 22.21,38.21 21.47,38.95 CON5103.1
SSD_PRESENT1: length 2.8
  BOTTOM w0.102: T5104.1 52.75,16.81 CON5104.1
STRAP0: length 14.4
  TOP w0.102: v3(142.96,76.51) 142.96,76.49 v1(142.47,76)
  IN4 w0.102: v3(142.96,76.51) 141.43,74.99 141.43,70.47 v2(140.37,69.4)
  BOTTOM w0.102: v2(140.37,69.4) 140.21,69.4 R7404.2 139.19,69.2 137.73,69.2 R7401.1 ; U7000.BL3 144.27,77.45 143.9,77.08 143.51,77.08 142.96,76.53 v3(142.96,76.51)
STRAP1: length 15
  TOP w0.102: v1(141.97,77.7) v3(143,77.7)
  IN4 w0.102: v3(143,77.7) 143,77.69 142.54,77.23 142.54,76.38 141.23,75.07 141.23,70.87 v2(140.37,70.01)
  BOTTOM w0.102: U7000.BL4 144.1,77.8 143.15,77.8 143.05,77.7 v3(143,77.7) ; v2(140.37,70.01) 139.99,70.01 R7413.2 139.18,70.06 137.75,70.06 R7412.1
STRAP2: length 13.7
  TOP w0.102: v1(143.72,77.99) v3(143.26,78.45)
  IN4 w0.102: v3(143.26,78.45) 142.92,78.11 142.86,78.11 142.34,77.59 142.34,76.47 141.03,75.16 141.03,71.51 v2(140.37,70.85)
  BOTTOM w0.102: v3(143.26,78.45) 143.56,78.15 U7000.BM4 ; v2(140.37,70.85) 139.99,70.47 R7416.2 139.19,70.88 137.73,70.88 R7415.1
STRAP3: length 15.3
  TOP w0.102: v2(140.37,71.46) 140.77,71.86 140.77,73.26 140.66,73.38 v1(140.66,73.86)
  IN4 w0.102: v2(140.37,71.46) 140.77,71.86 140.77,75.19 142.13,76.55 142.13,77.9 142.69,78.46 v3(142.69,78.47)
  BOTTOM w0.102: v3(142.69,78.47) 142.69,78.48 143.06,78.85 U7000.BM5 ; R7418.1 137.73,71.71 139.2,71.71 R7420.2 140.21,71.3 v2(140.37,71.46)
STRAP4: length 19.1
  TOP w0.102: v1(139.3,68.26) 139.3,67.9 139.83,67.37 v2(140.37,67.37)
  IN4 w0.102: v3(144.8,78.5) 144.43,78.88 142.56,78.88 141.92,78.23 141.92,76.62 139.96,74.66 139.96,67.77 v2(140.37,67.37)
  BOTTOM w0.102: R7421.1 R7417.2 140.06,67.06 v2(140.37,67.37) ; U7000.BK5 v3(144.8,78.5)
STRAP5: length 21.1
  TOP w0.102: v1(137.37,70.21) 137.37,68.49 v2(138.03,67.83)
  IN4 w0.102: v3(145.5,78.5) 144.93,79.08 142.48,79.08 141.71,78.32 141.71,76.7 139.2,74.19 139.2,68.99 v2(138.03,67.83)
  BOTTOM w0.102: R7424.2 R7422.1 v2(138.03,67.83) ; U7000.BJ5 v3(145.5,78.5)
SURGE_IN_C: length 10.1
  TOP w0.102: v1(291.37,155.89) 291.6,155.89 291.8,155.68 v2(292.21,155.68)
  TOP w0.457: C3400.1 v2(292.21,155.68)
  TOP w0.508: C3400.1 293.6,154.89 293.95,154.54 U3401.1 ; U3401.7 v2(296.7,148.54) ; U3401.4 v2(296.64,151.54) ; U3401.10 v2(297.69,145.54)
SURGE_OUT_C: length 10.3
  TOP w0.508: R3403.2 307.73,145.52 308.24,146.03 308.24,147.65 307.75,148.14 307.47,148.14 R3402.2 307.4,148.77 307.63,148.77 308.44,149.58 308.44,150.17 307.88,150.73 R3401.2 R3400.2 307.88,152.58 307.75,152.71 C3401.1
SUS_PWRGD: length 165.6
  TOP w0.102: v2(259.44,57.69) 259.78,57.69 260.14,58.05 U8100.7 ; v2(150.45,20.9) 150.12,20.57 149.7,20.57 149.26,20.13 U3002.67 ; D9200.2 180.96,42.25 180.98,42.27 R9202.2 182,42.7 183.37,42.7 185.05,41.03 v2(185.05,32.51) ; v2(166.99,39.45) 166.99,40.81 SR9210.2
  IN3 w0.102: v2(259.44,57.69) 258.32,56.57 256.6,56.57 253.85,53.83 253.85,46.51 254.54,45.83 254.54,44.67 254.26,44.39 252.9,44.39 249.69,41.18 241.26,41.18 240.65,40.57 211.41,40.57 211.09,40.89 209.93,40.89 209.81,41 205.16,41 199.8,35.64 198.24,35.64 197.61,35.01 197.61,34.03 194.87,31.29 188.44,31.29 187.89,31.83 186.83,31.83 186.56,32.1 185.45,32.1 v2(185.05,32.51) 184.64,32.1 172.22,32.1 171.41,32.91 167.33,32.91 167.32,32.9 167.3,32.9 166.89,32.49 v2(166.42,32.49)
  BOTTOM w0.102: v2(259.44,57.69) 259.44,58.68 T9205.1 ; v2(150.45,20.9) 151.83,19.51 155.03,19.51 156.01,20.49 156.01,21.57 157.94,23.5 158.55,23.5 159,23.95 159,24.67 159.86,25.54 160.47,25.54 161.06,26.13 162.01,26.13 163.48,27.61 163.48,30.37 164.79,31.68 165.61,31.68 v2(166.42,32.49) 166.42,38.88 v2(166.99,39.45)
SUSB#_PWR: length 609.4
  TOP w0.102: R8402.1 220.45,29.14 220.45,27.79 221.09,27.16 223.25,27.16 T9108.1 225.05,25.36 v2(225.13,25.36) ; R9104.1 244.56,20.43 v2(244.74,20.25) ; v2(197.95,39.55) 198.23,39.28 R9112.1 ; R8304.1 31.27,43.75 30.99,43.47 30.59,43.47 29.14,42.02 25.74,42.02 25.41,42.35 25.41,43.31 25.89,43.8 v2(26.78,43.8) ; v2(257.91,81.02) 257.54,80.65 257.54,80.47 257.44,80.37 256.17,80.37 T9301.1 ; v2(186.85,24.37) 186.85,24.77 185.15,26.47 185.15,29.9 184.84,30.21 Q9102.2 183.45,30.21 182.89,30.77 182.89,33.15 183.46,33.73 SR9101.2 184.49,33.12 184.49,32.49 184.88,32.1 185.21,32.1 185.48,32.36 185.48,39.25 189.37,43.15 192.28,43.15 192.76,43.63 v2(193.47,43.63)
  IN1 w0.102: v2(281.9,68.97) 281.67,68.97 280.24,70.39 270.06,70.39 268.92,69.25 263.36,69.25 259.92,72.68 259.92,77.02 259.49,77.45 259.49,79.53 258.01,81.02 v2(257.91,81.02) ; v2(102.22,157.72) 102.65,157.28 109,157.28 109.31,156.98 115.28,156.98 117.79,154.48 117.79,153.89 118.09,153.58 118.09,148.98 121.3,145.78 123.9,145.78 124.58,145.1 124.58,135.63 123.33,134.38 123.33,131.47 123.71,131.09 123.71,103.19 123.98,102.91 123.98,98.94 123.18,98.14 123.18,85.37 121.04,83.23 121.04,77.24 120.82,77.02 120.82,75.97 120.65,75.8 119.61,75.8 119.23,75.42 119.23,72.63 119.74,72.12 124.52,72.12 125.53,71.1 125.53,62.72 124.01,61.2 124.01,51.54 122.55,50.08 v2(122.55,49.84)
  IN3 w0.102: v2(26.78,43.8) 26.9,43.67 26.9,36.52 26.33,35.95 26.33,25.2 28.58,22.94 28.58,20.81 29.11,20.28 30.93,20.28 33.35,17.86 60.71,17.86 62.72,19.87 109.45,19.87 112.05,22.46 114.23,22.46 v2(115.04,23.27) 115.45,22.87 116.54,22.87 120.02,26.35 134.72,26.35 135.33,25.73 146.19,25.73 146.56,25.36 168.28,25.36 168.87,25.95 185.59,25.95 186.85,24.7 v2(186.85,24.37) 186.9,24.42 187.08,24.42 187.8,25.13 189.87,25.13 190.72,24.28 196,24.28 197.39,25.68 201.47,25.68 206.15,30.36 220.05,30.36 225.05,25.36 v2(225.13,25.36) 225.7,25.93 225.7,26.87 224.57,28 224.57,32.49 225.28,33.2 225.6,33.2 225.81,33.41 229.73,33.41 230.77,34.45 238.41,34.45 239.15,35.19 242.6,35.19 244.66,37.24 246.53,37.24 247.01,37.73 256.42,37.73 257.31,38.62 258.26,38.62 259.04,39.39 259.04,39.89 265.02,45.88 266.41,45.88 266.58,45.88 270.08,49.38 270.08,54.93 273.93,58.78 274.91,58.78 277.65,61.53 277.65,63.05 277.77,63.16 277.77,63.58 281.67,67.48 281.67,68.74 v2(281.9,68.97)
  BOTTOM w0.102: v2(197.95,39.55) 195.15,42.35 195.15,44.1 194.8,44.46 193.61,44.46 193.47,44.32 v2(193.47,43.63) ; v2(244.74,20.25) 244.1,20.25 239.59,24.76 236.91,24.76 236.01,25.66 226,25.66 225.7,25.36 v2(225.13,25.36) ; v2(115.04,23.27) 119.77,28 119.77,35.73 120.79,36.75 120.79,42.46 120.52,42.72 120.52,46.13 122.19,47.79 122.19,49.48 v2(122.55,49.84) ; R9106.1 258.07,81.19 v2(257.91,81.02) ; v2(102.22,157.72) 101.45,158.48 D9400.2 100.77,160.02 R9403.1
SUSB_EC#: length 157.9
  TOP w0.102: R3074.2 147.38,12.22 v1(147.43,12.17) 148.11,11.49 153.32,11.49 156.34,14.51 156.34,15.45 R3029.1 156.85,15.96 R3079.2 157.14,16.58 157.36,16.8 157.36,17.25 157.51,17.41 v2(157.51,18.04) ; R9204.1 180.63,36.96 181.16,36.43 D9201.2 183.39,36.43 183.88,35.95 SR9101.1 183.23,34.56 182.68,34.02 182.68,26.17 183.37,25.48 183.37,22.69 v2(183.62,22.44)
  IN1 w0.102: v2(251.19,32.97) 250.97,32.75 247.55,32.75 243.69,28.89 231.68,28.89 230.75,29.81 209.69,29.81 201.9,22.03 184.03,22.03 v2(183.62,22.44) 181.67,20.48 172.69,20.48 172.19,19.98 169.84,19.98 v2(169.23,20.59)
  BOTTOM w0.102: v2(157.51,18.04) 157.91,18.43 159.39,18.43 160.61,17.22 166.52,17.22 169.23,19.93 v2(169.23,20.59) ; U2404.2 253.68,45.3 253.73,45.24 255.33,45.24 255.99,44.59 255.99,41.08 254.61,39.71 254.1,39.71 253.4,40.41 252.48,40.41 251.99,39.93 251.99,36.57 251.19,35.76 v2(251.19,32.97)
SUSC#_PWR: length 382.7
  TOP w0.102: v2(176.35,22.3) 176.35,23.26 T9111.1 177.01,23.03 SR9103.2 177.49,22.5 177.55,22.56 Q9103.2 ; R8307.1 33.74,43.85 D8301.2 32.16,42.88 30.56,41.28 v2(22.59,41.28) ; v2(246.95,77.81) 246.95,77.8 247.71,77.03 252.98,77.03 T9302.1 JP9302.2 256.52,77.17 257.05,76.64 258.27,76.64 259.06,77.43 R9105.1 ; R9100.1 198.2,34.78 v2(198.48,34.5)
  IN2 w0.102: v2(246.95,77.81) 247.35,77.4 247.35,74.76 245.1,72.51 245.1,65.48 238.51,58.9 238.51,55.46 239.12,54.85 239.12,50.1 239.93,49.28 239.93,47.25 238.53,45.85 211.01,45.85 209.28,47.58 v2(200.08,47.58)
  IN3 w0.102: v2(22.59,41.28) 22.92,40.95 22.92,36.79 24.17,35.53 24.17,31.66 23.69,31.18 23.69,29.59 24.17,29.11 24.17,24.63 22.92,23.38 22.92,18.9 24.74,17.08 29.01,17.08 32.41,13.68 48.12,13.68 48.65,14.21 49.51,14.21 49.71,14.01 54.65,14.01 55.41,14.76 63.15,14.76 65.34,16.96 110.12,16.96 112.2,19.03 v2(112.76,19.03) 113.24,19.51 113.93,19.51 114.41,19.03 114.8,19.03 115.18,19.41 124.21,19.41 127.16,22.36 v2(133.28,22.36) 133.93,23.01 141.29,23.01 142.5,21.81 175.86,21.81 v2(176.35,22.3)
  BOTTOM w0.102: v2(200.08,47.58) 199.73,47.23 199.73,45.4 198.81,44.48 196.12,44.48 195.69,44.05 ; 195.69,44.05 195.08,44.66 191.91,44.66 188.14,40.89 188.14,32.06 182.55,26.47 178.64,26.47 176.64,24.48 176.64,22.59 v2(176.35,22.3) ; 195.69,44.05 195.69,42.65 198.56,39.78 198.56,39.41 197.57,38.41 197.57,35.41 v2(198.48,34.5) ; SR5702.1 138.49,33.73 139.15,34.38 140.59,34.38 140.82,34.14 140.82,32.37 142.09,31.1 142.09,29.06 139.05,26.02 137.14,26.02 133.48,22.36 v2(133.28,22.36) ; v2(112.76,19.03) 109.45,15.73 101.81,15.73 100.92,14.84 D9500.1 99.9,14.25 99.65,14 R9503.1
SUSC_EC#: length 39.6
  TOP w0.102: v2(171.76,20.59) 172.33,21.17 175.48,21.17 175.98,21.66 SR9103.1 ; R3075.2 146.95,12.94 148.44,12.94 v1(149.21,12.17) 149.69,11.69 153.19,11.69 156.14,14.64 156.14,15.45 R3030.1 155.96,16.09 R3080.2 156.3,16.58 156.38,16.66 156.38,17.72 v2(156.7,18.04)
  BOTTOM w0.102: v2(156.7,18.04) 157.3,18.64 159.48,18.64 160.69,17.42 166.43,17.42 168.83,19.81 168.83,20.86 169.05,21.09 171.27,21.09 v2(171.76,20.59)
SUSC_PWR: length 49.9
  TOP w0.102: Q5710.1 120.61,9.79 120.25,10.14 120.25,11.15 117.5,13.9 116.62,13.9 115.63,14.89 115.63,21.78 v1(116.29,22.44) 116.92,23.07 120.99,23.07 121.37,23.45 121.37,26.79 121.73,27.16 122.07,27.16 122.31,26.92 122.31,26.63 123.03,25.92 130.51,25.92 135.03,30.44 138.11,30.44 v2(138.36,30.69)
  BOTTOM w0.102: Q5707.1 138.68,30.73 138.64,30.69 v2(138.36,30.69) 138.36,31.38 R5709.2 139.55,31.86 139.81,32.12 Q5706.3
SUSWARN#: length 138.9
  TOP w0.102: R3098.2 169.74,29.86 169.74,29.97 R30101.2 170.08,27.54 170.62,27.01 170.62,24.81 v2(171.41,24.02)
  IN1 w0.102: v2(245.06,60.97) 244.52,60.43 244.39,60.43 243.82,59.87 243.82,51.16 243.85,51.13 243.85,45.84 242.4,44.38 240.96,44.38 238.82,42.24 238.82,41.54 237.72,40.44 234.67,40.44 234.23,40.01 232.22,40.01 229.93,37.73 225.06,37.73 224.6,38.18 217.37,38.18 210.03,30.84 209.28,30.84 202.26,23.83 198.59,23.83 197.89,23.13 187.01,23.13 185.59,24.55 171.94,24.55 v2(171.41,24.02) 170.85,24.58 166.69,24.58 166.63,24.52 158.15,24.52 v2(157.71,24.09)
  BOTTOM w0.102: U2000.BD19 238.69,60.78 239.27,60.78 239.44,60.61 240.57,60.61 240.8,60.84 244.68,60.84 244.81,60.97 v2(245.06,60.97) 245.36,61.27 245.91,61.27 246.04,61.14 248.14,61.14 248.44,61.45 248.77,61.45 R2263.1 ; v2(157.71,24.09) 157.64,24.16 v1(157.64,24.98) 157.64,25.28 157,25.92 157,27.11 157.64,27.74 157.64,28.13 158.47,28.96 R3011.2
SW0: length 2.4
  TOP w0.102: U4601.2 296.56,116 296.14,116.42 v1(295.97,116.42) 295.61,116.77 295.61,116.95 295.38,117.18 R4624.1
SW1: length 4.7
  TOP w0.102: v1(293,117.51) 293.1,117.61 294.65,117.61 R4626.1 296.56,116.5 U4601.1
SYS_PEX_RST_MON#: length 17
  BOTTOM w0.102: U7003.1 142.84,66.32 142.54,66.62 R7004.2 142,67.23 v1(141.64,67.59) 142.55,68.5 142.55,69.55 143.29,70.29 R7443.2 142.86,71.36 142.86,73.24 144.2,74.58 147.28,74.58 147.66,74.96 147.85,74.96 148.3,75.41 148.3,76.17 148.65,76.51 U7000.BE2
SYS_PWROK: length 146.1
  TOP w0.102: SR3016.2 141.33,30.97 v2(141.05,30.69)
  IN1 w0.102: v2(246.97,71.7) 242.83,67.56 242.83,55.99 239.4,52.56 239.4,48.7 238.1,47.39 236.39,47.39 235.64,46.64 235.64,46.55 235.3,46.21 233.11,46.21 232.6,45.7 222.66,45.7 222.08,46.29 211.42,46.29 208.15,43.02 208.15,42.1 203.68,37.63 203.68,35.84 196.48,28.63 165.83,28.63 165.22,28.02 161.6,28.02 161.04,28.58 143.16,28.58 v2(141.05,30.69)
  BOTTOM w0.102: v1(141.56,30.18) v2(141.05,30.69) ; R2489.1 248.7,75.37 249.42,74.64 U2403.1 249.42,72.77 248.98,72.32 247.59,72.32 v2(246.97,71.7)
SYS_PWROK_R: length 6.6
  TOP w0.102: R3006.2 143.53,31.45 143.61,31.38 SR3016.1 143.95,30.97 144.89,31.91 v1(144.89,32.24) 144.89,32.44 145.95,33.51 U3002.33
SYS_RESET#: length 349.7
  IN3 w0.102: v2(237.81,75.37) 236.94,76.24 236.22,76.24 236.05,76.41 233.62,76.41 231.89,78.14 217.34,78.14 215.45,76.25 215.45,73.7 213.35,71.6 206.79,71.6 204.94,69.76 204.94,68.86 203.13,67.04 203.13,64.44 198.42,59.73 198.42,48.46 194.43,44.47 193.14,44.47 190.13,41.47 170.17,41.47 169.59,40.88 154.49,40.88 148.36,47.01 142.64,47.01 141.99,46.36 135.35,46.36 135.07,46.08 133.79,46.08 129.03,41.32 121.49,41.32 118.84,38.68 102.68,38.68 96.24,32.24 58.15,32.24 54.34,28.43 46.06,28.43 42.68,31.8 42.68,40.57 37.85,45.41 37.85,69.2 53.14,84.49 53.14,99.19 49.66,102.67 49.66,105.65 55.58,111.57 55.58,124.95 v2(54.9,125.64)
  BOTTOM w0.102: U2000.AW1 236.28,69.96 236.28,71.24 237.27,72.23 237.73,72.23 238.92,73.42 R2451.2 238.49,74.35 238.49,75.1 238.22,75.37 v2(237.81,75.37) 237.81,75.69 v1(238.21,76.08) ; v2(54.9,125.64) 55.16,125.64 SR4407.2
TBT_BATLOW_N: length 18.8
  TOP w0.102: U1101.F2 296.98,45.57 296.98,46.53 297.03,46.58 297.03,49.11 296.73,49.41 294.74,49.41 294.36,49.79 294.16,49.79 293.68,50.27 291.27,50.27 290.28,51.26 289.52,51.26 v1(289.44,51.34) 289.21,51.57 285.74,51.57 285.08,50.91 R1132.1
TBT_CIO_PLUG_EVENT_N: length 91.2
  TOP w0.102: R2247.2 216.72,41.53 216.72,43.34 R2257.1 217.15,44.96 219.69,47.5 219.69,47.97 222.21,50.49 222.44,50.49 v2(222.5,50.54) ; v2(285.96,50.05) 285.96,49.97 R1146.1 285.43,49.38 SR1103.2
  IN3 w0.102: v2(222.5,50.54) 222.44,50.49 222.44,50.06 223.57,48.94 232.81,48.94 233.44,49.57 237.14,49.57 237.17,49.53 237.81,49.53 237.85,49.57 238.19,49.57 238.57,49.18 238.57,47.67 239.83,46.4 239.83,45.45 240.52,44.76 248.54,44.76 252.1,48.32 252.1,50.04 v2(252.52,50.46)
  IN4 w0.102: v2(252.52,50.46) 252.92,50.46 254.29,51.83 259.77,51.83 259.99,51.61 262.82,51.61 264.47,49.97 272.68,49.97 273.17,50.45 274.18,50.45 274.86,51.13 274.86,51.36 275.36,51.86 280.92,51.86 281.97,50.81 284.22,50.81 284.6,50.43 285.58,50.43 v2(285.96,50.05)
  BOTTOM w0.102: U2000.R39 223.77,51.25 223.04,51.25 222.71,50.92 222.71,50.76 v2(222.5,50.54) ; v2(285.96,50.05) 286.04,50.12 v1(286.59,50.12)
TBT_CIO_PLUG_EVENT_N_R: length 8.4
  TOP w0.102: U1101.W2 291,45.57 291,46.4 288.73,48.67 288.73,49.16 288.22,49.66 287.84,49.66 287.56,49.38 SR1103.1 287.04,50.26 287.08,50.3 v1(287.08,50.93)
TBT_CLKREQ_N: length 42.2
  TOP w0.121: R2482.2 251.36,50.41 251.99,49.78 v2(252.52,49.78) ; U1102.4 280.97,46.28 279.58,47.66 279.58,48.72 279.33,48.98 R1111.1 277.5,48.47 277.5,47.43 v1(276.89,46.82) 276.74,46.82 v2(275.85,47.71)
  IN4 w0.083: v2(252.52,49.78) 253.09,49.78 254.54,51.23 259.52,51.23 259.74,51.01 262.28,51.01 264.52,48.78 271.74,48.78 272.27,49.31 274.25,49.31 v2(275.85,47.71)
  BOTTOM w0.121: v2(252.52,49.78) 252.94,50.2 252.94,52.06 252.76,52.24 R2483.2 ; v2(275.85,47.71) 275.85,47.02 275.57,46.74 R1109.2
TBT_CLKREQ_N_R: length 18.4
  TOP w0.121: v2(242.12,56.78) 242.45,56.44 242.45,56.37 R2487.2
  IN4 w0.083: v2(242.12,56.78) 242.12,56.37 242.88,55.61 248.18,55.61 248.8,54.99 251.39,54.99 v2(252.15,54.24)
  BOTTOM w0.102: U2000.BD25 238.66,57.75 238.73,57.75 238.93,57.66 239.24,57.66 239.42,57.84
  BOTTOM w0.121: R2412.2 242.12,56.77 v2(242.12,56.78) v1(241.48,56.78) 241.46,56.78 240.39,57.84 239.42,57.84 ; 252.76,53.45 252.46,53.75 252.46,53.93 v2(252.15,54.24)
TBT_EE_CLK: length 39.8
  TOP w0.102: U1103.6 277.86,58.63 277.6,58.38 277.6,57.41 278.47,56.55 278.47,51.19 278.64,51.01 279.08,51.01 279.48,51.42 v2(280.07,51.42) 279.91,51.26 279.91,50.08 280.05,49.94 280.35,49.94 280.6,50.2 v1(280.96,50.2) 281.24,50.2 281.49,49.94 281.87,49.94 282.99,48.82 282.99,48.18 283.7,47.48 285.15,47.48 285.86,46.77 286.72,46.77 287.94,45.55 287.94,45.44 288.74,44.65 289.62,44.65 U1101.AB4 ; v2(290.38,57.01) 290.71,56.68 291.47,56.68 U1201.A3
  IN1 w0.102: v2(290.38,57.01) 289.72,57.01 289.26,57.47 287.92,57.47 287.04,56.58 286.9,56.58 284.71,54.4 284.71,54.27 283.23,52.79 281.44,52.79 v2(280.07,51.42)
TBT_EE_CS_N: length 49.6
  TOP w0.102: U1103.1 275.32,54.69 v2(274.89,55.13) 274.33,55.13 v1(273.67,55.79) R1105.1 ; U1201.B3 292.42,56.7 292.46,56.65 v5(292.46,56.65) ; U1101.AC3 288.78,44.89 288.14,45.53 288.14,45.63 286.81,46.97 286.01,46.97 285.25,47.73 283.73,47.73 283.19,48.27 283.19,48.91 281.8,50.3 281.61,50.3 281.29,50.63 280.45,50.63 v2(280.32,50.5)
  IN1 w0.102: v5(292.46,56.65) 291.04,58.07 290.15,58.07 289.39,58.83 285.81,58.83 284.36,57.39 284.36,55.35 282.2,53.19 280.6,53.19 279.3,54.49 279.3,54.91 277.95,56.27 276.03,56.27 v2(274.89,55.13) 275.88,54.13 277.58,54.13 279.28,52.44 279.28,51.01 279.79,50.5 v2(280.32,50.5)
TBT_EE_DI: length 42.4
  TOP w0.102: U1201.B4 292.27,57.2 v5(292.46,57.39) ; U1101.AB3 289.61,45.12 288.85,45.12 288.4,45.57 288.4,45.67 286.88,47.19 286.15,47.19 285.4,47.94 283.81,47.94 283.39,48.35 283.39,48.99 281.86,50.53 281.81,50.53 281.11,51.22 281.11,52.33 278.99,54.45 v2(278.99,56.81) 278.99,57.91 279.38,58.3 279.38,58.78 279.13,59.04 U1103.5
  IN1 w0.102: v5(292.46,57.39) 291.57,58.27 290.3,58.27 289.54,59.04 285.68,59.04 284.08,57.44 284.08,55.38 282.1,53.4 280.69,53.4 279.51,54.58 279.51,56.29 v2(278.99,56.81)
TBT_EE_DO: length 38.5
  TOP w0.102: v2(290.98,57.08) 291.37,57.08 U1201.A4 ; v2(277.86,55.79) 276.59,54.52 U1103.2 276.59,52.05 277.4,51.24 R1104.1 277.4,50.6 277.53,50.48 v1(278.36,50.48) 278.42,50.53 279.46,50.53 279.71,50.27 279.71,49.99 279.96,49.74 281.78,49.74 282.78,48.74 282.78,48.07 283.66,47.2 285.05,47.2 286.3,45.96 287.13,45.96 288.65,44.43 U1101.AC4
  IN1 w0.102: v2(290.98,57.08) 290.2,57.87 288.04,57.87 287.06,56.89 286.92,56.89 284.49,54.46 284.49,54.33 283.15,52.99 280.52,52.99 279.1,54.41 279.1,54.54 v2(277.86,55.79)
TBT_EE_WP_N: length 32
  TOP w0.102: U1103.3 277.86,54.26 v2(278.06,54.46) 278.26,54.67 278.26,56.12 277.25,57.13 277.25,57.54 276,58.78 276,61.32 R1103.1 ; v2(283.47,50.02) 283.88,50.43 v1(284.69,50.43) 284.88,50.43 285.82,51.37 288.78,51.37 289.24,50.91 290.34,50.91 290.66,50.59 290.66,49.36 291.19,48.83 291.19,47.25 291.69,46.76 U1101.V1
  IN1 w0.102: v2(278.06,54.46) 278.06,53.99 279.48,52.57 279.48,51.09 279.67,50.91 280.73,50.91 281.62,50.02 v2(283.47,50.02)
TBT_FORCE_PWR: length 74.9
  TOP w0.102: v1(221.98,48.98) R2259.2 223.49,49.47 223.49,49.77 v2(223.6,49.88)
  IN3 w0.102: v2(223.6,49.88) 224.31,49.17 232.73,49.17 233.34,49.77 237.22,49.77 237.26,49.73 237.73,49.73 237.76,49.77 238.27,49.77 238.77,49.27 238.77,47.75 240.04,46.49 240.04,45.53 240.6,44.97 248.29,44.97 251.81,48.48 251.81,50.36 v2(252.52,51.07)
  IN4 w0.102: v2(252.52,51.07) 253.24,51.07 254.2,52.03 259.86,52.03 260.07,51.82 262.91,51.82 264.55,50.17 271.14,50.17 271.63,50.65 274.1,50.65 274.66,51.21 274.66,51.5 275.26,52.1 279.73,52.1 282.15,54.52 v2(282.15,55.13)
  BOTTOM w0.102: v2(223.6,49.88) 223.49,49.77 223.49,49.49 U2000.P43 ; R1133.1 SR1102.2 282.58,55.77 282.15,55.34 v2(282.15,55.13)
TBT_FORCE_PWR_R: length 19.1
  TOP w0.102: U1101.H4 296.72,44.32 v5(296.75,44.32)
  IN4 w0.102: v5(296.75,44.32) 296.75,44.78 295.58,45.96 295.22,45.96 295.01,46.17 295.01,46.25 293.3,47.96 291.6,47.96 285.68,53.88 284.51,53.88 284.02,54.37 v2(284.02,54.44)
  BOTTOM w0.102: v2(284.02,54.44) 283.53,54.93 SR1102.1
TBT_HOLD_N: length 1.9
  TOP w0.102: U1103.7 276.59,61.12 276.43,61.27 R1106.1
TBT_HWRESET: length 151.6
  TOP w0.102: U3002.98 163.31,21.51 163.46,21.37 163.46,19.82 163.93,19.35 v2(163.93,18.03)
  IN2 w0.102: v2(279.89,62.34) 279.89,60.79 274.22,55.12 274.22,53.07 269.24,48.1 269.24,46.58 265.59,42.93 265.1,42.93 260.71,38.54 259.35,38.54 258.61,37.8 258.27,37.8 252.22,31.75 247.73,31.75 240.63,24.65 239.1,24.65 238.45,23.99 236.32,23.99 236.2,24.11 226.66,24.11 226.11,23.56 217.35,23.56 215.08,21.29 214.14,21.29 213.76,20.91 212.91,20.91 212.48,21.34 209.87,21.34 209.05,20.52 209.05,19.14 207.59,17.68 196.98,17.68 195.34,19.33 175.36,19.33 174.67,20.02 173.33,20.02 172.64,19.33 165.23,19.33 v2(163.93,18.03)
  BOTTOM w0.102: v2(163.93,18.03) 163.51,18.45 R3045.1 R3042.2 162.72,19.69 162.87,19.84 R3036.1 ; v2(279.89,62.34) 279.51,62.72 v1(278.67,62.72) 278.67,61.83 278.96,61.54 R1240.2
TBT_HWRESET_PCH: length 108.7
  IN3 w0.102: v2(219.28,33.26) 222.94,36.91 233.6,36.91 235.52,38.82 238.47,38.82 239.33,39.67 240.99,39.67 241.69,40.37 249.72,40.37 251.52,38.56 256.1,38.56 269.68,52.13 269.68,55.1 272.12,57.54 272.12,59.43 273.42,60.74 274.08,60.74 275.9,62.56 v2(275.9,63.28)
  BOTTOM w0.102: U2000.L43 221.74,48.82 221.74,48.59 221.57,48.43 221.25,48.43 221.03,48.21 220.85,48.21 220.5,47.86 220.11,47.86 219.24,46.99 215.86,46.99 215.68,47.17 213.52,47.17 210.9,44.56 210.83,44.56 R2256.1 209.53,43.77 209.07,43.31 v1(209.07,43.01) 209.07,41.94 R2245.2 209.1,40.16 209.1,39.02 214.86,33.26 v2(219.28,33.26) ; v2(275.9,63.28) 275.65,63.02 R1244.2
TBT_HWRESET_R: length 21.2
  TOP w0.102: U1201.D6 292.46,58.2 v5(292.46,58.2)
  BOTTOM w0.102: v1(276.76,62.87) 276.51,62.62 R1244.1 278.19,61.78 278.52,61.45 278.52,60.21 278.63,60.09 R1240.1 279.65,60.09 279.84,59.9 R1241.1 280.96,58.99 281.49,59.52 281.9,59.52 282.15,59.27 283.14,59.27 283.44,59.57 285.4,59.57 285.91,59.06 287.89,59.06 288.86,58.1 291.73,58.1 291.83,58.2 v5(292.46,58.2)
TBT_I2C_SCL: length 11.9
  TOP w0.076: 292.74,55.54 292.74,55.95 U1201.D2
  TOP w0.102: 291.92,46.41 291.92,45.58 U1101.U2
  TOP w0.121: v2(292.33,49) 292.2,48.86 292.13,48.86 291.96,48.7 R1141.1 291.7,48.12 291.78,48.05 v1(291.78,47.61) 291.92,47.47 291.92,46.41 ; 292.74,55.54 v2(292.18,54.98)
  IN4 w0.083: v2(292.18,54.98) 292.18,49.16 v2(292.33,49)
TBT_I2C_SDA: length 13.2
  TOP w0.121: R1140.1 292.64,48.37 v2(292.33,48.37) ; R1140.1 292.97,47.38 292.15,46.55 U1101.U1 ; R1140.1 293.58,48.7 v1(294.21,49.33) ; v2(292.79,55) 292.99,55.19 U1201.D1
  IN4 w0.083: v2(292.79,55) 292.79,48.62 292.54,48.37 v2(292.33,48.37)
TBT_MRESET: length 178.3
  TOP w0.102: U1201.E11 293.33,60.86 293.33,63.2 291.48,65.04 284.58,65.04 284.11,64.57 282.68,64.57 282.51,64.75 280.99,64.75 279.51,63.27 279.51,62.75 R1222.1 279.25,61.75 279.89,61.12 279.89,58.86 v2(280.5,58.25) ; v1(154.64,15.65) 154.64,16.17 R3092.2 154.66,16.58 154.62,16.62 154.62,18.07 v2(154.69,18.14)
  IN2 w0.102: v2(280.5,58.25) 280.83,57.92 280.83,55.52 280.32,55.01 279.64,55.01 276.87,52.23 276.87,47.23 274.3,44.66 274.3,44.27 269.96,39.93 269.96,38.82 265.64,34.5 261.6,34.5 260.08,32.98 254.1,32.98 252.45,31.33 247.88,31.33 240.79,24.24 239.27,24.24 238.59,23.55 236,23.55 235.85,23.7 226.82,23.7 226.28,23.15 217.52,23.15 215.25,20.89 214.31,20.89 213.74,20.32 210.3,20.32 209.63,19.64 209.63,19.15 207.76,17.28 196.81,17.28 195.17,18.92 166.62,18.92 165.31,17.62 155.21,17.62 v2(154.69,18.14)
TBT_MRESET_EC: length 7.5
  TOP w0.102: U3002.82 155.26,17.98 155.05,17.76 R3092.1 155.27,17.66 155.74,17.66 R3080.1 155.67,17.44 155.48,17.25 155.48,16.32 155.33,16.17 155.33,15.63 154.68,14.98 v1(154.68,13.82)
TBT_PCIE_RX0_N: length 92.6
  TOP w0.121: C1102.1 290.77,32.46 290.77,32.23 v2(290.97,32.03)
  IN4 w0.102: v2(221.49,61.35) 221.55,61.4 221.55,61.86 221.8,62.11 222.67,62.11 223.09,61.68 223.09,60.84 225.09,58.85 225.09,55.86 225.78,55.17 226.12,55.17 227.62,53.67 227.62,49.44 228.2,48.86 235.99,48.86 236.67,48.18 238.09,48.18 238.64,48.72 249.46,48.72 250,48.18 257.11,48.18 259,46.29 275.54,46.29 278.23,43.6 284.23,43.6 286.42,41.41 287.31,41.41 287.97,40.74 287.97,39.99 288.73,39.24 289.12,39.24 289.64,38.72 289.64,35.19 290.97,33.86 v2(290.97,32.03)
  BOTTOM w0.121: v2(221.49,61.35) 221.55,61.29 U2000.K19
TBT_PCIE_RX0_P: length 92.5
  TOP w0.121: C1101.1 290.33,32.47 290.43,32.47 290.53,32.37 290.53,32.27 v2(290.28,32.03)
  IN4 w0.102: v6(222.18,61.35) 222.08,61.35 221.76,61.67 221.76,61.77 221.89,61.89 222.58,61.89 222.88,61.59 222.88,60.75 224.87,58.76 224.87,55.77 225.69,54.96 226.03,54.96 227.4,53.58 227.4,49.35 228.11,48.65 235.9,48.65 236.58,47.96 238.18,47.96 238.73,48.51 249.37,48.51 249.91,47.96 257.02,47.96 258.91,46.08 275.45,46.08 278.14,43.38 284.14,43.38 286.33,41.19 287.22,41.19 287.76,40.65 287.76,39.9 288.64,39.02 289.03,39.02 289.42,38.63 289.42,35.1 290.75,33.77 290.75,32.5 v2(290.28,32.03)
  BOTTOM w0.121: v6(222.18,61.35) 222.18,60.86 U2000.L19
TBT_PCIE_RX1_N: length 98.9
  TOP w0.121: v6(293.05,32.06) 293.17,32.06 293.4,32.29 293.4,32.7 C1104.1
  IN4 w0.102: v2(220.3,60.13) 219.92,60.51 219.92,60.61 220,60.69 222.03,60.69 224.26,58.45 224.26,55.34 225.38,54.23 225.87,54.23 226.27,53.83 226.27,49.51 227.77,48.01 235.54,48.01 236.21,47.34 238.5,47.34 238.65,47.19 240.02,47.19 240.58,47.75 249.07,47.75 249.47,47.34 256.77,47.34 258.69,45.41 274.59,45.41 277.34,42.67 283.19,42.67 286.36,39.5 287.26,39.5 287.59,39.17 287.59,33.2 289.45,31.34 292.08,31.34 292.45,31.71 292.45,32.48 292.68,32.71 293.41,32.71 293.53,32.59 293.53,32.42 293.17,32.06 v6(293.05,32.06)
  BOTTOM w0.121: v2(220.3,60.13) 220.49,59.93 220.49,59.76 220.36,59.62 U2000.G22
TBT_PCIE_RX1_P: length 98.9
  TOP w0.121: v2(293.74,31.95) 293.63,32.06 293.63,32.77 C1103.1
  IN4 w0.102: v6(219.59,60.13) 219.59,60.59 219.91,60.9 222.12,60.9 224.48,58.54 224.48,55.43 225.47,54.44 225.96,54.44 226.49,53.92 226.49,49.6 227.86,48.23 235.63,48.23 236.3,47.56 238.59,47.56 238.74,47.4 239.94,47.4 240.49,47.96 249.15,47.96 249.56,47.56 256.86,47.56 258.78,45.63 274.68,45.63 277.43,42.88 283.28,42.88 286.45,39.71 287.35,39.71 287.8,39.26 287.8,33.29 289.54,31.55 291.99,31.55 292.23,31.8 292.23,32.57 292.59,32.93 293.5,32.93 293.74,32.68 v2(293.74,31.95)
  BOTTOM w0.121: v6(219.59,60.13) 219.59,59.95 U2000.E22
TBT_PCIE_RX2_N: length 97.8
  TOP w0.121: v6(295.58,31.89) 295.94,32.24 295.94,32.68 295.87,32.75 295.73,32.75 C1106.1
  IN4 w0.102: v6(295.58,31.89) 296.06,31.41 296.06,31.23 295.76,30.93 289.28,30.93 287.12,33.08 287.12,35.01 285.64,36.5 285.64,39.57 283.4,41.82 273.62,41.82 270.58,44.85 255.67,44.85 255.38,45.14 255.38,46.26 254.7,46.93 252.65,46.93 252.22,46.5 247.38,46.5 246.92,46.96 244.67,46.96 244.48,46.77 238.94,46.77 238.02,45.84 228.72,45.84 225.77,48.79 225.77,49.59 225.39,49.97 225.39,53.11 223.86,54.64 223.86,57.71 223.07,58.5 223.07,58.68 223.14,58.75 v2(223.32,58.75)
  BOTTOM w0.121: v2(223.32,58.75) 223.32,59.01 223.18,59.15 222.78,59.15 U2000.L22
TBT_PCIE_RX2_P: length 97.8
  TOP w0.121: v2(296.28,31.89) 296.28,32.11 296.17,32.21 296.17,32.78 C1105.1
  IN4 w0.102: v2(296.28,31.89) 296.28,31.14 295.85,30.71 289.19,30.71 286.91,32.99 286.91,34.93 285.43,36.41 285.43,39.48 283.31,41.6 273.53,41.6 270.49,44.63 255.58,44.63 255.16,45.05 255.16,46.17 254.61,46.72 252.74,46.72 252.31,46.28 247.29,46.28 246.83,46.75 244.76,46.75 244.57,46.55 239.03,46.55 238.1,45.62 228.63,45.62 225.55,48.7 225.55,49.5 225.18,49.88 225.18,53.02 223.64,54.55 223.64,57.63 222.85,58.41 222.85,58.54 v2(222.66,58.73)
  BOTTOM w0.121: U2000.K22 221.98,59.19 222.2,59.19 v2(222.66,58.73)
TBT_PCIE_RX3_N: length 99.6
  TOP w0.121: v2(297.96,31.7) 297.97,31.7 298.22,31.95 298.22,32.37 C1108.1
  IN4 w0.102: v2(297.96,31.7) 297.79,31.88 297.56,31.88 297.31,31.63 297.31,30.59 296.82,30.09 288.9,30.09 286.17,32.81 286.17,34.51 281.1,39.59 278.36,39.59 277.67,40.28 273.22,40.28 269.52,43.98 255.3,43.98 254.54,44.74 254.54,45.8 254.25,46.1 253,46.1 252.56,45.66 247.44,45.66 246.33,44.55 240.18,44.55 239.73,44.99 227.21,44.99 224.61,47.59 224.61,49.12 224.1,49.63 224.1,53.12 223.02,54.2 223.02,57.37 222.15,58.24 221.63,58.24 v6(221.16,58.7)
  BOTTOM w0.121: v6(221.16,58.7) 221.16,58.67 U2000.K24
TBT_PCIE_RX3_P: length 99.5
  TOP w0.121: v6(298.66,31.68) 298.46,31.89 298.46,32.44 C1107.1
  IN4 w0.102: v6(298.66,31.68) 298.66,31.7 298.23,32.14 297.52,32.14 297.1,31.72 297.1,30.68 296.73,30.31 288.98,30.31 286.39,32.9 286.39,34.6 281.19,39.81 278.45,39.81 277.76,40.49 273.31,40.49 269.61,44.19 255.39,44.19 254.76,44.83 254.76,45.89 254.34,46.31 252.91,46.31 252.47,45.87 247.35,45.87 246.24,44.76 240.26,44.76 239.82,45.21 227.3,45.21 224.82,47.68 224.82,49.21 224.31,49.72 224.31,53.21 223.23,54.29 223.23,57.46 222.21,58.48 222.1,58.48 v2(221.9,58.68)
  BOTTOM w0.121: v2(221.9,58.68) 221.92,58.68 U2000.L24
TBT_PCIE_TX0_N: length 134.6
  TOP w0.089: 290.89,34.79 290.89,35.38 291,35.48 291,35.92 U1101.Y22
  TOP w0.121: 290.89,34.79 289.19,33.09 v2(289.19,27.67)
  IN4 w0.102: v2(246.62,39.08) 246.62,39.38 246.95,39.7 246.95,39.94 248.18,41.17 259.77,41.17 260.3,40.65 264.29,40.65 264.76,40.17 264.76,39.47 266.12,38.11 266.68,38.11 268.32,36.47 270.99,36.47 272.19,35.26 280.56,35.26 282.8,33.02 282.8,30.4 285.35,27.85 285.71,27.85 286.66,26.9 288.41,26.9 v2(289.19,27.67)
  BOTTOM w0.121: 204.34,46.26 204.34,46.9 202.83,48.42 202.83,52.56 204.86,54.6 206.54,54.6 207.19,55.25 C2001.1 ; 204.34,46.26 204.34,38.24 212.76,29.83 228.74,29.83 232.14,33.23 239.33,33.23 240.18,34.09 242.9,34.09 246.62,37.81 v2(246.62,39.08) ; 204.34,46.26 v1(204.12,46.26)
TBT_PCIE_TX0_N_C: length 11.1
  BOTTOM w0.089: U2000.D22 218.46,59.78 217.58,59.78 217.57,59.79 217.34,59.73 217.13,59.73 217.12,59.74 217.05,59.74 217.04,59.76 217.03,59.76
  BOTTOM w0.121: C2001.2 210.65,55.25 210.74,55.35 210.74,55.76 212.55,57.56 212.55,57.81 213.91,59.17 214.39,59.17 214.74,59.53 216.42,59.53 216.56,59.67 216.69,59.67 216.78,59.76 217.03,59.76
TBT_PCIE_TX0_P: length 134.5
  TOP w0.089: 290.63,34.87 290.68,34.92 290.68,35.32 290.53,35.48 290.53,35.84 290.58,35.9 290.7,35.9 290.77,35.83 U1101.Y23
  TOP w0.121: v2(288.57,27.67) 288.95,28.05 288.95,33.19 290.63,34.87
  IN4 w0.102: v2(288.57,27.67) 288.57,27.36 288.32,27.11 286.75,27.11 285.8,28.06 285.44,28.06 283.01,30.49 283.01,33.11 280.65,35.48 272.28,35.48 271.08,36.68 268.41,36.68 266.77,38.32 266.21,38.32 264.98,39.55 264.98,40.26 264.38,40.86 260.39,40.86 259.86,41.39 248.09,41.39 246.73,40.03 246.73,39.79 v2(246.01,39.08)
  BOTTOM w0.121: v2(246.01,39.08) 246.03,39.08 246.39,38.72 246.39,37.91 242.8,34.32 240.09,34.32 239.23,33.47 232.04,33.47 228.64,30.06 212.85,30.06 204.58,38.34 204.58,47 203.06,48.51 203.06,48.83 ; C2000.1 208.92,54.36 208.81,54.47 208.81,54.6 208.92,54.72 208.92,54.9 208.81,55.01 207.29,55.01 206.64,54.36 204.96,54.36 203.06,52.46 203.06,48.83 ; v1(203.28,48.83) 203.06,48.83
TBT_PCIE_TX0_P_C: length 11.1
  BOTTOM w0.089: 217.03,59.52 217.37,59.52 217.62,59.59 217.8,59.61 218.17,59.61 218.27,59.51 U2000.C22
  BOTTOM w0.121: 217.03,59.52 216.88,59.52 216.79,59.44 216.66,59.44 216.52,59.29 214.84,59.29 214.48,58.94 214,58.94 212.78,57.71 212.78,57.46 210.98,55.66 210.98,55.25 210.7,54.97 210.7,54.47 210.59,54.36 C2000.2
TBT_PCIE_TX1_N: length 133.3
  TOP w0.089: U1101.T22 292.38,35.92 292.38,35.53 292.55,35.36 292.55,35.33 292.55,34.87
  TOP w0.121: v2(294.14,27.74) 294.27,27.87 294.27,28.6 292.19,30.68 292.19,33.97 292.55,34.33 292.55,34.87
  IN4 w0.102: v2(294.14,27.74) 293.88,28 293.88,28.06 293.78,28.16 287.95,28.16 286.46,29.66 285.47,29.66 283.42,31.71 283.42,33.28 281.1,35.6 281.1,36.13 280.76,36.47 276.88,36.47 276.37,35.96 274.36,35.96 272.09,38.23 269.07,38.23 265.89,41.41 261.7,41.41 261.32,41.8 246.65,41.8 245.47,40.62 245.47,40.13 v2(245.65,39.96)
  BOTTOM w0.121: v1(235.13,33.95) 235.13,34.17 ; 235.13,34.17 231.81,34.17 228.13,30.49 213.03,30.49 205.01,38.51 205.01,47.63 204.48,48.16 204.48,52.35 206,53.88 C2014.1 ; 235.13,34.17 239.15,34.17 239.83,34.85 242.12,34.85 245.5,38.23 245.5,39.8 v2(245.65,39.96)
TBT_PCIE_TX1_N_C: length 13.4
  BOTTOM w0.121: 208.46,53.88 210.79,53.88 211.13,54.22 211.13,54.69 211.41,54.97 211.41,55.48 213.28,57.35 213.28,57.61 214.28,58.61 214.54,58.61 214.97,59.04 216.72,59.04 216.88,59.2 217.13,59.2 217.16,59.23 217.65,59.23 U2000.B22 ; 208.46,53.88 v1(208.46,54.1) ; 208.46,53.88 C2014.2
TBT_PCIE_TX1_P: length 133.3
  TOP w0.089: U1101.T23 292.61,35.58 292.75,35.44 292.75,34.98 292.78,34.95 292.78,34.87
  TOP w0.121: 292.78,34.87 292.78,34.23 292.42,33.88 292.42,30.77 294.5,28.7 294.5,27.99 v2(294.75,27.74)
  IN4 w0.102: v2(294.75,27.74) 294.11,28.38 288.04,28.38 286.55,29.87 285.56,29.87 283.64,31.79 283.64,33.37 281.32,35.69 281.32,36.22 280.85,36.68 276.79,36.68 276.28,36.18 274.45,36.18 272.18,38.45 269.16,38.45 265.98,41.63 261.79,41.63 261.41,42.01 246.56,42.01 245.26,40.71 245.26,40.18 v2(245.04,39.96)
  BOTTOM w0.121: C2015.1 206.54,52.99 206.46,53.07 206.46,53.55 206.37,53.64 206.1,53.64 204.71,52.25 204.71,48.26 205.24,47.73 205.24,38.61 213.13,30.72 228.03,30.72 231.71,34.41 236.84,34.41 ; 236.84,34.41 239.05,34.41 239.73,35.08 242.02,35.08 245.26,38.33 245.26,39.74 v2(245.04,39.96) ; 236.84,34.41 v1(236.84,34.62)
TBT_PCIE_TX1_P_C: length 13.4
  BOTTOM w0.121: 211.65,55.13 211.65,54.88 211.37,54.6 211.37,54.12 210.89,53.64 208.43,53.64 208.21,53.42 208.21,53.09 208.11,52.99 C2015.2 ; 211.65,55.13 211.65,55.39 213.51,57.25 213.51,57.51 214.38,58.38 214.64,58.38 215.07,58.81 216.82,58.81 216.98,58.96 U2000.A23 ; 211.65,55.13 v1(211.86,55.13)
TBT_PCIE_TX2_N: length 133.8
  TOP w0.089: U1101.M22 294.68,35.92 294.68,35.45 294.59,35.37 294.59,34.83 294.61,34.81 294.61,34.77
  TOP w0.121: 294.61,34.77 294.61,30.33 295.77,29.18 295.77,28.73 v2(296.17,28.33)
  IN4 w0.102: v2(296.17,28.33) 295.76,28.73 295.43,28.73 295.15,29.02 288.37,29.02 284.69,32.7 284.69,34.42 281.7,37.42 274.31,37.42 269.56,42.16 267.38,42.16 267.24,42.3 262.18,42.3 261.79,42.69 251.58,42.69 250.87,43.39 246.92,43.39 243.81,40.28 243.81,39.69 244.25,39.25 244.25,39.05 v2(244.11,38.91)
  BOTTOM w0.121: v2(244.11,38.91) 244.3,38.72 244.3,38.3 241.76,35.77 232.01,35.77 227.65,31.41 217.71,31.41 ; 217.71,31.41 213.48,31.41 205.91,38.99 205.91,48.16 205.42,48.65 205.42,51.52 206.15,52.25 208.49,52.25 208.69,52.45 209.23,52.45 C2016.1 ; 217.71,31.41 v1(217.71,31.63)
TBT_PCIE_TX2_N_C: length 12.7
  BOTTOM w0.089: 216.65,58.27 216.9,58.27 217.13,58.5 217.51,58.5 217.63,58.6 218.07,58.6 218.13,58.66 218.27,58.66 U2000.C23
  BOTTOM w0.121: 216.65,58.27 215.22,58.27 214.81,57.87 214.65,57.87 213.97,57.19 213.97,56.26 212.05,54.34 212.05,53.75 211.33,53.04 211.33,52.36 211.08,52.1 211,52.1 ; 211,52.1 C2016.2 ; 211,52.1 v1(211,51.88)
TBT_PCIE_TX2_P: length 133.8
  TOP w0.089: 294.38,34.77 294.38,34.78 294.39,34.79 294.39,35.33 294.21,35.52 294.21,35.54 294.21,35.54 294.21,35.81 294.29,35.89 294.36,35.89 294.45,35.8 U1101.M23
  TOP w0.121: v2(295.54,28.33) 295.54,29.08 294.38,30.24 294.38,34.77
  IN4 w0.102: v2(295.54,28.33) 295.06,28.8 288.28,28.8 284.47,32.61 284.47,34.33 281.61,37.2 274.22,37.2 269.47,41.94 267.29,41.94 267.16,42.08 262.09,42.08 261.7,42.47 251.49,42.47 250.78,43.18 247.01,43.18 244.02,40.19 244.02,39.78 244.47,39.34 244.47,39.14 v2(244.72,38.89)
  BOTTOM w0.121: v2(244.72,38.89) 244.53,38.71 244.53,38.21 241.86,35.54 238.66,35.54 ; C2017.1 209.28,52.68 208.59,52.68 208.39,52.49 206.05,52.49 205.18,51.62 205.18,48.55 205.67,48.06 205.67,38.89 213.38,31.18 227.75,31.18 232.11,35.54 238.66,35.54 ; 238.66,35.54 v1(238.66,35.32)
TBT_PCIE_TX2_P_C: length 12.6
  BOTTOM w0.089: U2000.B23 217.89,58.79 217.59,58.79 217.45,58.68 217.05,58.68 216.86,58.49 216.67,58.49 216.65,58.51
  BOTTOM w0.121: 213.52,56.14 213.74,56.36 213.74,57.29 214.55,58.1 214.72,58.1 215.12,58.51 216.65,58.51 ; 213.52,56.14 v1(213.37,56.29) ; 213.52,56.14 211.81,54.43 211.81,53.85 211.1,53.14 211.1,52.45 210.98,52.33 210.77,52.33 210.67,52.43 210.67,52.92 210.6,52.99 C2017.2
TBT_PCIE_TX3_N: length 129.6
  TOP w0.089: 296.51,34.83 296.51,34.84 296.49,34.86 296.49,34.92 296.42,34.99 296.42,35.39 296.52,35.48 296.52,35.92 U1101.H22
  TOP w0.121: 296.51,34.83 296.51,34.62 297.42,33.7 297.42,28.67 297.4,28.65 v2(297.56,28.48)
  IN4 w0.102: v2(297.56,28.48) 297.35,28.69 297.35,29.31 296.97,29.68 288.6,29.68 285.67,32.62 285.67,34.44 282.07,38.04 274.8,38.04 270.06,42.78 267.9,42.78 267.11,43.57 254.9,43.57 254.09,44.38 251.91,44.38 251.73,44.56 247.15,44.56 243.09,40.49 243.09,40.13 v2(242.69,39.73)
  BOTTOM w0.121: v1(216.36,32.76) 216.36,32.54 ; 216.36,32.54 213.95,32.54 208.34,38.16 208.34,39.71 206.64,41.41 206.64,48.55 206.25,48.93 206.25,50.65 206.51,50.91 207.04,50.91 C2018.1 ; 216.36,32.54 226.93,32.54 230.85,36.46 241.47,36.46 243.07,38.07 243.07,39.35 v2(242.69,39.73)
