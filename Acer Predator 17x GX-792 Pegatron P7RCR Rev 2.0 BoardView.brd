# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R1310  0Ohm  [VX_R0402_0OHM_SMALL]  292.97 90.66 90 top
R1311  0Ohm  [VX_R0402_0OHM_SMALL]  292.97 88.88 270 top
R1312  47KOhm  [VX_R0402_SMALL]  295.13 87.87 90 top
R1313  47KOhm  [VX_R0402_SMALL]  296.27 87.87 90 top
R1319  64.9KOhm  [VX_R0402_SMALL]  291.7 82.15 0 bottom
R1320  64.9KOhm  [VX_R0402_SMALL]  291.7 83.17 180 bottom
R1321  6.98KOhm  [VX_R0402_SMALL]  297.67 78.72 90 top
R1322  64.9KOhm  [VX_R0402_SMALL]  290.3 81.77 270 bottom
R1323  64.9KOhm  [VX_R0402_SMALL]  295.51 78.72 270 top
R1324  64.9KOhm  [VX_R0402_SMALL]  292.72 76.05 90 bottom
R1325  64.9KOhm  [VX_R0402_SMALL]  296.78 78.72 270 top
R1326  64.9KOhm  [VX_R0402_SMALL]  301.35 82.15 0 bottom
R1327  64.9KOhm  [VX_R0402_SMALL]  301.35 80.88 270 bottom
R1328  2KOhm  [VX_R0402_SMALL]  291.19 79.1 180 bottom
R1329  2KOhm  [VX_R0402_SMALL]  289.16 81.77 270 bottom
R1330  64.9KOhm  [VX_R0402_SMALL]  297.92 87.87 270 bottom
R1331  64.9KOhm  [VX_R0402_SMALL]  299.19 89.77 0 top
R1332  0Ohm  [VX_R0402_0OHM_SMALL]  291.19 80.12 0 bottom
R1333  0Ohm  [VX_R0402_0OHM_SMALL]  291.19 78.09 0 bottom
R1401  4.7KOhm  [VX_R0402_SMALL]  262.03 41.06 90 top
R1402  4.7KOhm  [VX_R0402_SMALL]  258.31 48.36 270 top
R1403  4.7KOhm  [VX_R0402_SMALL]  263.07 39.41 90 top
R1404  4.7KOhm  [VX_R0402_SMALL]  257.41 48.36 90 top
R1405  4.7KOhm  [VX_R0402_SMALL]  262.03 39.41 90 top
R1406  4.7KOhm  [VX_R0402_SMALL]  263.07 41.06 90 top
R1407  10KOhm  [VX_R0402_SMALL]  258.31 51.95 270 top
R1408  0Ohm  [VX_R0603_0OHM_H28_SMALL]  268.71 40.88 180 top
R1409  0Ohm  [VX_R0603_0OHM_H28_SMALL]  268.71 42.27 180 top
R1411  4.99KOhm  [VX_R0402_SMALL]  265.61 40.92 270 top
R1414  100KOhm  [VX_R0402_SMALL]  267.32 52.23 270 top
R1415  100KOhm  [VX_R0402_SMALL]  266.3 52.23 270 top
R1416  100KOhm  [VX_R0402_SMALL]  265.41 52.23 90 top
R1417  1MOhm  [VX_R0402_SMALL]  266.68 40.92 270 top
R1501  4.7KOhm  [VX_R0402_SMALL]  48.62 11.41 180 top
R1502  4.7KOhm  [VX_R0402_SMALL]  48.75 10.14 180 top
R1503  4.7KOhm  [VX_R0402_SMALL]  36.61 13.01 0 top
R1504  4.7KOhm  [VX_R0402_SMALL]  47.3 16.01 180 bottom
R1505  4.7KOhm  [VX_R0402_SMALL]  35.92 16.75 0 bottom
R1506  4.7KOhm  [VX_R0402_SMALL]  36.61 11.75 0 top
R1507  4.7KOhm  [VX_R0402_SMALL]  38.21 11.75 0 top
R1508  0Ohm  [VX_R0402_0OHM_SMALL]  48.22 12.48 180 top
R1509  0Ohm  [VX_R0402_0OHM_SMALL]  48.22 13.72 180 top
R1510  0Ohm  [VX_R0402_0OHM_SMALL]  30.11 14.05 180 top
R1511  4.7KOhm  [VX_R0402_SMALL]  38.23 12.99 0 top
R1512  4.7KOhm  [VX_R0402_SMALL]  37.57 16.75 180 bottom
R1513  4.7KOhm  [VX_R0402_SMALL]  45.24 16.03 180 bottom
R1514  4.7KOhm  [VX_R0402_SMALL]  47.35 17.25 180 bottom
R1515  4.99KOhm  [VX_R0402_SMALL]  39.53 16.02 180 bottom
R1516  4.7KOhm  [VX_R0402_SMALL]  47.1 10.14 180 top
R1517  4.7KOhm  [VX_R0402_SMALL]  46.97 11.41 180 top
R1518  0Ohm  [VX_R0402_0OHM_SMALL]  30.11 12.81 180 top
R1519  0Ohm  [VX_R0603_0OHM_H28_SMALL]  17.51 10.78 90 top
R1600  240Ohm  [VX_R0402_SMALL]  75.16 69.58 0 bottom
R1601  240Ohm  [VX_R0402_SMALL]  75.7 71.71 90 bottom
R1602  0Ohm  [VX_R0402_0OHM_SMALL]  79.61 12.94 180 top
R1603  0Ohm  [VX_R0402_0OHM_SMALL]  81.64 12.94 0 top
R1604  0Ohm  [VX_R0402_0OHM_SMALL]  104.76 76.36 0 bottom
R1605  0Ohm  [VX_R0402_0OHM_SMALL]  103.08 76.36 180 bottom
R1606  0Ohm  [VX_R0402_0OHM_SMALL]  91.47 69.94 180 bottom
R1607  0Ohm  [VX_R0402_0OHM_SMALL]  100.87 69.58 0 bottom
R1608  0Ohm  [VX_R0402_0OHM_SMALL]  100.56 70.47 0 bottom
R1609  0Ohm  [VX_R0402_0OHM_SMALL]  89.34 70.95 180 bottom
R1610  1KOhm  [VX_R0402_SMALL]  85.38 72.73 0 bottom
R1612  1KOhm  [VX_R0402_SMALL]  85.38 71.84 180 bottom
R1613  0Ohm  [VX_R0402_0OHM_SMALL]  104.76 75.48 180 bottom
R1614  0Ohm  [VX_R0402_0OHM_SMALL]  103.08 75.42 0 bottom
R1615  0Ohm  [VX_R0402_0OHM_SMALL]  91.47 69.05 0 bottom
R1617  0Ohm  [VX_R0402_0OHM_SMALL]  100.87 68.69 180 bottom
R1618  0Ohm  [VX_R0402_0OHM_SMALL]  100.56 71.48 180 bottom
R1619  0Ohm  [VX_R0402_0OHM_SMALL]  89.34 70.12 0 bottom
R1700  240Ohm  [VX_R0402_SMALL]  78.47 42.15 0 bottom
R1701  240Ohm  [VX_R0402_SMALL]  114.79 47.35 0 bottom
R1704  0Ohm  [VX_R0402_0OHM_SMALL]  101.45 42.15 0 bottom
R1705  0Ohm  [VX_R0402_0OHM_SMALL]  114.41 43.54 180 bottom
R1706  0Ohm  [VX_R0402_0OHM_SMALL]  87.48 42.15 180 bottom
R1707  0Ohm  [VX_R0402_0OHM_SMALL]  117.2 51.21 90 top
R1708  0Ohm  [VX_R0402_0OHM_SMALL]  116.31 51.21 90 top
R1709  0Ohm  [VX_R0402_0OHM_SMALL]  115.68 44.3 90 bottom
R1710  1KOhm  [VX_R0402_SMALL]  59.92 102.72 0 top
R1712  0Ohm  [VX_R0402_0OHM_SMALL]  117.2 52.81 90 top
R1713  0Ohm  [VX_R0402_0OHM_SMALL]  116.31 52.81 90 top
R1714  1KOhm  [VX_R0402_SMALL]  59.92 101.84 180 top
R1715  0Ohm  [VX_R0402_0OHM_SMALL]  103.1 42.15 0 bottom
R1716  0Ohm  [VX_R0402_0OHM_SMALL]  108.06 42.15 180 bottom
R1717  0Ohm  [VX_R0402_0OHM_SMALL]  85.83 42.15 180 bottom
R1719  0Ohm  [VX_R0402_0OHM_SMALL]  114.79 45.57 180 bottom
R2000  1KOhm  [VX_R0402_SMALL]  228.07 69.17 90 top
R2100  10KOhm  [VX_R0402_SMALL]  231.91 43.34 90 bottom
R2102  10KOhm  [VX_R0402_SMALL]  230.84 40.67 90 bottom
R2103  10KOhm  [VX_R0402_SMALL]  230.02 40.67 90 bottom
R2104  10KOhm  [VX_R0402_SMALL]  229.19 40.67 90 bottom
R2105  10KOhm  [VX_R0402_SMALL]  228.45 43.34 90 top
R2106  10KOhm  [VX_R0402_SMALL]  228.34 40.67 90 bottom
R2107  10KOhm  [VX_R0402_SMALL]  227.18 43.34 90 top
R2108  10KOhm  [VX_R0402_SMALL]  225.15 43.34 90 top
R2110  10KOhm  [VX_R0402_SMALL]  227.23 40.24 180 top
R2111  10KOhm  [VX_R0402_SMALL]  227.23 41.08 180 top
R2112  10KOhm  [VX_R0402_SMALL]  226.29 43.34 270 top
R2113  10KOhm  [VX_R0402_SMALL]  221.6 40.67 90 top
R2114  10KOhm  [VX_R0402_SMALL]  223.88 43.34 90 bottom
R2115  10KOhm  [VX_R0402_SMALL]  222.99 40.75 270 bottom
R2116  10KOhm  [VX_R0402_SMALL]  222.99 43.34 90 bottom
R2117  10KOhm  [VX_R0402_SMALL]  227.18 43.34 90 bottom
R2118  10KOhm  [VX_R0402_SMALL]  228.45 43.34 90 bottom
R2119  10KOhm  [VX_R0402_SMALL]  224.26 43.34 90 top
R2120  10KOhm  [VX_R0402_SMALL]  227.51 40.67 90 bottom
R2121  10KOhm  [VX_R0402_SMALL]  226.68 40.67 270 bottom
R2141  10KOhm  [VX_R0402_SMALL]  226.29 43.34 270 bottom
R2145  10KOhm  [VX_R0402_SMALL]  224.26 40.67 270 bottom
R2146  10KOhm  [VX_R0402_SMALL]  221.6 43.34 270 bottom
R2148  100KOhm  [VX_R0402_SMALL]  215.75 43.09 0 top
R2157  10KOhm  [VX_R0402_SMALL]  230.13 43.34 90 bottom
R2165  100KOhm  [VX_R0402_SMALL]  240.7 74.07 90 bottom
R2201  10KOhm  [VX_R0402_SMALL]  212.81 43.34 270 bottom
R2202  10KOhm  [VX_R0402_SMALL]  245.89 67.19 180 top
R2203  10KOhm  [VX_R0402_SMALL]  243.23 64.04 0 top
R2204  10KOhm  [VX_R0402_SMALL]  213.59 40.54 90 bottom
R2205  10KOhm  [VX_R0402_SMALL]  213.65 43.34 90 bottom
R2206  10KOhm  [VX_R0402_SMALL]  243.23 64.93 0 top
R2207  10KOhm  [VX_R0402_SMALL]  220.96 40.67 270 bottom
R2208  10KOhm  [VX_R0402_SMALL]  220.71 43.34 90 bottom
R2209  10KOhm  [VX_R0402_SMALL]  219.82 43.34 270 top
R2210  10KOhm  [VX_R0402_SMALL]  212.71 40.54 90 bottom
R2211  0Ohm  [VX_R0402_0OHM_SMALL]  249.1 60.18 180 bottom
R2227  22Ohm  [VX_R0402_SMALL]  246.07 62.42 180 bottom
R2228  30OHM  [VX_R0402_SMALL]  226.83 74.35 90 bottom
R2235  1KOhm  [VX_R0402_SMALL]  229.37 74.35 90 bottom
R2243  8.2KOhm  [VX_R0402_SMALL]  214.48 43.34 90 top
R2244  10KOhm  [VX_R0402_SMALL]  210.93 40.54 90 bottom
R2245  10KOhm  [VX_R0402_SMALL]  210.04 40.54 90 bottom
R2246  10KOhm  [VX_R0402_SMALL]  218.04 40.67 90 top
R2247  10KOhm  [VX_R0402_SMALL]  217.15 40.67 90 top
R2248  10KOhm  [VX_R0402_SMALL]  218.04 43.34 90 top
R2249  10KOhm  [VX_R0402_SMALL]  214.48 40.42 90 bottom
R2250  10KOhm  [VX_R0402_SMALL]  243.23 61.49 180 bottom
R2251  8.2KOhm  [VX_R0402_SMALL]  246.07 59.77 180 top
R2255  10KOhm  [VX_R0402_SMALL]  210.85 43.34 270 bottom
R2256  10KOhm  [VX_R0402_SMALL]  210.04 43.34 270 bottom
R2257  1KOhm  [VX_R0402_SMALL]  217.15 43.34 270 top
R2258  10KOhm  [VX_R0402_SMALL]  214.48 43.34 270 bottom
R2259  10KOhm  [VX_R0402_SMALL]  222.99 48.54 90 top
R2260  10KOhm  [VX_R0402_SMALL]  223.88 48.54 270 top
R2261  1KOhm  [VX_R0402_SMALL]  218.04 43.34 90 bottom
R2262  2.2KOhm  [VX_R0402_SMALL]  238.63 61.31 0 top
R2263  1KOhm  [VX_R0402_SMALL]  248.75 61.86 180 bottom
R2264  22Ohm  [VX_R0402_SMALL]  243.23 63.02 180 top
R2265  22Ohm  [VX_R0402_SMALL]  246.07 62.42 180 top
R2300  33Ohm  [VX_R0402_SMALL]  245.12 74.58 270 bottom
R2301  33Ohm  [VX_R0402_SMALL]  243.44 74.58 270 bottom
R2302  10KOhm  [VX_R0402_SMALL]  230.21 43.34 90 top
R2303  10KOhm  [VX_R0402_SMALL]  231.92 43.32 90 top
R2304  10KOhm  [VX_R0402_SMALL]  231.03 43.34 90 top
R2305  10KOhm  [VX_R0402_SMALL]  231.02 43.34 90 bottom
R2306  33Ohm  [VX_R0402_SMALL]  244.28 74.58 270 bottom
R2307  30OHM  [VX_R0402_SMALL]  231.9 74.34 270 bottom
R2308  33Ohm  [VX_R0402_SMALL]  241.97 74.07 270 bottom
R2309  10KOhm  [VX_R0402_SMALL]  230.96 40.68 90 top
R2310  10KOhm  [VX_R0402_SMALL]  225.15 36.18 90 bottom
R2311  30OHM  [VX_R0402_SMALL]  232.74 74.34 270 bottom
R2312  1KOhm  [VX_R0402_SMALL]  233.27 40.42 90 top
R2313  1KOhm  [VX_R0402_SMALL]  232.44 40.42 90 top
R2314  0Ohm  [VX_R0402_0OHM_SMALL]  233.58 40.11 90 bottom
R2315  0Ohm  [VX_R0402_0OHM_SMALL]  234.42 40.11 270 bottom
R2316  0Ohm  [VX_R0402_0OHM_SMALL]  236.15 40.47 90 bottom
R2317  0Ohm  [VX_R0402_0OHM_SMALL]  235.29 40.47 270 bottom
R2318  0Ohm  [VX_R0402_0OHM_SMALL]  236.99 40.62 90 bottom
R2319  0Ohm  [VX_R0402_0OHM_SMALL]  237.88 40.62 270 bottom
R2320  0Ohm  [VX_R0402_0OHM_SMALL]  232.75 40.11 90 bottom
R2321  0Ohm  [VX_R0402_0OHM_SMALL]  231.91 40.11 270 bottom
R2323  100KOhm  [VX_R0402_SMALL]  243.19 43.29 90 bottom
R2324  10KOhm  [VX_R0402_SMALL]  230.74 38.03 180 bottom
R2325  0Ohm  [VX_R0402_0OHM_SMALL]  238.06 74.35 90 bottom
R2326  30OHM  [VX_R0402_SMALL]  230.21 74.35 90 bottom
R2327  1KOhm  [VX_R0402_SMALL]  237.6 40.67 270 top
R2328  1KOhm  [VX_R0402_SMALL]  239.24 40.67 270 top
R2329  499Ohm  [VX_R0402_SMALL]  240.06 40.67 90 top
R2330  499Ohm  [VX_R0402_SMALL]  240.9 40.67 90 top
R2331  1KOhm  [VX_R0402_SMALL]  235.91 40.67 90 top
R2332  1KOhm  [VX_R0402_SMALL]  238.64 43.34 90 bottom
R2333  4.7KOhm  [VX_R0402_SMALL]  236.76 40.67 90 top
R2334  4.7KOhm  [VX_R0402_SMALL]  242.53 43.34 90 top
R2335  4.7KOhm  [VX_R0402_SMALL]  248.52 57.05 180 top
R2347  20KOhm  [VX_R0402_SMALL]  236.96 43.34 270 top
R2348  20KOhm  [VX_R0402_SMALL]  241.69 43.34 90 top
R2349  20KOhm  [VX_R0402_SMALL]  245.85 56.8 0 top
R2350  51Ohm  [VX_R0402_SMALL]  233.74 74.35 90 bottom
R2357  10KOhm  [VX_R0402_SMALL]  237.8 43.34 90 bottom
R2358  10KOhm  [VX_R0402_SMALL]  236.96 43.34 90 bottom
R2360  10KOhm  [VX_R0402_SMALL]  234.47 43.34 270 bottom
R2363  10KOhm  [VX_R0402_SMALL]  226.04 36.18 90 bottom
R2364  10KOhm  [VX_R0402_SMALL]  234.96 40.67 90 top
R2365  10KOhm  [VX_R0402_SMALL]  224.42 40.67 90 top
R2371  10KOhm  [VX_R0402_SMALL]  236.03 43.34 90 bottom
R2375  0Ohm  [VX_R0402_0OHM_SMALL]  229.95 45.14 270 top
R2376  0Ohm  [VX_R0402_0OHM_SMALL]  229.06 45.14 90 top
R2378  4.7KOhm  [VX_R0402_SMALL]  239.25 79.08 0 top
R2379  1KOhm  [VX_R0402_SMALL]  234.3 43.67 180 top
R2380  1KOhm  [VX_R0402_SMALL]  234.04 49.82 90 top
R2381  10KOhm  [VX_R0402_SMALL]  232.75 43.34 90 bottom
R2382  0Ohm  [VX_R0402_0OHM_SMALL]  225.15 37.83 270 bottom
R2401  0Ohm  [VX_R0402_0OHM_SMALL]  307.45 100.57 180 top
R2402  0Ohm  [VX_R0402_0OHM_SMALL]  254.49 42.45 0 bottom
R2405  2.2KOhm  [VX_R0402_SMALL]  248.56 56.85 0 bottom
R2406  10KOhm  [VX_R0402_SMALL]  250.82 57 180 top
R2407  10KOhm  [VX_R0402_SMALL]  250.81 55.27 180 top
R2408  10KOhm  [VX_R0402_SMALL]  247.33 60.13 90 bottom
R2409  10KOhm  [VX_R0402_SMALL]  246.07 59.77 180 bottom
R2410  10KOhm  [VX_R0402_SMALL]  243.23 58.07 180 top
R2411  10KOhm  [VX_R0402_SMALL]  243.23 57.23 180 top
R2412  10KOhm  [VX_R0402_SMALL]  243.4 56.77 180 bottom
R2413  20KOhm  [VX_R0402_SMALL]  245.85 56.42 0 bottom
R2414  10KOhm  [VX_R0402_SMALL]  246.87 48.62 180 bottom
R2415  10KOhm  [VX_R0402_SMALL]  246.87 49.92 180 bottom
R2416  10KOhm  [VX_R0402_SMALL]  247.25 49.97 180 top
R2417  10KOhm  [VX_R0402_SMALL]  247.25 50.81 180 top
R2420  10KOhm  [VX_R0402_SMALL]  243.23 59.74 180 bottom
R2421  10KOhm  [VX_R0402_SMALL]  249.69 58.91 90 bottom
R2422  10KOhm  [VX_R0402_SMALL]  243.23 59.03 180 top
R2423  10KOhm  [VX_R0402_SMALL]  243.4 57.61 180 bottom
R2424  20KOhm  [VX_R0402_SMALL]  245.85 55.4 180 top
R2425  10KOhm  [VX_R0402_SMALL]  245.85 58.2 180 bottom
R2426  10KOhm  [VX_R0402_SMALL]  248.52 56.16 180 top
R2427  10KOhm  [VX_R0402_SMALL]  248.52 55.27 180 top
R2428  10KOhm  [VX_R0402_SMALL]  248.52 53.19 180 top
R2429  10KOhm  [VX_R0402_SMALL]  248.52 54.39 180 top
R2430  10KOhm  [VX_R0402_SMALL]  243.87 53.37 180 bottom
R2431  10KOhm  [VX_R0402_SMALL]  243.95 53.83 180 top
R2432  10KOhm  [VX_R0402_SMALL]  243.95 52.56 180 top
R2433  10KOhm  [VX_R0402_SMALL]  250.55 49.99 90 bottom
R2434  10KOhm  [VX_R0402_SMALL]  246.25 51.72 180 top
R2435  10KOhm  [VX_R0402_SMALL]  232.87 43.34 90 top
R2436  10KOhm  [VX_R0402_SMALL]  243.54 51.8 180 bottom
R2437  10KOhm  [VX_R0402_SMALL]  248.52 52.73 180 bottom
R2442  10KOhm  [VX_R0402_SMALL]  245.89 66.3 180 top
R2444  10KOhm  [VX_R0402_SMALL]  245.89 65.41 180 bottom
R2446  1KOhm  [VX_R0402_SMALL]  248.65 65.89 0 bottom
R2447  10KOhm  [VX_R0402_SMALL]  239.5 73.56 270 top
R2448  1MOhm  [VX_R0402_SMALL]  250.48 67.11 270 bottom
R2449  2.2KOhm  [VX_R0402_SMALL]  248.56 57.69 0 bottom
R2450  1KOhm  [VX_R0402_SMALL]  225.23 75.57 270 bottom
R2451  2.2KOhm  [VX_R0402_SMALL]  238.92 74.35 270 bottom
R2452  470Ohm  [VX_R0402_SMALL]  245.34 71.02 90 top
R2454  620Ohm  [VX_R0402_SMALL]  225.61 74.1 180 bottom
R2458  1.5KOhm  [VX_R0402_SMALL]  232.72 67.01 270 top
R2459  10KOhm  [VX_R0402_SMALL]  243.23 66.2 180 top
R2460  20KOhm  [VX_R0402_SMALL]  245.85 57.26 0 bottom
R2463  10KOhm  [VX_R0402_SMALL]  249.03 49.05 180 bottom
R2464  4.7KOhm  [VX_R0402_SMALL]  249.03 49.89 180 bottom
R2465  10KOhm  [VX_R0402_SMALL]  246.25 51.72 180 bottom
R2466  10KOhm  [VX_R0402_SMALL]  246.87 47.76 180 bottom
R2469  10KOhm  [VX_R0402_SMALL]  248.52 51.85 180 bottom
R2472  10KOhm  [VX_R0402_SMALL]  241.66 49.89 180 top
R2473  10KOhm  [VX_R0402_SMALL]  244.23 49.77 0 top
R2474  1KOhm  [VX_R0402_SMALL]  227.67 74.35 90 bottom
R2475  10KOhm  [VX_R0402_SMALL]  242.55 69.4 90 top
R2476  100KOhm  [VX_R0402_SMALL]  240.39 71.4 270 top
R2477  10KOhm  [VX_R0402_SMALL]  241.66 77.25 90 top
R2478  10KOhm  [VX_R0402_SMALL]  245.34 69.37 270 top
R2479  100KOhm  [VX_R0402_SMALL]  239.83 74.1 90 bottom
R2481  10KOhm  [VX_R0402_SMALL]  245.94 52.66 0 top
R2482  10KOhm  [VX_R0402_SMALL]  250.93 50.81 0 top
R2483  0Ohm  [VX_R0402_0OHM_SMALL]  252.76 53.02 270 bottom
R2484  20KOhm  [VX_R0402_SMALL]  249.03 50.73 180 bottom
R2486  10KOhm  [VX_R0402_SMALL]  255.76 71.81 90 bottom
R2487  10KOhm  [VX_R0402_SMALL]  242.35 56.05 0 top
R2489  0Ohm  [VX_R0402_0OHM_SMALL]  248.27 76.86 180 bottom
R2490  10KOhm  [VX_R0402_SMALL]  35.41 25.27 0 top
R2491  0Ohm  [VX_R0402_0OHM_SMALL]  246.87 74.07 90 bottom
R2493  0Ohm  [VX_R0402_0OHM_SMALL]  253.83 73.44 90 bottom
R2494  0Ohm  [VX_R0402_0OHM_SMALL]  254.67 73.44 90 bottom
R2495  0Ohm  [VX_R0402_0OHM_SMALL]  252.23 44.05 270 bottom
R2496  0Ohm  [VX_R0402_0OHM_SMALL]  252.53 42.45 180 bottom
R2497  10KOhm  [VX_R0402_SMALL]  252.53 41.53 0 bottom
R2498  0Ohm  [VX_R0402_0OHM_SMALL]  254.34 47.35 0 bottom
R2512  2.71Kohm  [VX_R0402_H14_SMALL_T01]  213.04 70.21 180 bottom
R2516  100Ohm  [VX_R0402_SMALL]  216.59 61.5 180 top
R2522  0Ohm  [VX_R0402_0OHM_SMALL]  213.04 67.8 180 bottom
R2523  10MOhm  [VX_R0402_SMALL]  242.94 69.44 270 bottom
R2524  1MOhm  [VX_R0402_SMALL]  211.82 68.23 270 bottom
R2525  0Ohm  [VX_R0402_0OHM_SMALL]  243.77 70.1 270 bottom
R2526  113Ohm  [VX_R0402_SMALL]  223.96 75.19 0 bottom
R2529  0Ohm  [VX_R0402_0OHM_SMALL]  213.04 68.66 180 bottom
R2601  0Ohm  [VX_R0603_0OHM_H28_SMALL]  248.86 41.75 90 top
R2602  100KOhm  [VX_R0402_SMALL]  250.93 44.94 270 top
R2607  0Ohm  [VX_R0603_0OHM_H28_SMALL]  230.74 63.6 0 top
R2608  0Ohm  [VX_R0603_0OHM_H28_SMALL]  245.47 73.31 270 top
R2610  100KOhm  [VX_R0402_SMALL]  251.69 48.75 90 top
R2611  0Ohm  [VX_R0603_0OHM_H28_SMALL]  224.44 55.48 0 top
R2616  0Ohm  [VX_R0603_0OHM_H28_SMALL]  243.53 47.98 270 bottom
R2617  0Ohm  [VX_R0603_0OHM_H28_SMALL]  229.79 74.4 0 top
R2619  0Ohm  [VX_R0603_0OHM_H28_SMALL]  244.81 47.98 270 bottom
R2801  0Ohm  [VX_R0603_0OHM_H28_SMALL]  95.06 15 270 bottom
R2802  0Ohm  [VX_R0603_0OHM_H28_SMALL]  96.38 14.99 270 bottom
R2803  10MOhm  [VX_R0402_SMALL]  248.65 66.53 0 top
R2804  100KOhm  [VX_R0402_SMALL]  250.55 61.83 0 bottom
R2810  20KOhm  [VX_R0402_SMALL]  273.41 65.77 270 bottom
R2811  1KOhm  [VX_R0402_SMALL]  279.1 64.17 90 bottom
R2812  20KOhm  [VX_R0402_SMALL]  272.57 65.77 270 bottom
R3001  10KOhm  [VX_R0402_SMALL]  165.74 19.92 180 top
R3003  100KOhm  [VX_R0402_SMALL]  152.51 22.97 270 bottom
R3004  10KOhm  [VX_R0402_SMALL]  165.92 22.49 180 bottom
R3005  10KOhm  [VX_R0402_SMALL]  165.79 35.44 180 top
R3006  100KOhm  [VX_R0402_SMALL]  141.59 31.45 0 top
R3007  100KOhm  [VX_R0402_SMALL]  159.39 29.8 180 bottom
R3010  10KOhm  [VX_R0402_SMALL]  162.4 22.03 180 bottom
R3011  0Ohm  [VX_R0402_0OHM_SMALL]  159.39 28.96 180 bottom
R3012  15Ohm  [VX_R0402_SMALL]  160.51 33.51 0 bottom
R3013  0Ohm  [VX_R0402_0OHM_SMALL]  161.14 38.46 270 top
R3017  15Ohm  [VX_R0402_SMALL]  168.89 23.1 0 top
R3019  15Ohm  [VX_R0402_SMALL]  152.76 31.22 180 bottom
R3021  15Ohm  [VX_R0402_SMALL]  160.51 32.49 180 bottom
R3022  15Ohm  [VX_R0402_SMALL]  155.43 25 180 bottom
R3023  15Ohm  [VX_R0402_SMALL]  155.43 26.02 0 bottom
R3024  15Ohm  [VX_R0402_SMALL]  154.92 31.22 180 bottom
R3025  0Ohm  [VX_R0603_0OHM_H28_SMALL]  162.16 23.15 180 bottom
R3026  10KOhm  [VX_R0402_SMALL]  162.41 36.56 270 top
R3027  10KOhm  [VX_R0402_SMALL]  162.41 38.34 270 top
R3028  15Ohm  [VX_R0402_SMALL]  154.92 29.7 0 bottom
R3029  4.7KOhm  [VX_R0402_SMALL]  156.75 15.42 270 top
R3030  4.7KOhm  [VX_R0402_SMALL]  155.73 15.42 270 top
R3031  0Ohm  [VX_R0603_0OHM_H28_SMALL]  163.68 36.68 270 top
R3034  0Ohm  [VX_R0402_0OHM_SMALL]  165.67 28.69 180 top
R3035  0Ohm  [VX_R0402_0OHM_SMALL]  165.67 29.6 180 top
R3036  0Ohm  [VX_R0402_0OHM_SMALL]  163.35 20.28 90 bottom
R3038  0Ohm  [VX_R0603_0OHM_H28_SMALL]  155.56 23.35 270 bottom
R3039  0Ohm  [VX_R0603_0OHM_H28_SMALL]  160.51 31.35 180 bottom
R3040  0Ohm  [VX_R0603_0OHM_H28_SMALL]  161.02 29.06 90 bottom
R3041  15Ohm  [VX_R0402_SMALL]  165.92 20.78 180 top
R3042  10KOhm  [VX_R0402_SMALL]  162.29 19.03 0 bottom
R3043  15Ohm  [VX_R0402_SMALL]  165.92 23.31 180 top
R3044  15Ohm  [VX_R0402_SMALL]  165.92 21.65 180 top
R3045  10KOhm  [VX_R0402_SMALL]  163.94 19.03 0 bottom
R3053  10KOhm  [VX_R0402_SMALL]  154.92 32.49 0 bottom
R3061  100KOhm  [VX_R0402_SMALL]  140.95 39.99 90 top
R3062  100KOhm  [VX_R0402_SMALL]  153.14 38.45 270 top
R3063  100KOhm  [VX_R0402_SMALL]  151.49 38.45 270 top
R3064  100KOhm  [VX_R0402_SMALL]  152.32 38.45 270 top
R3065  47KOhm  [VX_R0402_SMALL]  165.92 31.73 180 top
R3066  47KOhm  [VX_R0402_SMALL]  165.79 26.93 180 top
R3070  10KOhm  [VX_R0402_SMALL]  167.65 26.67 180 top
R3071  10KOhm  [VX_R0402_SMALL]  167.44 25.24 180 top
R3072  10KOhm  [VX_R0402_SMALL]  159.09 15.8 90 top
R3073  10KOhm  [VX_R0402_SMALL]  158.25 15.8 90 top
R3074  0Ohm  [VX_R0402_0OHM_SMALL]  146.03 12.22 0 top
R3075  0Ohm  [VX_R0402_0OHM_SMALL]  146.03 13.42 0 top
R3077  0Ohm  [VX_R0402_0OHM_SMALL]  281.51 56.01 0 top
R3079  0Ohm  [VX_R0402_0OHM_SMALL]  156.85 17.01 270 top
R3080  0Ohm  [VX_R0402_0OHM_SMALL]  155.96 17.01 270 top
R3081  10KOhm  [VX_R0402_SMALL]  165.79 34.35 180 top
R3092  0Ohm  [VX_R0402_0OHM_SMALL]  155.05 17.01 270 top
R3098  0Ohm  [VX_R0402_0OHM_SMALL]  168.87 29.42 0 top
R3099  15Ohm  [VX_R0402_SMALL]  165.92 22.49 180 top
R3101  3.01KOHM  [VX_R0402_SMALL]  171.18 22.33 90 top
R3102  0Ohm  [VX_R0402_0OHM_SMALL]  46.21 129.14 180 top
R3103  0Ohm  [VX_R0402_0OHM_SMALL]  48.11 129.14 0 top
R3104  2.7KOhm  [VX_R0402_SMALL]  209.02 40.37 180 top
R3105  2.7KOhm  [VX_R0402_SMALL]  211.92 38.95 180 top
R3106  15KOhm  [VX_R0402_SMALL]  44.18 125.97 180 top
R3107  1KOhm  [VX_R0402_SMALL]  44.18 124.06 180 top
R3108  0Ohm  [VX_R0402_0OHM_SMALL]  209.02 41.26 180 top
R3109  2.7KOhm  [VX_R0402_SMALL]  46.21 127.87 0 top
R3110  0Ohm  [VX_R0402_0OHM_SMALL]  211.92 38.11 180 top
R3111  2.7KOhm  [VX_R0402_SMALL]  48.24 124.06 180 top
R3112  1KOhm  [VX_R0402_SMALL]  208.01 36.18 0 top
R3113  0Ohm  [VX_R0402_0OHM_SMALL]  48.24 127.87 180 top
R3114  15KOhm  [VX_R0402_SMALL]  209.78 36.18 0 top
R3115  0Ohm  [VX_R0402_0OHM_SMALL]  46.21 124.06 0 top
R3116  1KOhm  [VX_R0402_SMALL]  172.83 35.8 270 top
R3117  3.3KOhm  [VX_R0402_SMALL]  174.35 23.86 0 bottom
R3124  1KOhm  [VX_R0402_SMALL]  175.37 24.11 270 top
R3137  0Ohm  [VX_R0402_0OHM_SMALL]  181.84 16.87 0 top
R3140  169OHM  [VX_R0402_SMALL]  181.84 20.4 180 top
R3141  10KOhm  [VX_R0402_SMALL]  179.56 20.4 270 top
R3142  10KOhm  [VX_R0402_SMALL]  181.57 21.37 0 top
R3143  10KOhm  [VX_R0402_SMALL]  178.67 20.4 270 top
R3144  10KOhm  [VX_R0402_SMALL]  181.84 19.51 0 top
R3145  10KOhm  [VX_R0402_SMALL]  177.83 20.4 270 top
R3146  10KOhm  [VX_R0402_SMALL]  181.84 18.63 0 top
R3147  10KOhm  [VX_R0402_SMALL]  177.01 20.4 270 top
R3148  10KOhm  [VX_R0402_SMALL]  181.84 17.74 0 top
R3156  33Ohm  [VX_R0402_SMALL]  172.42 23.4 270 top
R3157  33Ohm  [VX_R0402_SMALL]  173.38 23.96 270 top
R3158  33Ohm  [VX_R0402_SMALL]  174.54 24.11 270 top
R3159  33Ohm  [VX_R0402_SMALL]  173.72 35.8 270 top
R3160  33Ohm  [VX_R0402_SMALL]  174.99 35.36 180 top
R3167  10KOhm  [VX_R0402_SMALL]  275.44 58.15 180 bottom
R3168  100KOhm  [VX_R0402_SMALL]  273.78 59.04 180 bottom
R3169  330Ohm  [VX_R0603_H28_SMALL]  277.81 54.46 270 bottom
R3170  0Ohm  [VX_R0603_0OHM_H28_SMALL]  277.35 49.89 180 bottom
R3172  10KOhm  [VX_R0402_SMALL]  181.84 15.09 0 top
R3301  30KOhm  [VX_R0402_SMALL]  290.05 96.3 270 top
R3306  2.37KOhm  [VX_R0402_SMALL]  283.29 103.69 270 top
R3307  4.7KOhm  [VX_R0402_SMALL]  287.66 93.95 180 top
R3400  75Ohm  [VX_R0402_SMALL]  307.45 152.08 0 top
R3401  75Ohm  [VX_R0402_SMALL]  307.45 151.11 0 top
R3402  75Ohm  [VX_R0402_SMALL]  306.69 148.49 0 top
R3403  75Ohm  [VX_R0402_SMALL]  306.69 145.52 0 top
R3404  0Ohm  [VX_R0603_0OHM_H28_SMALL]  299.07 149 0 bottom
R3600  100KOhm  [VX_R0402_SMALL]  10.14 38.46 0 top
R3603  100KOhm  [VX_R0402_SMALL]  15.6 26.02 0 top
R3604  10KOhm  [VX_R0402_SMALL]  19.54 21.57 0 top
R3606  22KOhm  [VX_R0402_SMALL]  16.82 22.46 0 top
R3607  22KOhm  [VX_R0402_SMALL]  15.22 22.46 180 top
R3608  10KOhm  [VX_R0402_SMALL]  19.54 22.46 0 top
R3610  0Ohm  [VX_R0402_0OHM_SMALL]  5.95 23.73 90 top
R3611  22Ohm  [VX_R0402_SMALL]  6.84 23.73 90 top
R3613  22Ohm  [VX_R0402_SMALL]  10.06 23.73 90 top
R3620  0Ohm  [VX_R0402_0OHM_SMALL]  13.04 28.49 180 top
R3621  0Ohm  [VX_R0402_0OHM_SMALL]  3.66 45.96 270 top
R3622  0Ohm  [VX_R0402_0OHM_SMALL]  19.54 20.68 180 top
R3623  200KOhm  [VX_R0402_SMALL]  13.44 27.54 0 top
R3624  100KOhm  [VX_R0402_SMALL]  13.44 26.65 0 top
R3629  0Ohm  [VX_R0603_0OHM_H28_SMALL]  13.82 45.96 270 top
R3630  0Ohm  [VX_R0603_0OHM_H28_SMALL]  2.14 40.11 0 top
R3631  0Ohm  [VX_R0603_0OHM_H28_SMALL]  7.09 45.96 270 top
R3632  10KOhm  [VX_R0402_SMALL]  16.24 19.54 180 top
R3700  6.98KOhm  [VX_R0402_SMALL]  59.16 12.05 0 bottom
R3704  6.98KOhm  [VX_R0402_SMALL]  59.16 14.21 0 bottom
R3707  0Ohm  [VX_R0402_0OHM_SMALL]  67.93 15.22 270 top
R3708  0Ohm  [VX_R0402_0OHM_SMALL]  69.07 15.22 270 top
R3711  12KOhm  [VX_R0402_SMALL]  59.16 13.32 0 bottom
R3712  12KOhm  [VX_R0402_SMALL]  60.43 14.08 270 bottom
R3713  0Ohm  [VX_R1206_H28]  69.83 12.3 0 top
R3714  0Ohm  [VX_R1206_H28]  69.83 10.01 0 top
R4403  0Ohm  [VX_R0402_0OHM_SMALL]  65.64 143.49 180 bottom
R4404  1KOhm  [VX_R0402_SMALL]  58.51 126.73 90 bottom
R4405  1KOhm  [VX_R0402_SMALL]  57.61 125.1 270 bottom
R4406  1KOhm  [VX_R0402_SMALL]  58.44 125.1 270 bottom
R4409  150Ohm  [VX_R0402_SMALL]  60.4 126.73 270 bottom
R4410  2.2KOhm  [VX_R0402_SMALL]  56.72 125.09 90 bottom
R4411  2.2KOhm  [VX_R0402_SMALL]  62.71 125.13 90 bottom
R4412  1KOhm  [VX_R0402_SMALL]  60.18 125.13 90 bottom
R4414  1KOhm  [VX_R0402_SMALL]  63.58 125.13 270 bottom
R4415  0Ohm  [VX_R0402_0OHM_SMALL]  59.31 125.13 270 bottom
R4416  1KOhm  [VX_R0402_SMALL]  61.02 125.13 270 bottom
R4417  0Ohm  [VX_R0402_0OHM_SMALL]  61.85 125.13 270 bottom
R4418  1KOhm  [VX_R0402_SMALL]  57.61 126.73 270 bottom
R4422  1KOhm  [VX_R0402_SMALL]  63.19 148.75 90 bottom
R4423  0Ohm  [VX_R0402_0OHM_SMALL]  56.72 126.73 90 bottom
R4424  0Ohm  [VX_R0402_0OHM_SMALL]  64.06 148.75 270 bottom
R4425  1KOhm  [VX_R0402_SMALL]  53.24 126.74 270 bottom
R4427  51Ohm  [VX_R0402_SMALL]  70.39 127.93 0 top
R4428  51Ohm  [VX_R0402_SMALL]  68.04 125.59 270 bottom
R4501  10KOhm  [VX_R0402_SMALL]  123.55 191.12 90 bottom
R4505  200KOhm  [VX_R0402_SMALL]  120.12 191.12 90 bottom
R4517  10KOhm  [VX_R0402_SMALL]  124.44 191.12 270 bottom
R4518  100KOhm  [VX_R0402_SMALL]  94.06 187.56 0 top
R4523  10KOhm  [VX_R0402_SMALL]  113.93 186.98 0 bottom
R4524  10KOhm  [VX_R0402_SMALL]  115.58 187.02 180 bottom
R4525  4.7KOhm  [VX_R0402_SMALL]  92.69 190.86 270 top
R4526  10KOhm  [VX_R0402_SMALL]  110.6 184.13 0 bottom
R4587  10KOhm  [VX_R0402_SMALL]  109.51 191.75 270 bottom
R4592  10KOhm  [VX_R0402_SMALL]  95.66 187.56 180 top
R4593  10KOhm  [VX_R0402_SMALL]  92.69 187.56 90 top
R4595  0Ohm  [VX_R0402_0OHM_SMALL]  122.28 192.26 180 bottom
R4596  0Ohm  [VX_R0402_0OHM_SMALL]  125.46 188.2 0 bottom
R4597  10KOhm  [VX_R0402_SMALL]  111.49 182.73 270 bottom
R4601  4.7KOhm  [VX_R0402_SMALL]  299.45 118.47 90 top
R4602  4.7KOhm  [VX_R0402_SMALL]  297.52 118.47 90 top
R4604  4.7KOhm  [VX_R0402_SMALL]  299.19 105.26 270 top
R4605  200KOhm  [VX_R0402_SMALL]  292.84 106.15 90 top
R4606  4.7KOhm  [VX_R0402_SMALL]  298.56 118.47 90 top
R4607  100KOhm  [VX_R0402_SMALL]  302.62 120.93 180 top
R4608  100KOhm  [VX_R0402_SMALL]  302.62 119.69 180 top
R4609  1MOhm  [VX_R0402_SMALL]  282.81 113.52 180 top
R4610  1MOhm  [VX_R0402_SMALL]  303.71 122.13 0 top
R4611  4.7KOhm  [VX_R0402_SMALL]  298.3 105.26 270 top
R4623  4.7KOhm  [VX_R0402_SMALL]  301.22 118.47 90 top
R4624  4.7KOhm  [VX_R0402_SMALL]  294.62 117.18 180 top
R4625  4.7KOhm  [VX_R0402_SMALL]  300.34 118.47 90 top
R4626  4.7KOhm  [VX_R0402_SMALL]  294.62 118.02 180 top
R4627  4.7KOhm  [VX_R0402_SMALL]  296.68 118.47 90 top
R4629  10KOhm  [VX_R0402_SMALL]  306.3 111.03 90 top
R4801  200KOhm  [VX_R0402_SMALL]  310.11 97.52 270 top
R4806  2KOhm  [VX_R0402_SMALL]  307.42 84.56 90 top
R4807  2KOhm  [VX_R0402_SMALL]  307.42 86.21 270 top
R5000  4.7KOhm  [VX_R0402_SMALL]  62.2 111.85 90 bottom
R5001  5.1KOhm  [VX_R0402_SMALL]  293.6 134.86 180 top
R5002  5.1KOhm  [VX_R0402_SMALL]  292.21 135.24 270 top
R5003  4.7KOhm  [VX_R0402_SMALL]  60.04 111.42 180 bottom
R5004  100KOhm  [VX_R0402_SMALL]  140.06 39.99 90 top
R5005  1.5KOhm  [VX_R0402_SMALL]  58.39 111.42 180 bottom
R5006  150Ohm  [VX_R0402_SMALL]  62.2 113.5 90 bottom
R5007  4.7KOhm  [VX_R0402_SMALL]  265.89 85.27 0 top
R5008  4.7KOhm  [VX_R0402_SMALL]  263.84 85.4 90 top
R5009  1.5KOhm  [VX_R0402_SMALL]  263.84 87.18 90 top
R5010  150Ohm  [VX_R0402_SMALL]  267.54 85.27 0 top
R5011  10KOhm  [VX_R0402_SMALL]  291.01 129.88 180 top
R5012  10KOhm  [VX_R0402_SMALL]  44.68 120.38 180 top
R5013  10KOhm  [VX_R0402_SMALL]  259.06 93.4 0 top
R5014  100KOhm  [VX_R0402_SMALL]  138.92 37.73 0 top
R5015  1KOhm  [VX_R0402_SMALL]  43.29 120.38 180 bottom
R5016  1KOhm  [VX_R0402_SMALL]  259.07 92.03 0 top
R5017  22KOhm  [VX_R0402_SMALL]  283.22 104.4 90 bottom
R5018  10KOhm  [VX_R0402_SMALL]  279.89 107.68 270 bottom
R5019  10KOhm  [VX_R0402_SMALL]  79.86 8.62 180 top
R5020  100KOhm  [VX_R0402_SMALL]  143.29 32.9 180 top
R5021  4.7KOhm  [VX_R0402_SMALL]  79.86 7.35 180 top
R5022  10KOhm  [VX_R0402_SMALL]  127.23 29.45 0 top
R5115  10KOhm  [VX_R0402_SMALL]  34.52 22.71 180 top
R5131  0Ohm  [VX_R0402_0OHM_SMALL]  33.64 16.75 0 bottom
R5200  80.6KOhm  [VX_R0402_SMALL]  309.1 65.77 0 top
R5201  22KOhm  [VX_R0402_SMALL]  309.1 66.66 0 top
R5206  100KOhm  [VX_R0402_SMALL]  299.32 65.18 180 top
R5207  100KOhm  [VX_R0402_SMALL]  297.17 64.66 0 top
R5208  10KOhm  [VX_R0402_SMALL]  299.49 63.48 0 top
R5209  100KOhm  [VX_R0402_SMALL]  294.44 65.21 180 top
R5210  100KOhm  [VX_R0402_SMALL]  294.44 64.37 0 top
R5211  0Ohm  [VX_R0402_0OHM_SMALL]  292.46 69.98 0 top
R5300  4.7KOhm  [VX_R0402_SMALL]  301.24 99.45 90 top
R5301  20KOhm  [VX_R0402_SMALL]  297.36 96.96 90 top
R5302  10KOhm  [VX_R0402_SMALL]  297.36 95.36 270 top
R5305  10KOhm  [VX_R0402_SMALL]  305.29 96.96 90 top
R5306  10KOhm  [VX_R0402_SMALL]  301 93.03 90 top
R5307  100KOhm  [VX_R0402_SMALL]  284.71 88.75 0 bottom
R5308  4.7KOhm  [VX_R0402_SMALL]  302.06 99.45 90 top
R5309  100KOhm  [VX_R0402_SMALL]  284.71 89.64 0 bottom
R5310  0Ohm  [VX_R0402_0OHM_SMALL]  301.53 103.97 270 top
R5311  0Ohm  [VX_R0402_0OHM_SMALL]  299.72 102.22 0 top
R5312  0Ohm  [VX_R0402_0OHM_SMALL]  299.72 101.38 0 top
R5313  0Ohm  [VX_R0402_0OHM_SMALL]  294.32 98.15 180 top
R5314  0Ohm  [VX_R0402_0OHM_SMALL]  302.75 87.46 270 bottom
R5319  0Ohm  [VX_R0402_0OHM_SMALL]  297.8 92.18 0 top
R5341  0Ohm  [VX_R0402_0OHM_SMALL]  296.14 92.18 180 top
R5349  10KOhm  [VX_R0402_SMALL]  302.37 101.84 270 top
R5354  10KOhm  [VX_R0402_SMALL]  301.86 97.01 90 top
R5355  0Ohm  [VX_R0402_0OHM_SMALL]  300.92 97.85 90 top
R5356  0Ohm  [VX_R0402_0OHM_SMALL]  292.72 92.18 180 top
R5501  220KOhm  [VX_R0402_SMALL]  302.88 67.67 90 top
R5601  10KOhm  [VX_R0402_SMALL]  89.8 188.3 90 top
R5602  10KOhm  [VX_R0402_SMALL]  88.91 188.3 90 top
R5603  10KOhm  [VX_R0402_SMALL]  92.39 186.34 0 top
R5701  5.1OHM  [VX_R0805_SMALL_T01]  201.86 136.28 180 top
R5702  5.1OHM  [VX_R0805_SMALL_T01]  201.86 134.5 180 top
R5703  5.1OHM  [VX_R0805_SMALL_T01]  201.86 139.83 180 top
R5704  100KOhm  [VX_R0402_SMALL]  208.26 138.74 270 top
R5705  5.1OHM  [VX_R0805_SMALL_T01]  201.86 138.06 180 top
R5707  100KOhm  [VX_R0402_SMALL]  206.86 133.79 180 top
R5709  100KOhm  [VX_R0402_SMALL]  138.41 31.86 0 bottom
R5710  330Ohm  [VX_R0603_H28_SMALL]  136.63 32.62 270 bottom
R5712  100KOhm  [VX_R0402_SMALL]  17.51 60 90 top
R5713  330Ohm  [VX_R0603_H28_SMALL]  20.05 56.12 180 top
R5714  330Ohm  [VX_R0603_H28_SMALL]  117.2 8.62 0 top
R5715  100KOhm  [VX_R0402_SMALL]  280.12 66 90 bottom
R5717  330Ohm  [VX_R0603_H28_SMALL]  273.18 100.62 180 bottom
R5718  330Ohm  [VX_R0603_H28_SMALL]  282.43 70.06 180 bottom
R5719  51Ohm  [VX_R0402_SMALL]  232.44 26.17 180 bottom
R5720  5.1OHM  [VX_R0805_SMALL_T01]  123.35 130.13 0 top
R5721  5.1OHM  [VX_R0805_SMALL_T01]  123.35 128.35 0 top
R5722  5.1OHM  [VX_R0805_SMALL_T01]  123.35 131.91 0 top
R5723  100KOhm  [VX_R0402_SMALL]  236.4 29.85 180 bottom
R5727  100KOhm  [VX_R0402_SMALL]  236.35 26.07 0 bottom
R5728  5.1OHM  [VX_R0805_SMALL_T01]  198.1 55.99 180 bottom
R5729  5.1OHM  [VX_R0805_SMALL_T01]  198.1 54.08 180 bottom
R5730  5.1OHM  [VX_R0805_SMALL_T01]  198.1 57.77 180 bottom
R5731  5.1OHM  [VX_R0805_SMALL_T01]  201.86 132.72 180 top
R5732  5.1OHM  [VX_R0805_SMALL_T01]  123.35 126.6 0 top
R5733  5.1OHM  [VX_R0805_SMALL_T01]  123.35 124.8 0 top
R5734  5.1OHM  [VX_R0805_SMALL_T01]  123.25 137.27 0 top
R5735  5.1OHM  [VX_R0805_SMALL_T01]  123.25 139.02 0 top
R5736  100KOhm  [VX_R0402_SMALL]  125.18 146.16 270 top
R5737  0Ohm  [VX_R0402_0OHM_SMALL]  129.04 144.94 0 top
R5738  5.1OHM  [VX_R0805_SMALL_T01]  127.01 88.6 0 bottom
R5739  5.1OHM  [VX_R0805_SMALL_T01]  127.01 90.43 0 bottom
R5740  100KOhm  [VX_R0402_SMALL]  128.25 148.47 0 top
R5741  0Ohm  [VX_R0402_0OHM_SMALL]  127.41 144.94 180 top
R5742  5.1OHM  [VX_R0805_SMALL_T01]  133.99 167.57 270 bottom
R5743  5.1OHM  [VX_R0805_SMALL_T01]  132.19 167.57 270 bottom
R5744  100KOhm  [VX_R0402_SMALL]  127.72 168 90 bottom
R5745  0Ohm  [VX_R0402_0OHM_SMALL]  127.74 164.98 270 bottom
R5801  0Ohm  [VX_R0402_0OHM_SMALL]  300.21 129.78 270 top
R5802  0Ohm  [VX_R0402_0OHM_SMALL]  301.1 129.78 270 top
R5803  0Ohm  [VX_R0402_0OHM_SMALL]  298.3 133.63 0 top
R5804  0Ohm  [VX_R0402_0OHM_SMALL]  302.04 129.77 90 top
R5805  0Ohm  [VX_R0402_0OHM_SMALL]  306.56 133.2 180 top
R5806  10KOhm  [VX_R0402_SMALL]  298.3 134.47 180 top
R5807  0Ohm  [VX_R0402_0OHM_SMALL]  306.56 134.22 180 top
R5808  0Ohm  [VX_R0402_0OHM_SMALL]  303.23 129.78 90 top
R5809  15KOhm  [VX_R0402_SMALL]  306.56 136.13 0 top
R5810  0Ohm  [VX_R0402_0OHM_SMALL]  300.59 137.9 0 top
R5811  10KOhm  [VX_R0402_SMALL]  306.56 135.24 180 top
R6001  100KOhm  [VX_R0402_SMALL]  291.05 27.74 90 bottom
R6002  0Ohm  [VX_R0805_0OHM_H24_SMALL]  11.31 63.3 90 top
R6005  0Ohm  [VX_R0603_0OHM_H28_SMALL]  33 57.77 0 bottom
R6006  100KOhm  [VX_R0402_SMALL]  305.54 76.69 270 bottom
R6007  0Ohm  [VX_R0805_0OHM_H24_SMALL]  13.9 61.96 0 top
R6008  0Ohm  [VX_R0805_0OHM_H24_SMALL]  18.12 65.74 90 bottom
R6009  0Ohm  [VX_R0603_0OHM_H28_SMALL]  20.38 63.56 0 bottom
R6101  10KOhm  [VX_R0402_SMALL]  219.69 40.29 90 bottom
R6102  10KOhm  [VX_R0402_SMALL]  219.82 43.34 270 bottom
R6103  10KOhm  [VX_R0402_SMALL]  218.29 40.29 90 bottom
R6104  10KOhm  [VX_R0402_SMALL]  218.93 43.34 270 bottom
R6113  10KOhm  [VX_R0402_SMALL]  218.93 40.67 90 top
R6114  10KOhm  [VX_R0402_SMALL]  218.93 43.34 270 top
R6115  10KOhm  [VX_R0402_SMALL]  211.82 40.54 90 bottom
R6116  10KOhm  [VX_R0402_SMALL]  211.94 43.34 270 bottom
R6117  10KOhm  [VX_R0402_SMALL]  219.82 40.67 90 top
R6118  10KOhm  [VX_R0402_SMALL]  220.71 40.67 270 top
R6119  10KOhm  [VX_R0402_SMALL]  215.37 40.42 90 bottom
R6120  10KOhm  [VX_R0402_SMALL]  215.37 43.34 270 bottom
R6121  10KOhm  [VX_R0402_SMALL]  217.15 40.29 90 bottom
R6122  10KOhm  [VX_R0402_SMALL]  217.15 43.34 270 bottom
R6123  10KOhm  [VX_R0402_SMALL]  216.26 40.42 90 bottom
R6124  10KOhm  [VX_R0402_SMALL]  216.26 43.34 270 bottom
R6737  4.7KOhm  [VX_R0402_SMALL]  9 43.8 0 top
R6738  4.7KOhm  [VX_R0402_SMALL]  9 45.07 0 top
R6740  0Ohm  [VX_R0603_0OHM_H28_SMALL]  18.78 86.72 0 top
R6745  47KOhm  [VX_R0402_SMALL]  1.96 56.37 0 top
R6746  47KOhm  [VX_R0402_SMALL]  3.41 51.62 90 top
R7001  10KOhm  [VX_R0402_SMALL]  133.56 92.7 270 bottom
R7004  0Ohm  [VX_R0402_0OHM_SMALL]  142.97 67.23 180 bottom
R7005  0Ohm  [VX_R0402_0OHM_SMALL]  133.6 90.28 270 bottom
R7006  100KOhm  [VX_R0402_SMALL]  142.53 61.95 270 bottom
R7007  100KOhm  [VX_R0402_SMALL]  124.64 81.87 0 bottom
R7009  2.49KOhm  [VX_R0402_SMALL]  139.4 106.48 180 bottom
R7100  10KOhm  [VX_R0402_SMALL]  163.06 125.3 180 bottom
R7101  10KOhm  [VX_R0402_SMALL]  151.37 125.34 0 bottom
R7102  10KOhm  [VX_R0402_SMALL]  192.86 119.22 90 bottom
R7103  10KOhm  [VX_R0402_SMALL]  184.51 125.56 0 bottom
R7104  10KOhm  [VX_R0402_SMALL]  192.72 84.23 90 bottom
R7105  10KOhm  [VX_R0402_SMALL]  194.77 93.45 0 bottom
R7106  10KOhm  [VX_R0402_SMALL]  166.46 63.1 0 bottom
R7107  10KOhm  [VX_R0402_SMALL]  175.22 62.84 180 bottom
R7112  10KOhm  [VX_R0402_SMALL]  140.67 134.07 90 top
R7113  10KOhm  [VX_R0402_SMALL]  172.37 134.09 90 top
R7114  10KOhm  [VX_R0402_SMALL]  175.34 134.4 90 top
R7115  10KOhm  [VX_R0402_SMALL]  201.99 109.46 270 top
R7116  10KOhm  [VX_R0402_SMALL]  202.03 106.56 90 top
R7117  10KOhm  [VX_R0402_SMALL]  201.53 74.28 270 top
R7118  10KOhm  [VX_R0402_SMALL]  187.08 53.6 270 top
R7119  10KOhm  [VX_R0402_SMALL]  155.3 53.91 270 top
R7201  100KOhm  [VX_R0402_SMALL]  261.35 52.78 180 top
R7204  1KOhm  [VX_R0402_SMALL]  145.27 91.35 0 top
R7205  10KOhm  [VX_R0402_SMALL]  143.64 69.5 90 top
R7208  10KOhm  [VX_R0402_SMALL]  136.2 76.55 180 bottom
R7210  10KOhm  [VX_R0402_SMALL]  143.62 71.36 270 top
R7211  10KOhm  [VX_R0402_SMALL]  138.23 76.55 0 bottom
R7212  1KOhm  [VX_R0402_SMALL]  145.23 89.14 0 top
R7213  100KOhm  [VX_R0402_SMALL]  288.78 121.06 180 top
R7214  100KOhm  [VX_R0402_SMALL]  290.68 117.41 0 top
R7216  4.7KOhm  [VX_R0402_SMALL]  287.41 126.47 0 top
R7217  4.7KOhm  [VX_R0402_SMALL]  287.41 122.79 0 top
R7218  4.7KOhm  [VX_R0402_SMALL]  287.41 128.38 0 top
R7221  1KOhm  [VX_R0402_SMALL]  145.88 85.83 0 top
R7225  10KOhm  [VX_R0402_SMALL]  283.83 84.06 0 top
R7226  10KOhm  [VX_R0402_SMALL]  283.83 85.58 0 top
R7227  0Ohm  [VX_R0603_0OHM_H28_SMALL]  286.24 84.18 0 top
R7228  0Ohm  [VX_R0603_0OHM_H28_SMALL]  286.24 85.58 0 top
R7229  100KOhm  [VX_R0402_SMALL]  261.35 53.83 180 top
R7230  4.7KOhm  [VX_R0402_SMALL]  284.97 114.41 0 top
R7321  100KOhm  [VX_R0402_SMALL]  130.61 81.95 90 bottom
R7322  100KOhm  [VX_R0402_SMALL]  130.61 80.3 270 bottom
R7400  10KOhm  [VX_R0402_SMALL]  130.87 69.83 90 bottom
R7401  100KOhm  [VX_R0402_SMALL]  136.89 68.79 180 bottom
R7402  33Ohm  [VX_R0402_SMALL]  136.89 62.36 180 bottom
R7403  33Ohm  [VX_R0402_SMALL]  136.89 66.1 180 bottom
R7404  100KOhm  [VX_R0402_SMALL]  139.17 68.79 0 bottom
R7405  1.8KOHM  [VX_R0402_SMALL]  138.74 79.79 90 bottom
R7406  1.8KOHM  [VX_R0402_SMALL]  137.92 79.79 90 bottom
R7407  1.8KOHM  [VX_R0402_SMALL]  136.26 79.79 90 bottom
R7408  1.8KOHM  [VX_R0402_SMALL]  137.09 79.79 90 bottom
R7409  1.8KOHM  [VX_R0402_SMALL]  133.15 79.99 180 bottom
R7410  1.8KOHM  [VX_R0402_SMALL]  134.98 74.81 90 bottom
R7411  1KOhm  [VX_R0402_SMALL]  152.13 61.68 0 bottom
R7412  100KOhm  [VX_R0402_SMALL]  136.89 69.63 180 bottom
R7413  100KOhm  [VX_R0402_SMALL]  139.17 69.63 0 bottom
R7414  10KOhm  [VX_R0402_SMALL]  141.33 71.36 270 bottom
R7415  100KOhm  [VX_R0402_SMALL]  136.89 70.47 180 bottom
R7416  100KOhm  [VX_R0402_SMALL]  139.17 70.47 0 bottom
R7417  100KOhm  [VX_R0402_SMALL]  139.17 67.06 0 bottom
R7418  100KOhm  [VX_R0402_SMALL]  136.89 71.3 180 bottom
R7419  10KOhm  [VX_R0402_SMALL]  144.84 69.2 90 bottom
R7420  100KOhm  [VX_R0402_SMALL]  139.17 71.3 0 bottom
R7421  100KOhm  [VX_R0402_SMALL]  139.17 67.95 180 bottom
R7422  100KOhm  [VX_R0402_SMALL]  136.89 67.83 180 bottom
R7423  100KOhm  [VX_R0402_SMALL]  144.51 69.2 90 top
R7424  100KOhm  [VX_R0402_SMALL]  136.89 66.96 0 bottom
R7425  10KOhm  [VX_R0402_SMALL]  138.21 89.31 0 bottom
R7426  100KOhm  [VX_R0402_SMALL]  132.75 71.24 90 bottom
R7427  100KOhm  [VX_R0402_SMALL]  133.08 69.32 180 bottom
R7428  100KOhm  [VX_R0402_SMALL]  136.89 63.25 0 bottom
R7429  100KOhm  [VX_R0402_SMALL]  147.43 71.36 90 bottom
R7430  100KOhm  [VX_R0402_SMALL]  136.89 61.48 180 bottom
R7431  100KOhm  [VX_R0402_SMALL]  136.89 64.42 0 bottom
R7432  100KOhm  [VX_R0402_SMALL]  136.89 65.26 180 bottom
R7435  100KOhm  [VX_R0402_SMALL]  152.83 66.9 0 bottom
R7436  10KOhm  [VX_R0402_SMALL]  148.29 62.82 0 bottom
R7437  10KOhm  [VX_R0402_SMALL]  146.41 66.91 180 bottom
R7438  10KOhm  [VX_R0402_SMALL]  142.17 71.36 270 bottom
R7439  10KOhm  [VX_R0402_SMALL]  146.54 71.36 270 bottom
R7440  10KOhm  [VX_R0402_SMALL]  139.83 65.87 180 bottom
R7442  100KOhm  [VX_R0402_SMALL]  147.43 56.22 90 bottom
R7443  10KOhm  [VX_R0402_SMALL]  143.29 71.36 270 bottom
R7444  10KOhm  [VX_R0402_SMALL]  145.78 69.2 90 top
R7445  10KOhm  [VX_R0402_SMALL]  147.55 69.25 90 bottom
R7448  56KOhm  [VX_R0402_SMALL]  150.48 62.01 180 bottom
R7449  100KOhm  [VX_R0402_SMALL]  145.9 61.96 0 bottom
R7450  100KOhm  [VX_R0402_SMALL]  148.57 64.37 0 top
R7451  100KOhm  [VX_R0402_SMALL]  147.68 69.48 180 top
R7453  100KOhm  [VX_R0402_SMALL]  141.63 73.16 270 top
R7454  100KOhm  [VX_R0402_SMALL]  142.53 67.56 0 top
R7455  100KOhm  [VX_R0402_SMALL]  148.93 66.53 90 bottom
R7456  100KOhm  [VX_R0402_SMALL]  149.59 71.99 0 bottom
R7457  10KOhm  [VX_R0402_SMALL]  144.13 71.36 270 bottom
R7458  10KOhm  [VX_R0402_SMALL]  139.12 59.16 270 bottom
R7459  10KOhm  [VX_R0402_SMALL]  149.36 57.26 90 bottom
R7460  10KOhm  [VX_R0402_SMALL]  148.47 57.26 90 bottom
R7461  100KOhm  [VX_R0402_SMALL]  138.61 53.7 0 bottom
R7462  0Ohm  [VX_R0402_0OHM_SMALL]  131.4 71.46 90 bottom
R7463  0Ohm  [VX_R0402_0OHM_SMALL]  130.57 71.46 90 bottom
R7466  10KOhm  [VX_R0402_SMALL]  137.34 53.32 90 bottom
R7467  100KOhm  [VX_R0402_SMALL]  138.23 59.19 90 bottom
R7468  100KOhm  [VX_R0402_SMALL]  150.22 66.53 270 bottom
R7469  100KOhm  [VX_R0402_SMALL]  123.93 49.77 90 top
R7470  10KOhm  [VX_R0402_SMALL]  135.52 90.25 0 bottom
R7475  10KOhm  [VX_R0402_SMALL]  152 71.99 0 bottom
R7477  10KOhm  [VX_R0402_SMALL]  151.52 66.52 90 bottom
R7478  0Ohm  [VX_R0402_0OHM_SMALL]  145.78 71.36 90 top
R7482  100KOhm  [VX_R0402_SMALL]  151.11 57.08 0 bottom
R7483  33Ohm  [VX_R0402_SMALL]  131.69 69.83 270 bottom
R7484  100KOhm  [VX_R0402_SMALL]  148.82 47.1 270 bottom
R7485  100KOhm  [VX_R0402_SMALL]  149.21 48.37 180 bottom
R7486  100KOhm  [VX_R0402_SMALL]  149.41 53.83 90 bottom
R7487  10KOhm  [VX_R0402_SMALL]  151.36 52.81 90 bottom
R7488  1.8KOHM  [VX_R0402_SMALL]  148.57 53.83 270 bottom
R7489  100KOhm  [VX_R0402_SMALL]  140.44 50.91 0 bottom
R7490  100KOhm  [VX_R0402_SMALL]  144 51.92 0 bottom
R7491  100KOhm  [VX_R0402_SMALL]  144.76 49.89 270 bottom
R7493  100KOhm  [VX_R0402_SMALL]  144.63 60.94 0 top
R7494  100KOhm  [VX_R0402_SMALL]  144.13 67.56 180 top
R7495  100KOhm  [VX_R0402_SMALL]  208.9 135.31 270 top
R7496  0Ohm  [VX_R0402_0OHM_SMALL]  143.39 61.95 270 bottom
R7497  0Ohm  [VX_R0402_0OHM_SMALL]  144.23 61.96 270 bottom
R7498  0Ohm  [VX_R0402_0OHM_SMALL]  136.26 77.78 270 bottom
R7499  0Ohm  [VX_R0402_0OHM_SMALL]  137.09 77.78 270 bottom
R7500  60.4Ohm  [VX_R0402_SMALL]  171.11 115.24 0 top
R7501  40.2Ohm  [VX_R0402_SMALL]  170.01 104.16 270 top
R7502  2Ohm  [VX_R0402_SMALL]  161.17 44.33 180 bottom
R7503  2Ohm  [VX_R0402_SMALL]  175.75 119.26 90 top
R7504  2Ohm  [VX_R0402_SMALL]  174.89 119.26 90 top
R7505  5mohm  [VX_R2512_H35_YAGEO]  151.49 65.25 90 top
R7506  40.2Ohm  [VX_R0402_SMALL]  171.15 112.91 90 top
R7511  2Ohm  [VX_R0402_SMALL]  161.17 45.18 180 bottom
R7512  2Ohm  [VX_R0402_SMALL]  210.05 100.19 270 top
R7513  2Ohm  [VX_R0402_SMALL]  210.5 101.84 270 top
R7609  931OHM  [VX_R0402_SMALL]  156.6 134.96 270 bottom
R7610  549Ohm  [VX_R0402_SMALL]  157.71 134.96 90 bottom
R7611  1.33KOhm  [VX_R0402_SMALL]  155.61 134.96 270 bottom
R7612  121OHM  [VX_R0402_SMALL]  159.35 135.84 0 top
R7613  121OHM  [VX_R0402_SMALL]  153.9 133.64 180 top
R7709  931OHM  [VX_R0402_SMALL]  201.78 126.85 270 bottom
R7710  549Ohm  [VX_R0402_SMALL]  200.89 126.85 90 bottom
R7711  1.33KOhm  [VX_R0402_SMALL]  200.01 126.85 270 bottom
R7712  121OHM  [VX_R0402_SMALL]  203.82 122.66 270 top
R7713  121OHM  [VX_R0402_SMALL]  188.55 133.58 180 top
R7809  931OHM  [VX_R0402_SMALL]  202.67 90.86 180 bottom
R7810  549Ohm  [VX_R0402_SMALL]  202.67 91.96 0 bottom
R7811  1.33KOhm  [VX_R0402_SMALL]  202.67 89.77 180 bottom
R7812  121OHM  [VX_R0402_SMALL]  203.63 87.42 270 top
R7813  121OHM  [VX_R0402_SMALL]  200.41 93.2 180 top
R7909  931OHM  [VX_R0402_SMALL]  171.35 50.17 90 bottom
R7910  549Ohm  [VX_R0402_SMALL]  172.4 50.17 270 bottom
R7911  1.33KOhm  [VX_R0402_SMALL]  170.11 52.76 90 bottom
R7912  121OHM  [VX_R0402_SMALL]  168.02 52.08 180 top
R7913  121OHM  [VX_R0402_SMALL]  173.88 54.44 0 top
R8000  100Ohm  [VX_R0402_SMALL]  53.04 183.67 180 top
R8006  0Ohm  [VX_R0402_0OHM_SMALL]  54.72 175.8 90 bottom
R8007  0Ohm  [VX_R0402_0OHM_SMALL]  53.83 175.8 90 bottom
R8008  0Ohm  [VX_R0402_0OHM_SMALL]  57.51 177.75 90 bottom
R8012  49.9Ohm  [VX_R0402_SMALL]  57.85 188.93 90 bottom
R8014  10Ohm  [VX_R0402_SMALL]  56.01 188.54 90 bottom
R8015  2.87KOhm  [VX_R0402_SMALL]  62.49 184.74 180 bottom
R8019  100Ohm  [VX_R0402_SMALL]  67.67 183.29 270 bottom
R8020  0Ohm  [VX_R0402_0OHM_SMALL]  65.89 183.29 90 bottom
R8021  12.1KOhm  [VX_R0402_SMALL]  59.54 191.16 270 bottom
R8023  2KOhm  [VX_R0402_SMALL]  61.49 186.03 270 bottom
R8024  2.61KOhm  [VX_R0402_SMALL]  52.43 187.86 180 top
R8025  11KOhm  [VX_R0402_SMALL]  48.49 187.61 270 bottom
R8026  10KOhm  [VX_R0402_H24_SMALL]  89.13 153.27 270 top
R8027  0Ohm  [VX_R0402_0OHM_SMALL]  63.1 183.9 180 bottom
R8028  110KOHM  [VX_R0402_SMALL]  53.32 191.24 90 bottom
R8029  93.1KOHM  [VX_R0402_SMALL]  60.43 191.16 270 bottom
R8030  3.4KOhm  [VX_R0402_SMALL]  61.72 188.28 180 bottom
R8031  15.8KOhm  [VX_R0402_SMALL]  61.73 189.16 0 bottom
R8032  0Ohm  [VX_R0402_0OHM_SMALL]  51.48 186.77 270 bottom
R8033  100Ohm  [VX_R0402_SMALL]  50.91 182.94 180 top
R8034  0Ohm  [VX_R0402_0OHM_SMALL]  52.97 175.16 90 bottom
R8035  470Ohm  [VX_R0402_SMALL]  50.65 186.54 90 bottom
R8036  1KOhm  [VX_R0402_SMALL]  49.69 186.54 90 bottom
R8037  487Ohm  [VX_R0402_SMALL]  62.69 185.6 180 bottom
R8038  150KOhm  [VX_R0402_SMALL]  51.45 181.49 270 bottom
R8039  100KOHM  [VX_R0402_H24_SMALL_T02XT01]  60.26 179.94 180 top
R8040  0Ohm  [VX_R0402_0OHM_SMALL]  69.3 179.73 180 bottom
R8041  56.2KOHM  [VX_R0402_SMALL]  52.43 191.24 90 bottom
R8043  1KOhm  [VX_R0402_SMALL]  71.99 180.62 90 bottom
R8044  11KOhm  [VX_R0402_SMALL]  67.93 181.51 270 bottom
R8045  274Ohm  [VX_R0402_SMALL]  71.1 180.62 90 bottom
R8046  16.9KOhm  [VX_R0402_SMALL]  50.65 191.24 90 bottom
R8047  2KOhm  [VX_R0402_SMALL]  50.65 184.99 90 top
R8049  487Ohm  [VX_R0402_SMALL]  57.33 182.53 0 top
R8050  2.2Ohm  [VX_R0603_H28_SMALL]  66.66 149.33 0 bottom
R8051  2.2Ohm  [VX_R0603_H28_SMALL]  81.01 182.1 0 bottom
R8052  2.2Ohm  [VX_R0603_H28_SMALL]  66.91 167.88 0 bottom
R8053  2.2Ohm  [VX_R0805_H24_SMALL]  75.04 152.76 270 bottom
R8054  2.2Ohm  [VX_R0805_H24_SMALL]  83.93 175.52 180 bottom
R8055  2.2Ohm  [VX_R0805_H24_SMALL]  75.29 168.13 270 bottom
R8056  3.65KOhm  [VX_R0402_SMALL]  58.4 177.75 270 bottom
R8057  1Ohm  [VX_R0402_SMALL]  56.11 175.65 0 bottom
R8058  3.65KOhm  [VX_R0402_SMALL]  50.37 175.16 270 bottom
R8059  1Ohm  [VX_R0402_SMALL]  48.37 175.29 0 bottom
R8060  3.65KOhm  [VX_R0402_SMALL]  51.21 175.16 270 bottom
R8061  1Ohm  [VX_R0402_SMALL]  48.37 176.18 0 bottom
R8062  3.65KOhm  [VX_R0402_SMALL]  63.99 178.46 0 bottom
R8063  3.65KOhm  [VX_R0402_SMALL]  69.78 182.84 0 bottom
R8064  1Ohm  [VX_R0402_SMALL]  65.21 179.73 270 bottom
R8065  2.2Ohm  [VX_R0603_H28_SMALL]  63.1 174.23 270 top
R8066  1Ohm  [VX_R0402_SMALL]  71.48 179.35 180 bottom
R8067  3.65KOhm  [VX_R0402_SMALL]  51.16 190.61 0 top
R8070  2.2Ohm  [VX_R0805_H24_SMALL]  92.67 158.93 0 top
R8071  2.2Ohm  [VX_R0603_H28_SMALL]  57.13 170.09 90 top
R8072  2.2Ohm  [VX_R0805_H24_SMALL]  62.21 164.95 0 top
R8073  2.2Ohm  [VX_R0805_H24_SMALL]  49.13 170.03 270 top
R8075  100Ohm  [VX_R0402_SMALL]  48.49 181.16 180 top
R8079  1KOhm  [VX_R0402_SMALL]  49.76 184.99 90 top
R8080  2KOhm  [VX_R0402_SMALL]  58.2 183.54 180 top
R8081  15.8KOhm  [VX_R0402_SMALL]  62.85 179.73 270 bottom
R8082  10KOhm  [VX_R0402_H24_SMALL]  75.42 158.35 270 bottom
R8083  11KOhm  [VX_R0402_SMALL]  50.53 177.45 90 bottom
R8084  100KOHM  [VX_R0402_H24_SMALL_T02XT01]  75.93 181.97 270 bottom
R8085  121KOHM  [VX_R0402_SMALL]  48.88 191.24 90 bottom
R8087  165KOHM  [VX_R0402_SMALL]  49.76 191.24 90 bottom
R8088  10KOhm  [VX_R0402_H24_SMALL]  47.1 160 270 top
R8089  100Ohm  [VX_R0402_SMALL]  63 182.94 180 top
R8091  0Ohm  [VX_R0402_0OHM_SMALL]  71 183.29 270 bottom
R8092  102KOhm  [VX_R0402_SMALL]  61.96 179.73 270 bottom
R8093  3.3KOhm  [VX_R0402_SMALL]  49.76 182.35 270 bottom
R8094  2.61KOhm  [VX_R0402_SMALL]  68.56 183.29 90 bottom
R8096  2.7KOhm  [VX_R0402_SMALL]  61.45 177.07 90 bottom
R8098  510Ohm  [VX_R0402_SMALL]  55.73 177.75 270 bottom
R8099  3.65KOhm  [VX_R0402_SMALL]  48.49 184.56 180 top
R8100  1Ohm  [VX_R0603_H28_SMALL]  265.82 69.58 90 bottom
R8101  1Ohm  [VX_R0603_H28_SMALL]  271.23 20.56 180 bottom
R8102  60.4KOhm  [VX_R0402_SMALL]  256.77 63.23 180 top
R8103  69.8KOhm  [VX_R0402_SMALL]  259.34 55 270 top
R8104  16KOHM  [VX_R0402_SMALL]  257.16 60.69 270 top
R8105  6.98KOhm  [VX_R0402_SMALL]  257.89 55.51 0 top
R8106  10KOhm  [VX_R0402_SMALL]  256.27 60.69 270 top
R8107  10KOhm  [VX_R0402_SMALL]  257.78 57.6 0 top
R8108  560KOhm  [VX_R0402_SMALL]  258.04 65.84 270 top
R8109  560KOhm  [VX_R0402_SMALL]  264.89 65.64 0 top
R8110  1KOhm  [VX_R0402_SMALL]  263.25 66.53 0 top
R8111  0Ohm  [VX_R0402_0OHM_SMALL]  257.16 65.84 90 top
R8200  4.7Ohm  [VX_R0603_H28_SMALL]  220.33 13.32 0 top
R8201  20KOhm  [VX_R0402_SMALL]  190.48 16.87 0 top
R8202  2.2Ohm  [VX_R0805_H24_SMALL]  220.58 15.86 270 top
R8203  100KOhm  [VX_R0402_SMALL]  221.21 11.92 180 top
R8205  56KOhm  [VX_R0402_SMALL]  221.21 10.78 0 top
R8206  82.5KOhm  [VX_R0402_SMALL]  222.94 10.78 180 top
R8207  499Ohm  [VX_R0402_SMALL]  217.28 10.9 0 top
R8208  0Ohm  [VX_R0402_0OHM_SMALL]  213.98 10.9 180 top
R8300  499KOhm  [VX_R0402_SMALL]  32.01 46.34 180 top
R8301  2.2Ohm  [VX_R0805_H24_SMALL]  27.54 69.96 270 top
R8302  243KOhm  [VX_R0402_SMALL]  31.16 50.02 90 top
R8303  0Ohm  [VX_R0402_0OHM_SMALL]  32.01 47.35 0 top
R8304  0Ohm  [VX_R0402_0OHM_SMALL]  30.84 44.3 180 top
R8305  8.2KOhm  [VX_R0402_SMALL]  27.79 44.3 180 top
R8306  10KOhm  [VX_R0402_SMALL]  25.56 45.96 90 top
R8307  680KOhm  [VX_R0402_SMALL]  33.76 44.3 180 top
R8308  12.7KOhm  [VX_R0402_SMALL]  26.44 45.96 270 top
R8401  88.7KOHM  [VX_R0402_SMALL]  218.95 25.71 270 top
R8402  30KOhm  [VX_R0402_SMALL]  219.94 30.08 0 top
R8403  100KOhm  [VX_R0402_SMALL]  219.87 27.36 270 top
R8601  51KOhm  [VX_R0402_SMALL]  121.82 58.86 270 bottom
R8602  47KOhm  [VX_R0402_SMALL]  122.26 55.73 180 bottom
R8603  2.2Ohm  [VX_R0805_H24_SMALL]  124.71 61.6 90 bottom
R8604  102KOhm  [VX_R0402_SMALL]  122.66 58.02 90 bottom
R8605  499Ohm  [VX_R0402_SMALL]  123.07 59.24 0 bottom
R8606  100KOhm  [VX_R0402_SMALL]  123.02 60.97 90 bottom
R8607  4.7Ohm  [VX_R0603_H28_SMALL]  117.71 62.97 0 top
R8700  13KOhm  [VX_R0402_SMALL]  124.06 158.73 0 bottom
R8701  4.7KOhm  [VX_R0402_SMALL]  133.97 158.66 180 top
R8702  4.7KOhm  [VX_R0402_SMALL]  133.97 157.77 180 top
R8703  10KOhm  [VX_R0402_SMALL]  132.57 159.71 180 top
R8704  10KOhm  [VX_R0402_SMALL]  132.57 160.73 180 top
R8705  6.19KOhm  [VX_R0402_SMALL_T01]  128.25 160 270 bottom
R8706  20.5KOhm  [VX_R0402_SMALL]  131.04 164.7 90 top
R8707  4.32KOhm  [VX_R0402_SMALL]  129.27 160.64 90 bottom
R8708  16.5KOhm  [VX_R0402_SMALL]  130.16 162.34 270 bottom
R8709  309Ohm  [VX_R0402_SMALL_T01]  130.16 164.19 270 bottom
R8710  1KOhm  [VX_R0402_SMALL]  129.27 164.7 270 top
R8711  10KOhm  [VX_R0402_SMALL]  125.71 164.7 270 top
R8712  10KOhm  [VX_R0402_SMALL]  124.82 164.7 270 top
R8713  10KOhm  [VX_R0402_SMALL]  123.93 164.7 90 top
R8714  10KOhm  [VX_R0402_SMALL]  123.04 164.7 90 top
R8715  10KOhm  [VX_R0402_SMALL]  122.15 164.7 90 top
