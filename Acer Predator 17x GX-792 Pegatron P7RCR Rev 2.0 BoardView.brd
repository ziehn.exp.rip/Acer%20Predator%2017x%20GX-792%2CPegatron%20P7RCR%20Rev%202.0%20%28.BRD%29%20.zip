# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQ10: length 73.4
  TOP w0.165: v2(50.4,57.87) 51.17,57.87 51.62,57.42 CON1600.37
  IN1 w0.114: v3(75.29,101.58) 74.68,101.58 72.85,99.75 71.76,99.75 49.02,77.02 49.02,61.84 49.34,61.52 49.67,61.52 49.87,61.32 49.87,59.08 50.06,58.89 51.14,58.89 51.29,58.75 51.29,58.02 51.37,57.94 51.97,57.94 52.05,58.02 52.05,58.45 52.18,58.58 52.56,58.58 52.74,58.4 52.74,58.07 52.86,57.94 53.28,57.94 53.61,57.62 53.61,56.93 53.47,56.79 51.23,56.79 50.88,57.14 50.88,57.39 v2(50.4,57.87)
  BOTTOM w0.076: U0300.BL2 77.4,104.04 76.77,103.4 76.77,103.11 76.03,102.37 75.55,102.37 75.29,102.12 v3(75.29,101.58)
  BOTTOM w0.165: CON1601.38 49.88,57.42 49.67,57.62 49.67,57.87 49.81,58 50.05,58 50.18,57.87 v2(50.4,57.87)
M_CHA_DQ11: length 74.6
  TOP w0.165: CON1600.41 52.62,57.42 51.56,58.48 v2(50.4,58.48)
  IN1 w0.114: v2(50.4,58.48) 49.97,58.05 49.97,57.41 50.24,57.14 50.24,56.28 50.11,56.14 49.67,56.14 49.37,56.44 49.37,56.88 49.27,56.98 49.02,56.98 48.92,56.88 48.92,56.24 48.8,56.13 48.3,56.13 48.12,56.31 48.12,57.29 49.53,58.7 49.53,60.97 49.33,61.18 48.95,61.18 48.68,61.44 48.68,77.16 71.55,100.03 72.79,100.03 74.9,102.14 75.57,102.14 v3(75.72,101.99)
  BOTTOM w0.076: v3(75.72,101.99) 75.91,102.18 76.09,102.18 77,103.08 77,103.18 U0300.BM1
  BOTTOM w0.165: v2(50.4,58.48) 50.95,58.48 51.18,58.71 51.38,58.71 51.5,58.6 51.5,58.33 50.88,57.71 CON1601.42
M_CHA_DQ12: length 76.4
  TOP w0.165: CON1600.29 49.62,57.61 48.93,58.3 48.53,58.3 47.43,59.4 47.43,59.9 47.28,60.05 v2(46.74,60.05)
  IN1 w0.114: v3(78.02,105.01) 78.02,104.49 77.88,104.35 75.9,104.35 73.64,102.09 73.01,102.09 72.24,101.33 70.55,101.33 47.05,77.83 47.05,69.35 46.89,69.19 46.41,69.19 46.3,69.07 46.3,68.84 46.41,68.73 46.9,68.73 47.05,68.58 47.05,65.62 46.94,65.5 46.48,65.5 46.37,65.39 46.37,65.16 46.48,65.05 46.94,65.05 47.05,64.93 47.05,64.7 46.94,64.59 46.48,64.59 46.37,64.47 46.37,64.25 46.48,64.13 46.94,64.13 47.05,64.02 47.05,60.86 46.97,60.77 46,60.77 45.88,60.65 45.88,60.35 45.98,60.26 46.54,60.26 v2(46.74,60.05)
  BOTTOM w0.076: U0300.BK4 78.09,105.01 v3(78.02,105.01)
  BOTTOM w0.165: v2(46.74,60.05) 46.74,60.59 46.84,60.69 47.25,60.69 47.38,60.56 CON1601.28
M_CHA_DQ13: length 74.6
  TOP w0.165: v2(46.75,59.4) 46.87,59.4 48.62,57.65 CON1600.25
  IN1 w0.114: v3(78.82,106.32) 78.82,104.93 77.91,104.02 75.86,104.02 72.84,101 70.7,101 47.4,77.69 47.4,59.92 47.4,59.42 47.73,59.08 47.73,57.77 47.53,57.56 47.12,57.56 46.93,57.76 46.93,59.23 v2(46.75,59.4)
  BOTTOM w0.076: v3(78.82,106.32) 78.75,106.32 U0300.BK5
  BOTTOM w0.165: CON1601.24 46.38,57.48 46.66,57.76 46.66,58.59 46.18,59.07 46.18,59.29 46.29,59.4 v2(46.75,59.4)
M_CHA_DQ14: length 76
  TOP w0.165: v2(49.51,61.93) 50.42,61.93 51.97,63.48 52.38,63.48 52.87,63.98 CON1600.42
  IN1 w0.114: v2(49.51,61.93) 49.87,62.29 49.87,66.07 49.71,66.23 49.71,70.84 49.78,70.91 50.18,70.91 50.27,70.82 50.27,70.25 50.41,70.11 50.83,70.11 50.96,70.24 50.96,71.1 51.43,71.57 51.43,74.28 51.31,74.4 49.89,74.4 49.78,74.51 49.78,74.74 49.89,74.85 51.31,74.85 51.43,74.97 51.43,75.2 51.31,75.31 49.89,75.31 49.78,75.43 49.78,75.65 49.89,75.77 51.31,75.77 51.43,75.88 51.43,76.11 51.31,76.23 49.89,76.23 49.78,76.34 49.78,76.57 49.89,76.68 51.31,76.68 51.43,76.8 51.43,78.45 70.93,97.95 71.7,97.95 73.55,99.8 74.2,99.8 74.66,100.27 v3(74.66,100.66)
  BOTTOM w0.076: U0300.BK1 77.98,102.97 77.79,102.79 77.21,102.79 76.27,101.85 76.27,101.76 74.95,100.44 74.88,100.44 v3(74.66,100.66)
  BOTTOM w0.165: CON1601.41 50.55,64.72 50.55,61.59 50.37,61.42 49.66,61.42 49.51,61.58 v2(49.51,61.93)
M_CHA_DQ15: length 75
  TOP w0.165: v2(49.46,62.55) 50.48,62.55 51.87,63.94 CON1600.38
  IN1 w0.114: v2(49.46,62.55) 49.36,62.65 49.36,63.44 49.53,63.6 49.53,63.9 49.36,64.06 49.36,64.35 49.53,64.52 49.53,64.81 49.36,64.97 49.36,65.27 49.53,65.43 49.53,65.72 49.36,65.89 49.36,71.43 49.56,71.63 49.95,71.63 50.25,71.33 50.66,71.33 51.08,71.75 51.08,71.98 50.98,72.08 49.44,72.08 49.36,72.16 49.36,72.42 49.48,72.53 50.99,72.53 51.08,72.63 51.08,72.86 50.95,72.99 49.48,72.99 49.36,73.11 49.36,73.32 49.48,73.44 50.97,73.44 51.08,73.55 51.08,73.78 50.97,73.89 49.48,73.89 49.36,74.01 49.36,76.87 50.06,77.57 50.23,77.57 50.76,77.04 50.92,77.04 51.08,77.2 51.08,77.36 50.55,77.9 50.55,78.05 70.98,98.49 71.14,98.49 71.36,98.27 71.55,98.27 71.71,98.43 71.71,98.6 71.47,98.84 71.47,98.98 71.71,99.22 72.65,99.22 74.68,101.25 74.86,101.25 v3(75.01,101.09)
  BOTTOM w0.076: U0300.BK2 78.18,104.04 77.52,103.37 77.52,103.15 77.33,102.97 77.13,102.97 76.09,101.92 76.09,101.83 75.35,101.09 v3(75.01,101.09)
  BOTTOM w0.165: v2(49.46,62.55) 50.13,62.55 50.28,62.7 50.28,63.22 50.1,63.41 49.71,63.41 49.62,63.49 CON1601.37
M_CHA_DQ16: length 67.6
  TOP w0.165: v2(51.76,59.6) 52.15,59.21 52.15,59.02 53.62,57.55 CON1600.45
  IN1 w0.076: v3(79.66,105) 77.93,103.27 77.93,102.4 76.43,100.9 75.62,100.9
  IN1 w0.114: 75.62,100.9 74.26,99.53 73.57,99.53 52.18,78.14 52.18,71.26 51.71,70.79 51.71,69.6 51.47,69.36 50.77,69.36 50.62,69.22 50.62,60.38 51.4,59.6 v2(51.76,59.6)
  BOTTOM w0.076: v3(79.66,105) 79.8,105 U0300.BG4
  BOTTOM w0.165: v2(51.76,59.6) 52.65,58.71 52.65,58.34 52.3,58 52.03,58 51.88,57.84 CON1601.46
M_CHA_DQ17: length 69.2
  TOP w0.165: CON1600.49 54.62,57.86 54.17,58.32 53.66,58.32 51.76,60.22 v2(51.76,60.23)
  IN1 w0.076: 75.77,100.64 76.41,100.64 78.1,102.33 78.1,102.92 80.03,104.84 80.03,105.29 v3(79.7,105.61)
  IN1 w0.114: 75.77,100.64 74.09,98.96 73.48,98.96 52.52,78 52.52,71.12 52.05,70.65 52.05,69.37 50.97,68.29 50.97,61.03 v2(51.76,60.23)
  BOTTOM w0.076: v3(79.7,105.61) 79.76,105.61 U0300.BG5
  BOTTOM w0.165: v2(51.76,60.23) 51.76,60.22 52.99,58.99 53.35,58.99 53.53,58.81 53.53,58.39 52.88,57.73 CON1601.50
M_CHA_DQ18: length 69.4
  TOP w0.165: CON1600.50 54.87,63.98 54.17,63.28 53.87,63.28 51.98,61.39 v2(51.46,61.39)
  IN1 w0.076: v3(81.29,104.35) 80,104.35 78.43,102.78 78.43,102.2 76.39,100.16 76.1,100.16
  IN1 w0.114: v2(51.46,61.39) 51.74,61.39 51.85,61.5 51.85,62.36 51.65,62.56 51.65,62.82 51.85,63.02 51.85,63.26 51.65,63.47 51.65,63.65 51.85,63.85 51.85,64.17 51.65,64.37 51.65,64.69 51.85,64.9 51.85,68.15 52.02,68.32 52.93,68.32 53.21,68.59 53.21,77.71 73.8,98.31 74.25,98.31 76.1,100.16
  BOTTOM w0.076: U0300.BF4 81.29,104.93 v3(81.29,104.35)
  BOTTOM w0.165: v2(51.46,61.39) 51.46,61.58 52.07,62.19 52.07,62.6 51.98,62.68 51.33,62.68 51.2,62.81 51.2,62.95 51.91,63.66 52.32,63.66 52.62,63.96 CON1601.49
M_CHA_DQ19: length 68
  TOP w0.165: v2(51.44,62.19) 51.67,61.96 51.98,61.96 53.87,63.85 CON1600.46
  IN1 w0.076: v3(81.28,105.67) 81.28,104.88 81.12,104.72 80.14,104.72 78.26,102.85 78.26,102.27 76.41,100.41 75.95,100.41
  IN1 w0.114: 75.95,100.41 74.17,98.63 73.64,98.63 52.86,77.86 52.86,70.73 52.75,70.62 52.51,70.62 52.39,70.5 52.39,70.27 52.51,70.16 52.75,70.16 52.86,70.05 52.86,69.82 52.75,69.7 52.51,69.7 52.39,69.59 52.39,69.36 52.51,69.25 52.75,69.25 52.86,69.13 52.86,68.79 52.73,68.66 51.82,68.66 51.51,68.35 51.51,65.95 51.31,65.75 51.31,65.5 51.51,65.29 51.51,65.04 51.31,64.84 51.31,62.32 v2(51.44,62.19)
  BOTTOM w0.076: v3(81.28,105.67) 81.2,105.67 U0300.BF5
  BOTTOM w0.165: v2(51.44,62.19) 51.18,61.92 50.91,61.92 50.81,62.03 50.81,63.41 51.02,63.62 51.32,63.62 51.62,63.93 CON1601.45
M_CHA_DQ20: length 68.7
  TOP w0.165: v2(53.55,62.34) 54.12,62.34 54.83,63.05 55.95,63.05 56.87,63.98 CON1600.58
  IN1 w0.076: 77.1,100.02 77.1,100.15 78.96,102.01 v3(79.36,102.01)
  IN1 w0.114: v2(53.55,62.34) 53.04,62.85 53.04,63.2 54.53,64.69 54.53,65.85 54.42,65.96 54.04,65.96 53.93,66.07 53.93,66.42 54.04,66.53 54.42,66.53 54.53,66.65 54.53,66.99 54.42,67.1 54.04,67.1 53.93,67.22 53.93,67.56 54.04,67.67 54.42,67.67 54.53,67.79 54.53,72.65 54.65,72.77 54.95,72.77 55.06,72.88 55.06,73.22 54.95,73.34 54.65,73.34 54.53,73.45 54.53,73.8 54.65,73.91 54.95,73.91 55.06,74.02 55.06,74.37 54.95,74.48 54.65,74.48 54.53,74.6 54.53,74.94 54.65,75.05 54.95,75.05 55.06,75.17 55.06,75.51 54.95,75.62 54.65,75.62 54.53,75.74 54.53,76.08 54.65,76.2 54.95,76.2 55.06,76.31 55.06,76.65 54.95,76.77 54.65,76.77 54.53,76.88 54.53,77.22 77.1,99.79 77.1,100.02
  BOTTOM w0.076: U0300.BG2 80.56,103.62 80.56,102.63 79.95,102.01 v3(79.36,102.01)
  BOTTOM w0.165: v2(53.55,62.34) 53.72,62.16 54.9,62.16 55.71,62.97 55.71,63.35 55.53,63.54 55.26,63.54 55.13,63.67 CON1601.59
M_CHA_DQ21: length 69.5
  TOP w0.165: v2(53.88,61.73) 55.18,61.73 56.91,63.46 57.43,63.46 57.87,63.9 CON1600.62
  IN1 w0.076: v3(80.19,102.78) 80.19,102.11 77.72,99.64 77.55,99.64
  IN1 w0.114: v2(53.88,61.73) 54.09,61.73 54.2,61.61 54.2,60.51 53.46,59.77 53.46,59.66 53.67,59.46 53.83,59.46 54.88,60.51 54.88,71.39 55.4,71.92 55.4,77.61 77.44,99.64 77.55,99.64
  BOTTOM w0.076: v3(80.19,102.78) 80.37,102.96 80.37,103.16 U0300.BG1
  BOTTOM w0.165: v2(53.88,61.73) 54.38,61.22 55.1,61.22 56.13,62.25 CON1601.63
M_CHA_DQ22: length 67
  TOP w0.165: v2(55.41,58.84) 55.77,58.84 57.12,57.48 CON1600.59
  IN1 w0.076: v3(81.26,102.32) 81.26,102.24 80.19,101.18 79.81,101.18 78.4,99.76
  IN1 w0.114: 78.4,99.76 78.4,99.63 56.09,77.32 56.09,71.63 55.56,71.11 55.56,60.05 55.96,59.65 55.96,57.28 55.65,56.97 55.1,56.97 54.93,57.13 54.93,58.74 55.03,58.84 v2(55.41,58.84)
  BOTTOM w0.076: v3(81.26,102.32) 80.88,102.71 U0300.BF1
  BOTTOM w0.165: v2(55.41,58.84) 54.7,58.84 54.51,58.66 54.51,58.2 54.88,57.84 CON1601.58
M_CHA_DQ23: length 68.3
  TOP w0.165: v2(55.41,59.47) 55.69,59.47 57.08,58.08 57.46,58.08 58.12,57.42 CON1600.63
  IN1 w0.076: 78,99.63 79.71,101.34 80.12,101.34 80.89,102.11 80.89,102.51 v3(81.27,102.9)
  IN1 w0.114: v2(55.41,59.47) 55.1,59.47 54.03,58.4 53.88,58.4 53.7,58.59 53.7,58.84 55.22,60.36 55.22,71.25 55.75,71.77 55.75,77.47 77.68,99.4 77.77,99.4 78,99.63
  BOTTOM w0.076: v3(81.27,102.9) 81.27,103.64 U0300.BF2
  BOTTOM w0.165: CON1601.62 55.88,57.42 55.69,57.61 55.69,58.5 55.88,58.69 55.88,59.83 55.72,59.99 55.48,59.99 55.41,59.91 v2(55.41,59.47)
M_CHA_DQ24: length 65.5
  TOP w0.165: v2(56.7,59.09) 57.59,59.09 59.12,57.55 CON1600.67
  IN1 w0.114: v3(80.13,99.84) 79.71,99.42 79.71,98.86 77.98,97.13 77.98,96.7 57.87,76.59 57.87,59.09 57.54,58.76 57.03,58.76 v2(56.7,59.09)
  BOTTOM w0.076: U0300.BD2 82.66,104.03 83.01,103.68 83.01,100.52 82.18,99.69
  BOTTOM w0.089: 82.18,99.69 82.11,99.63 80.35,99.63 v3(80.13,99.84)
  BOTTOM w0.165: v2(56.7,59.09) 56.7,58.38 56.49,58.17 56.49,58.01 56.61,57.89 56.93,57.89 57.05,57.77 57.05,57.6 56.88,57.42 CON1601.66
M_CHA_DQ25: length 66.9
  TOP w0.165: CON1600.71 60.12,57.42 59.3,58.25 58.99,58.25 57.49,59.75 v2(56.7,59.75)
  IN1 w0.114: v2(56.7,59.75) 57.03,59.42 57.33,59.42 57.52,59.61 57.52,76.73 77.64,96.84 77.64,97.27 79.38,99.01 79.38,99.91 79.87,100.4 v3(80.13,100.4)
  BOTTOM w0.076: v3(80.13,100.4) 80.58,99.95 82.01,99.95 82.7,100.65 82.7,102.83 82.66,102.88 U0300.BD1
  BOTTOM w0.165: v2(56.7,59.75) 56.7,60.05 56.8,60.15 57.04,60.15 57.14,60.05 57.14,59.15 57.57,58.72 57.57,57.73 57.88,57.42 CON1601.70
M_CHA_DQ26: length 67.7
  TOP w0.165: CON1600.84 63.37,63.77 59.89,60.28 v2(59.67,60.28)
  IN1 w0.114: v3(83.84,105.01) 82.89,104.06 82.89,100.87 80.88,98.86 80.88,97.3 60.2,76.62 60.2,61.27 60.5,60.98 60.5,60.52 60.26,60.28 v2(59.67,60.28)
  BOTTOM w0.076: v3(83.84,105.01) 83.72,105.01 U0300.BC4
  BOTTOM w0.165: v2(59.67,60.28) 59.85,60.46 60.61,60.46 61.13,60.97 CON1601.83
M_CHA_DQ27: length 66.3
  TOP w0.165: v2(59.67,61.14) 59.88,61.14 62.37,63.64 CON1600.80
  IN1 w0.114: v3(83.84,105.66) 82.62,104.44 82.62,100.98 80.55,98.91 80.55,97.46 59.86,76.76 59.86,74.51 59.74,74.39 59.36,74.39 59.24,74.28 59.24,74.05 59.36,73.94 59.74,73.94 59.86,73.82 59.86,73.59 59.74,73.48 59.36,73.48 59.24,73.37 59.24,73.14 59.36,73.02 59.74,73.02 59.86,72.91 59.86,72.68 59.7,72.52 59.7,72.16 59.86,71.99 59.86,61.33 v2(59.67,61.14)
  BOTTOM w0.076: U0300.BC5 83.72,105.66 v3(83.84,105.66)
  BOTTOM w0.165: CON1601.79 60.13,62.19 60.28,62.03 60.28,61.27 60.15,61.14 v2(59.67,61.14)
M_CHA_DQ28: length 65.8
  TOP w0.165: CON1600.66 58.87,63.77 56.67,61.56 v2(56.53,61.56)
  IN1 w0.114: v2(56.53,61.56) 56.31,61.78 56.31,65.03 56.43,65.14 56.66,65.14 56.75,65.23 56.75,65.49 56.64,65.6 56.43,65.6 56.31,65.71 56.31,69.88 56.43,70 56.72,70 56.84,70.11 56.84,70.34 56.72,70.45 56.43,70.45 56.31,70.57 56.31,70.8 56.43,70.91 56.72,70.91 56.84,71.02 56.84,77.01 76.86,97.04 76.86,97.38 78.73,99.26 78.73,99.84 79.88,100.99 80.27,100.99 81.19,101.91 81.6,101.91 82.16,102.47 82.16,104.11 81.85,104.43 81.85,105.26 v3(82.24,105.66)
  BOTTOM w0.076: v3(82.24,105.66) 82.33,105.66 U0300.BD5
  BOTTOM w0.165: CON1601.67 57.13,63.32 57.32,63.12 57.32,62.15 56.73,61.56 v2(56.53,61.56)
M_CHA_DQ29: length 67.1
  TOP w0.165: v2(56.56,60.84) 57,60.84 58.13,61.97 58.55,61.97 59.87,63.29 CON1600.70
  IN1 w0.114: v3(82.26,105.01) 82.36,104.91 82.36,102.38 81.68,101.71 81.27,101.71 80.35,100.79 79.97,100.79 79.07,99.89 79.07,99.21 77.27,97.42 77.27,96.96 57.18,76.87 57.18,60.86 56.98,60.66 56.74,60.66 v2(56.56,60.84)
  BOTTOM w0.076: v3(82.26,105.01) 82.33,105.01 U0300.BD4
  BOTTOM w0.165: v2(56.56,60.84) 57.05,60.84 57.86,61.65 57.86,63.1 58.13,63.36 CON1601.71
M_CHA_DQ30: length 65.5
  TOP w0.165: v2(59.67,58.76) 60.98,58.76 62.12,57.61 CON1600.79
  IN1 w0.114: v2(59.67,58.76) 60.38,58.05 61.19,58.05 62.52,59.37 62.52,59.93 60.89,61.56 60.89,76.34 81.51,96.97 81.51,98.58 83.48,100.55 83.48,102.58 v3(83.84,102.94)
  BOTTOM w0.076: v3(83.84,102.94) 83.4,103.39 U0300.BC1
  BOTTOM w0.165: CON1601.80 60.38,58.04 60.71,58.38 60.71,58.55 60.2,59.06 59.98,59.06 v2(59.67,58.76)
M_CHA_DQ31: length 66.8
  TOP w0.165: v2(59.67,59.4) 60,59.72 61.09,59.72 63.12,57.69 CON1600.83
  IN1 w0.114: v3(83.83,103.71) 83.28,103.16 83.28,100.81 81.24,98.76 81.24,97.17 60.54,76.48 60.54,61.42 61.6,60.36 61.6,59.72 61.28,59.4 v2(59.67,59.4)
  BOTTOM w0.076: v3(83.83,103.71) 83.72,103.71 U0300.BC2
  BOTTOM w0.165: CON1601.84 61.38,57.95 61.6,58.17 61.6,58.73 60.79,59.54 59.82,59.54 v2(59.67,59.4)
M_CHA_DQ32: length 66.4
  TOP w0.165: v2(90.3,59.36) 90.39,59.27 91.07,59.27 91.22,59.11 91.22,58.97 91.1,58.85 91.1,58.26 90.99,58.15 90.83,58.15 90.79,58.1 90.79,57.76 91.12,57.42 CON1600.187
  IN1 w0.114: v3(101.44,101.09) 101.44,100.2 106.1,95.55 106.1,81.41 95.4,70.72 95.4,69.36 95.06,69.01 94.45,69.01 92.74,67.3 92.74,66.99 92.84,66.89 93.08,66.89 93.18,66.78 93.18,66.38 93.1,66.3 92.82,66.3 92.74,66.22 92.74,65.94 91.64,64.84 91.64,64.15 91.07,63.59 91.07,61.75 91.17,61.64 91.17,61.3 90.94,61.07 90.94,60.54 91.17,60.3 91.17,59.11 91.6,58.68 91.6,58.46 91.18,58.04 91.05,58.04 90.82,58.27 90.82,59.18 90.64,59.36 v2(90.3,59.36)
  BOTTOM w0.076: U0300.AB1 100.26,101.33 100.64,100.95 101.3,100.95 v3(101.44,101.09)
  BOTTOM w0.165: v2(90.3,59.36) 89.46,59.36 87.88,57.78 CON1601.182
M_CHA_DQ33: length 65.3
  TOP w0.165: v2(90.3,58.73) 90.3,58.35 90.23,58.27 89.9,58.27 89.71,58.09 89.71,57.87 89.82,57.76 90.05,57.76 90.12,57.69 CON1600.183
  IN1 w0.114: v2(90.3,58.73) 90.3,58.2 91.3,57.21 91.9,57.21 92.44,57.75 92.44,58.55 91.52,59.48 91.52,61.79 91.41,61.89 91.41,63.44 91.98,64.01 91.98,64.67 93.52,66.21 93.52,67.6 94.59,68.67 95.2,68.67 95.75,69.22 95.75,70.58 106.44,81.27 106.44,95.5 101.87,100.06 101.87,101.34 v3(101.44,101.77)
  BOTTOM w0.076: U0300.AB2 100.26,104.03 100.6,103.69 100.6,102.08 100.91,101.77 v3(101.44,101.77)
  BOTTOM w0.165: v2(90.3,58.73) 89.87,58.73 88.88,57.74 CON1601.186
M_CHA_DQ34: length 66.1
  TOP w0.165: v2(88.14,59.01) 87.81,59.34 87.54,59.34 86.62,58.43 CON1600.169
  IN1 w0.076: 100.14,100.01 99.66,100.01 99.08,100.59 99.08,100.76 98.92,100.92 98.92,103.12 100.21,104.41 100.21,105.36 100.5,105.66 v3(101.44,105.66)
  IN1 w0.114: v2(88.14,59.01) 89.07,59.94 89.07,64.37 89.29,64.59 89.29,67.01 89.55,67.26 89.87,67.26 90.55,67.95 90.55,68.43 90.92,68.8 91.45,68.8 93.44,70.78 93.44,71.54 104.13,82.23 104.13,96.03 100.14,100.01
  BOTTOM w0.076: U0300.AA4 101.15,105.49 101.27,105.49 v3(101.44,105.66)
  BOTTOM w0.165: CON1601.174 85.88,57.55 87.34,59.01 v2(88.14,59.01)
M_CHA_DQ35: length 67.6
  TOP w0.165: CON1600.173 87.62,57.72 87.49,57.86 87.12,57.86 87.01,57.97 87.01,58.37 87.13,58.49 88.29,58.49 88.63,58.83 88.63,59.21 v2(88.14,59.7)
  IN1 w0.076: 99.81,99.83 99.61,99.83 98.91,100.52 98.91,100.69 98.75,100.85 98.75,103.19 99.84,104.27 v3(99.84,105.02)
  IN1 w0.114: 99.81,99.83 99.96,99.83 103.78,96.01 103.78,82.37 94.27,72.86 94.01,72.86 93.09,71.95 93.09,70.92 92.49,70.32 92.16,70.32 91.78,69.93 91.78,69.61 91.31,69.14 90.78,69.14 90.21,68.57 90.21,68.19 89.63,67.61 89.4,67.61 88.94,67.15 88.94,64.73 88.73,64.51 88.73,60.28 v2(88.14,59.7)
  BOTTOM w0.076: v3(99.84,105.02) 100.12,105.02 100.13,105.02 100.39,105.02 100.68,105.31 100.68,105.67 U0300.AA5
  BOTTOM w0.165: CON1601.170 84.88,57.97 85.52,58.62 86.24,58.62 87.32,59.7 v2(88.14,59.7)
M_CHA_DQ36: length 69.5
  TOP w0.165: CON1600.174 87.87,63.93 87.02,63.07 87.02,62.78 87.27,62.53 87.54,62.53 88.42,63.41 88.75,63.41 89.21,62.95 89.21,62.55 88.27,61.6 v2(88.12,61.6)
  IN1 w0.076: 98.57,100.55 98.42,100.69 98.42,103.32 99.29,104.18 99.29,106.23 99.53,106.47 99.66,106.47 v3(99.83,106.29)
  IN1 w0.114: 98.57,100.55 98.57,100.38 99.6,99.35 99.87,99.35 103.1,96.12 103.1,82.66 93.99,73.55 93.72,73.55 91.45,71.28 91.45,71.04 91.21,70.79 90.85,70.79 88.25,68.2 88.25,65.53 87.66,64.94 87.66,62.06 v2(88.12,61.6)
  BOTTOM w0.076: v3(99.83,106.29) 100.14,105.99 U0300.AB5
  BOTTOM w0.165: CON1601.169 84.63,63.98 84.86,63.74 85.48,63.74 85.76,63.46 85.76,63.23 85.19,62.66 85.19,62.45 85.39,62.24 85.71,62.24 86.22,62.76 86.46,62.76 87.61,61.6 v2(88.12,61.6)
M_CHA_DQ37: length 66.2
  TOP w0.165: v2(88.09,62.21) 87.05,62.21 86.63,62.64 86.63,63.49 86.87,63.74 CON1600.170
  IN1 w0.076: 99.88,99.63 99.58,99.63 98.75,100.45 98.75,100.62 98.59,100.78 98.59,103.25 99.47,104.14 99.47,105.61 99.53,105.67 v3(99.84,105.67)
  IN1 w0.114: 99.88,99.63 103.44,96.06 103.44,82.51 94.13,73.21 93.86,73.21 92.53,71.87 92.53,71.67 92.75,71.45 92.75,71.18 92.55,70.97 92.45,70.97 92.12,71.31 91.97,71.31 91.8,71.14 91.8,70.89 91.27,70.37 90.95,70.37 90.77,70.19 90.77,70.02 90.94,69.86 90.94,69.78 90.68,69.53 90.52,69.53 90.37,69.68 90.21,69.68 90.05,69.51 90.05,69.35 90.2,69.21 90.2,69.04 90.04,68.88 89.87,68.88 89.73,69.03 89.57,69.03 89.4,68.87 89.4,68.71 89.71,68.4 89.71,68.23 89.55,68.06 89.39,68.06 89.07,68.38 88.92,68.38 88.76,68.22 88.76,68.06 88.9,67.91 88.9,67.75 88.6,67.45 88.6,65.4 88,64.8 88,64.31 88.12,64.19 88.27,64.19 88.39,64.08 88.39,63.85 88.27,63.73 88.12,63.73 88,63.62 88,63.28 88.11,63.17 88.27,63.17 88.39,63.06 88.39,62.83 88.27,62.72 88.11,62.72 88,62.61 88,62.3 v2(88.09,62.21)
  BOTTOM w0.076: v3(99.84,105.67) 100.22,105.67 100.26,105.62 U0300.AB4
  BOTTOM w0.165: v2(88.09,62.21) 87.38,62.21 85.63,63.97 CON1601.173
M_CHA_DQ38: length 64.6
  TOP w0.165: CON1600.182 89.87,63.82 89.62,63.56 89.62,63.28 89.74,63.15 v2(90.29,63.15)
  IN1 w0.114: v2(90.29,63.15) 90.29,63.77 90.95,64.44 90.95,66.34 91.07,66.45 91.45,66.45 91.57,66.58 91.57,67.1 94.17,69.7 94.56,69.7 94.72,69.85 94.72,71.01 105.41,81.7 105.41,95.66 100.79,100.28 100.79,100.96 99.81,101.94 99.81,103.57 100.52,104.28 100.52,105.19 100.62,105.29 100.92,105.29 101.04,105.17 101.04,104.03 101.12,103.95 102.13,103.95 102.42,103.66 102.42,101.78 102.29,101.66 102.01,101.66 101.82,101.85 101.82,102.56 v3(101.44,102.94)
  BOTTOM w0.076: v3(101.44,102.94) 101.44,103.59 U0300.AA2
  BOTTOM w0.165: v2(90.29,63.15) 89.82,63.15 89.13,63.85 CON1601.187
M_CHA_DQ39: length 65.8
  TOP w0.165: v2(90.3,62.54) 90.3,62.29 90.48,62.11 90.71,62.11 90.87,62.28 CON1600.186
  IN1 w0.114: v2(90.3,62.54) 90.3,62.24 90.38,62.16 90.65,62.16 90.73,62.24 90.73,63.73 91.3,64.3 91.3,65.71 91.41,65.83 91.59,65.83 91.72,65.69 92,65.69 92.39,66.08 92.39,67.44 94.31,69.36 94.92,69.36 95.06,69.5 95.06,70.87 105.75,81.56 105.75,95.61 101,100.36 101,101.19 100.16,102.03 100.16,103.42 100.41,103.67 101.69,103.67 101.78,103.58 101.78,103.4 101.71,103.33 100.63,103.33 100.51,103.2 100.51,102.16 100.7,101.97 100.82,101.97 100.92,102.07 100.92,102.61 100.97,102.67 101.14,102.67 v3(101.43,102.38)
  BOTTOM w0.076: v3(101.43,102.38) 101,102.82 U0300.AA1
  BOTTOM w0.165: v2(90.3,62.54) 90.1,62.75 89.4,62.75 88.5,63.64 88.34,63.64 88.13,63.86 CON1601.183
M_CHA_DQ40: length 64.3
  TOP w0.165: v2(91.83,62.8) 92.18,63.14 92.18,63.44 91.87,63.74 CON1600.190
  IN1 w0.114: v2(91.83,62.8) 92.73,63.7 92.73,64.36 94.35,65.98 94.35,67.36 94.9,67.92 95.51,67.92 96.9,69.31 96.9,70.67 107.19,80.96 107.19,86.34 107.3,86.46 107.4,86.46 107.52,86.57 107.52,86.8 107.4,86.92 107.3,86.92 107.19,87.03 107.19,87.26 107.3,87.37 107.4,87.37 107.52,87.49 107.52,87.72 107.4,87.83 107.3,87.83 107.19,87.94 107.19,88.17 107.3,88.29 107.5,88.29 107.62,88.4 107.62,88.63 107.5,88.74 107.3,88.74 107.19,88.86 107.19,89.09 107.3,89.2 107.5,89.2 107.62,89.32 107.62,89.54 107.5,89.66 107.3,89.66 107.19,89.77 107.19,90 107.3,90.12 107.5,90.12 107.62,90.23 107.62,90.46 107.5,90.57 107.3,90.57 107.19,90.69 107.19,90.92 107.3,91.03 107.5,91.03 107.62,91.14 107.62,91.37 107.5,91.49 107.3,91.49 107.19,91.6 107.19,91.83 107.3,91.94 107.5,91.94 107.62,92.06 107.62,92.29 107.5,92.4 107.3,92.4 107.19,92.52 107.19,92.75 107.3,92.86 107.5,92.86 107.62,92.97 107.62,93.2 107.5,93.32 107.3,93.32 107.19,93.43 107.19,93.66 107.3,93.77 107.5,93.77 107.62,93.89 107.62,94.12 107.5,94.23 106.95,94.23 106.84,94.34 106.84,94.6 106.91,94.67 107.16,94.67 107.25,94.76 107.25,94.98 102.69,99.53 102.69,104.97 102.39,105.26 101.69,105.26 v3(101.44,105.01)
  BOTTOM w0.076: U0300.V5 102.37,105.58 102.37,105.29 102.09,105.01 101.44,105.01 v3(101.44,105.01)
  BOTTOM w0.165: v2(91.83,62.8) 91.83,62.95 91.13,63.66 CON1601.195
M_CHA_DQ41: length 66.3
  TOP w0.165: v2(94.37,61.61) 94.6,61.61 96.37,63.38 CON1600.208
  IN1 w0.076: v3(103.95,103.7) 105.05,102.61 105.05,100.69 104.93,100.57
  IN1 w0.114: 104.93,100.57 104.93,99.38 110.27,94.04 110.27,80.07 108.95,78.74 108.95,78.34 105.29,74.68 105.12,74.68 103.85,73.41 103.39,73.41 103.12,73.14 103.12,72.4 102.07,71.36 102.07,70.73 99.33,67.98 99.33,67.11 98.1,65.87 98.1,65.72 95.68,63.3 95.68,60.98 95.36,60.66 95.36,60.08 95.68,59.76 95.68,59.54 95.51,59.38 94.96,59.38 94.82,59.52 94.82,60.74 94.56,61.01 94.56,61.43 v2(94.37,61.61)
  BOTTOM w0.076: v3(103.95,103.7) 103.1,103.7 102.77,104.03 U0300.V2
  BOTTOM w0.165: v2(94.37,61.61) 94.71,61.61 95,61.91 95,62.47 94.13,63.35 CON1601.207
M_CHA_DQ42: length 65.8
  TOP w0.165: v2(92.03,59.79) 92.82,59 92.82,58.36 92.12,57.67 CON1600.191
  IN1 w0.114: v3(103.69,102.64) 103.53,102.64 103.3,102.41 103.3,99.78 108.65,94.44 108.65,83.09 108.22,82.65 108.22,80.54 100.55,72.87 100.55,71.5 96.76,67.71 96.76,66.85 93.94,64.03 93.94,63.31 92.92,62.29 92.92,59.68 93.82,58.77 93.82,57.81 93.66,57.64 93.49,57.64 93.34,57.79 93.34,58.71 92.27,59.79 v2(92.03,59.79)
  BOTTOM w0.076: v3(103.69,102.64) 103.51,102.82 U0300.U1
  BOTTOM w0.165: v2(92.03,59.79) 92.03,59.1 90.88,57.94 CON1601.194
M_CHA_DQ43: length 64.7
  TOP w0.165: v2(95,58.96) 96.12,57.84 CON1600.207
  IN1 w0.076: v3(103.96,104.38) 105.21,103.12 105.21,100.62 105.12,100.52 105.12,99.83 105.24,99.71
  IN1 w0.114: 105.24,99.71 110.62,94.33 110.62,79.92 109.29,78.6 109.29,78.19 105.34,74.24 105.34,73.72 105.04,73.41 104.43,73.41 104.22,73.21 104.22,72.92 104.43,72.71 104.43,72.55 103.7,71.81 103.01,71.81 102.42,71.22 102.42,70.58 99.67,67.84 99.67,66.96 98.44,65.73 98.44,65.57 96.02,63.15 96.02,60.76 95.74,60.48 95.74,60.23 96.02,59.95 96.02,59.4 95.64,59.02 95.64,58.73 95.94,58.43 95.94,58.07 95.74,57.87 95.18,57.87 95,58.05 v2(95,58.96)
  BOTTOM w0.076: v3(103.96,104.38) 103.62,104.04 U0300.U2
  BOTTOM w0.165: CON1601.208 94.38,57.64 95.01,58.27 95.01,58.95 v2(95,58.96)
M_CHA_DQ44: length 65.4
  TOP w0.165: v2(94.37,62.22) 94.37,62.68 94.6,62.9 95.2,62.9 95.37,63.07 CON1600.204
  IN1 w0.076: 104.73,99.63 104.73,100.63 104.88,100.78 104.88,101.57 104.67,101.78 104.26,101.78 104.12,101.92 103.83,101.92 v3(103.69,102.06)
  IN1 w0.114: v2(94.37,62.22) 94.79,62.22 94.9,62.11 94.9,61.25 95,61.14 95.23,61.14 95.33,61.25 95.33,63.61 96.05,64.33 96.22,64.33 96.46,64.57 96.46,64.73 96.7,64.97 96.87,64.97 97.11,65.21 97.11,65.38 97.35,65.62 97.51,65.62 97.75,65.86 97.75,66.02 98.98,67.25 98.98,68.12 101.73,70.87 101.73,71.5 102.77,72.55 102.77,73.42 103.1,73.75 103.71,73.75 104.55,74.6 104.55,74.71 104.43,74.84 104.43,74.99 104.6,75.17 104.85,75.17 104.99,75.02 105.15,75.02 105.31,75.19 105.31,75.35 105.15,75.5 105.15,75.66 105.33,75.84 105.47,75.84 105.64,75.67 105.8,75.67 105.96,75.83 105.96,75.99 105.8,76.15 105.8,76.31 105.97,76.47 106.13,76.47 106.28,76.32 106.44,76.32 106.61,76.48 106.61,76.64 106.45,76.79 106.45,76.96 106.62,77.12 106.77,77.12 106.93,76.96 107.09,76.96 107.25,77.13 107.25,77.29 107.1,77.44 107.1,77.6 107.26,77.77 107.42,77.77 107.58,77.61 107.74,77.61 107.9,77.77 107.9,77.93 107.75,78.08 107.75,78.26 107.91,78.42 108.06,78.42 108.22,78.26 108.38,78.26 108.6,78.48 108.6,78.59 108.45,78.75 108.45,78.95 109.5,80 109.72,80 109.86,80.14 109.86,80.37 109.74,80.48 109.62,80.48 109.5,80.6 109.5,80.77 109.79,81.06 109.79,81.49 109.5,81.78 109.5,82.12 109.93,82.55 109.93,94.1 104.73,99.3 104.73,99.63
  BOTTOM w0.076: U0300.V1 102.77,102.98 v3(103.69,102.06)
  BOTTOM w0.165: CON1601.203 93.13,63.78 93.5,63.41 93.5,63.09 v2(94.37,62.22)
M_CHA_DQ45: length 65.8
  TOP w0.165: v2(91.83,62.06) 92.46,62.06 92.59,62.19 92.59,63.58 92.87,63.86 CON1600.194
  IN1 w0.114: v3(103.96,106.32) 103.01,106.32 102.72,106.03 102.72,105.72 102.9,105.55 102.9,99.61 107.96,94.55 107.96,86.43 107.53,86 107.53,80.82 99.44,72.73 99.44,72.56 99.86,72.14 99.86,71.94 99.73,71.81 99.55,71.81 99.12,72.24 98.95,72.24 98.17,71.46 98.17,70.96 98.01,70.79 97.5,70.79 97.24,70.53 97.24,69.16 96.08,68 96.08,67.63 95.92,67.47 94.94,67.47 94.78,67.31 94.78,67.13 95.34,66.56 95.34,66.4 93.17,64.23 93.17,63.66 92.23,62.72 92.23,62.46 v2(91.83,62.06)
  BOTTOM w0.076: U0300.V4 102.77,105.34 103.13,105.7 103.13,106.13 103.32,106.32 v3(103.96,106.32)
  BOTTOM w0.165: v2(91.83,62.06) 91.4,62.49 91.4,62.71 90.13,63.98 CON1601.191
M_CHA_DQ46: length 67.1
  TOP w0.165: CON1600.195 93.12,58.06 93.54,58.48 93.54,58.93 92.54,59.93 92.54,60.36 92.45,60.45 v2(92.03,60.45)
  IN1 w0.114: v3(103.97,105.67) 103.1,104.8 103.1,99.7 108.31,94.49 108.31,86.29 107.87,85.86 107.87,85.51 107.99,85.4 108.19,85.4 108.31,85.29 108.31,85.06 108.19,84.94 107.99,84.94 107.87,84.83 107.87,84.6 107.99,84.49 108.19,84.49 108.31,84.37 108.31,84.14 108.19,84.03 107.99,84.03 107.87,83.91 107.87,83.69 107.99,83.57 108.09,83.57 108.2,83.46 108.2,83.23 108.09,83.11 107.99,83.11 107.87,83 107.87,80.68 100.21,73.01 100.21,71.64 98.94,70.38 98.78,70.38 98.66,70.49 98.5,70.49 98.34,70.33 98.34,70.17 98.45,70.05 98.45,69.89 96.42,67.86 96.42,66.99 93.6,64.17 93.6,63.45 92.57,62.43 92.57,60.56 92.46,60.45 v2(92.03,60.45)
  BOTTOM w0.076: U0300.U5 103.66,105.99 v3(103.97,105.67)
  BOTTOM w0.165: CON1601.190 89.88,57.5 91.47,59.09 91.47,59.89 v2(92.03,60.45)
M_CHA_DQ47: length 64.5
  TOP w0.165: CON1600.203 95.12,57.42 95.46,57.76 95.46,57.95 94.95,58.45 v2(94.57,58.45)
  IN1 w0.076: 105.34,100.49 105.38,100.52 105.38,103.79 104.12,105.05 v3(103.98,105.05)
  IN1 w0.114: 105.34,100.49 105.34,99.89 110.96,94.28 110.96,79.78 109.63,78.46 109.63,78.05 105.68,74.1 105.68,73.58 104.88,72.77 104.88,72.5 100.85,68.47 100.85,67.78 100.61,67.54 100.55,67.54 100.01,67.01 100.01,66.82 98.78,65.59 98.78,65.43 96.36,63.01 96.36,57.96 95.93,57.53 95.04,57.53 94.57,57.99 v2(94.57,58.45)
  BOTTOM w0.076: U0300.U4 103.69,105.34 v3(103.98,105.05)
  BOTTOM w0.165: v2(94.57,58.45) 94.32,58.2 94.07,58.2 93.38,57.5 CON1601.204
M_CHA_DQ48: length 65.1
  TOP w0.165: CON1600.228 101.37,62.16 100.46,61.25 v2(100.08,61.25)
  IN1 w0.114: v3(106.45,103.71) 106.79,103.71 107.05,103.45 107.05,101.66 108.26,100.45 108.26,99.69 114.36,93.58 114.36,78.42 113.65,77.71 113.65,75.98 110.8,73.14 110.8,72.97 110.97,72.81 110.97,72.64 110.81,72.48 110.62,72.48 110.45,72.65 110.32,72.65 110.16,72.49 110.16,72.33 110.67,71.81 110.67,71.65 110.51,71.49 110.35,71.49 109.83,72 109.67,72 109.43,71.76 109.43,71.6 109.91,71.11 109.91,70.89 102.42,63.4 101.59,63.4 100.64,62.45 100.64,61.59 100.3,61.25 v2(100.08,61.25)
  BOTTOM w0.076: v3(106.45,103.71) 105.61,103.71 U0300.R2
  BOTTOM w0.165: v2(100.08,61.25) 100.77,61.93 100.77,62.77 99.63,63.91 CON1601.229
M_CHA_DQ49: length 65.2
  TOP w0.165: v2(96.91,61.09) 98.37,62.56 CON1600.216
  IN1 w0.076: 105.75,100.06 105.73,100.08 105.73,104.83 105.59,104.97 105.59,105.65 106.22,106.27 v3(106.45,106.27)
  IN1 w0.114: v2(96.91,61.09) 97.72,61.9 97.72,62.82 100.61,65.71 101.4,65.71 102.12,66.44 102.12,67.19 102.47,67.54 102.47,67.79 102.47,68.07 103.79,69.39 103.79,69.87 104.01,70.09 104.55,70.09 104.73,70.26 104.73,70.47 105.33,71.07 105.61,71.07 109.92,75.38 109.92,75.74 109.54,76.12 109.54,76.42 110.72,77.6 110.72,78 112.05,79.33 112.05,93.76 105.75,100.06
  BOTTOM w0.076: U0300.P5 106.3,106.27 v3(106.45,106.27)
  BOTTOM w0.165: v2(96.91,61.09) 97.35,61.53 97.35,61.98 96.85,62.48 96.75,62.48 96.13,63.1 CON1601.215
M_CHA_DQ50: length 64.4
  TOP w0.165: CON1600.212 97.37,63.73 97.78,63.33 97.78,62.67 v2(96.91,61.8)
  IN1 w0.076: v3(104.88,105.02) 104.88,105.01 105.57,104.33 105.57,100.45 105.55,100.43
  IN1 w0.114: 105.55,100.43 105.55,99.98 111.71,93.81 111.71,79.47 110.38,78.15 110.38,77.74 109.2,76.56 109.2,75.29 108.84,74.92 108.62,74.92 108.27,75.28 108.04,75.28 107.88,75.12 107.88,74.93 108.28,74.53 108.28,74.37 108.12,74.21 107.96,74.21 107.56,74.61 107.4,74.61 107.24,74.44 107.24,74.28 107.64,73.88 107.64,73.72 107.47,73.56 107.24,73.56 106.94,73.86 106.78,73.86 106.58,73.66 106.58,73.35 106.89,73.05 106.89,72.83 105.47,71.41 104.85,71.41 102.4,68.96 102.4,68.48 102.22,68.31 101.75,68.31 101.6,68.16 101.6,67.19 97.37,62.97 97.37,62.27 v2(96.91,61.8)
  BOTTOM w0.076: v3(104.88,105.02) 105.2,105.34 U0300.R4
  BOTTOM w0.165: CON1601.211 95.13,63.48 96.81,61.8 v2(96.91,61.8)
M_CHA_DQ51: length 64.9
  TOP w0.165: CON1600.215 98.12,59.02 96.92,60.23 v2(96.91,60.23)
  IN1 w0.076: v3(106.45,105.67) 105.9,105.12 105.9,100.2 105.92,100.18
  IN1 w0.114: v2(96.91,60.23) 97.11,60.03 97.57,60.03 97.75,60.21 97.75,61.27 98.06,61.59 98.06,62.68 100.75,65.37 101.54,65.37 102.46,66.29 102.46,67.05 102.81,67.4 102.81,67.79 110.39,75.37 110.39,76.78 111.07,77.46 111.07,77.86 112.39,79.19 112.39,93.7 105.92,100.18
  BOTTOM w0.076: v3(106.45,105.67) 106.36,105.67 U0300.P4
  BOTTOM w0.165: CON1601.216 96.38,57.77 96.44,57.83 96.44,58.61 96.97,59.14 97.04,59.14 97.35,59.44 97.35,59.8 96.92,60.23 v2(96.91,60.23)
M_CHA_DQ52: length 63.5
  TOP w0.165: CON1600.225 100.62,57.47 100.75,57.59 100.75,58.3 v2(100.11,58.94)
  IN1 w0.076: 108.78,100.32 108.78,100.48 107.44,101.83 107.44,104.03 v3(106.45,105.01)
  IN1 w0.114: 108.78,100.32 108.78,99.74 115.05,93.47 115.05,78.09 114.61,77.65 114.34,77.38 114.34,75.7 113.04,74.4 113.04,73.76 113.21,73.59 113.21,73.22 102.71,62.71 101.87,62.71 101.33,62.17 101.33,60.35 100.81,59.83 100.81,59.63 v2(100.11,58.94)
  BOTTOM w0.076: v3(106.45,105.01) 105.89,105.01 105.61,105.3 105.61,105.67 U0300.R5
  BOTTOM w0.165: v2(100.11,58.94) 99.54,58.37 99.54,57.97 99.38,57.8 CON1601.228
M_CHA_DQ53: length 64.6
  TOP w0.165: v2(100.06,59.57) 100.26,59.57 101.23,58.6 101.23,57.82 101.62,57.42 CON1600.229
  IN1 w0.114: v3(106.45,104.36) 106.82,104.36 107.24,103.95 107.24,103.93 107.25,103.92 107.25,101.75 108.46,100.54 108.46,99.77 114.71,93.53 114.71,78.23 114,77.52 114,75.84 112.08,73.92 112.08,73.79 112.39,73.48 112.39,73.3 112.24,73.15 112.07,73.15 111.78,73.44 111.59,73.44 111.35,73.2 111.35,72.96 111.77,72.54 111.77,72.27 102.56,63.06 101.73,63.06 100.98,62.31 100.98,60.5 v2(100.06,59.57)
  BOTTOM w0.076: v3(106.45,104.36) 106.35,104.36 U0300.P2
  BOTTOM w0.165: CON1601.224 98.38,58.3 99.64,59.57 v2(100.06,59.57)
M_CHA_DQ54: length 64.6
  TOP w0.165: CON1600.211 97.12,57.42 97.73,58.03 97.73,58.8 v2(96.91,59.62)
  IN1 w0.076: v3(106.45,102.37) 106.06,101.98 106.06,100.32 106.37,100.02
  IN1 w0.114: 106.37,100.02 112.74,93.65 112.74,79.05 111.41,77.72 111.41,75.9 103.16,67.64 103.16,67.25 102.81,66.9 102.81,66.15 101.68,65.03 100.89,65.03 98.4,62.54 98.4,58.44 98.25,58.29 97.85,58.29 97.69,58.45 97.69,58.84 v2(96.91,59.62)
  BOTTOM w0.076: v3(106.45,102.37) 106.45,102.36 106.3,102.52 106.16,102.52 U0300.R1
  BOTTOM w0.165: CON1601.212 95.38,57.51 96.04,58.17 96.04,59.02 96.64,59.62 v2(96.91,59.62)
M_CHA_DQ55: length 63.6
  TOP w0.165: v2(100.08,62.49) 100.49,62.49 100.64,62.64 100.64,63.46 100.37,63.72 CON1600.224
  IN1 w0.114: v2(100.08,62.49) 100.19,62.49 101.45,63.74 102.28,63.74 105.43,66.9 105.43,67.06 105.27,67.22 105.27,67.38 105.44,67.54 105.6,67.54 105.76,67.38 105.92,67.38 106.63,68.1 106.63,68.44 106.26,68.8 106.26,69.08 106.51,69.32 106.67,69.32 107.18,68.81 107.34,68.81 107.51,68.97 107.51,69.13 106.99,69.65 106.99,69.81 107.15,69.97 107.31,69.97 107.83,69.46 107.99,69.46 108.15,69.62 108.15,69.78 107.64,70.29 107.64,70.46 107.8,70.62 107.96,70.62 108.48,70.1 108.64,70.1 108.8,70.26 108.8,70.43 108.28,70.94 108.28,71.1 108.45,71.26 108.61,71.26 109.05,70.83 109.21,70.83 109.37,70.99 109.37,71.15 108.93,71.59 108.93,71.75 113.31,76.13 113.31,77.88 114.02,78.59 114.02,93.64 108.05,99.6 108.05,100.37 106.85,101.58 106.85,102.55 v3(106.45,102.95)
  BOTTOM w0.076: U0300.P1 106.03,103.39 106.45,102.97 v3(106.45,102.95)
  BOTTOM w0.165: v2(100.08,62.49) 98.63,63.95 CON1601.225
M_CHA_DQ56: length 72.1
  TOP w0.165: CON1600.232 102.37,63.49 102.18,63.29 102.18,62.61 102.37,62.41 102.37,62.06 102.05,61.73 v2(101.81,61.73)
  IN1 w0.076: 109.44,100.11 109.39,100.11 107.6,101.89 107.6,104.74 107.38,104.96 v3(107.38,104.97)
  IN1 w0.114: 109.44,100.11 111.9,100.11 112.02,99.99 112.02,99.64 112.13,99.52 112.59,99.52 112.7,99.64 112.7,99.99 112.82,100.11 114.82,100.11 117.61,97.32 117.61,95.45 115.8,93.64 115.8,77.77 115.14,77.12 115.09,77.06 115.09,75.39 114.63,74.93 114.63,74.77 115.09,74.32 115.09,74.06 114.93,73.9 114.76,73.9 114.28,74.38 114.08,74.38 113.91,74.21 113.91,73.94 114.25,73.6 114.25,73.2 109.44,68.39 109.44,68.25 109.6,68.09 109.6,67.93 109.44,67.76 109.27,67.76 109.19,67.85 109.03,67.85 108.78,67.61 108.78,67.43 109.06,67.16 109.06,66.9 107.38,65.22 107.09,65.22 106.77,65.54 106.59,65.54 106.29,65.24 106.29,65.08 106.67,64.7 106.67,64.54 106.51,64.37 106.34,64.37 105.96,64.75 105.8,64.75 105.64,64.59 105.64,64.43 105.95,64.12 105.95,63.99 105.76,63.8 105.62,63.8 105.44,63.99 105.18,63.99 102.92,61.73 v2(101.81,61.73)
  BOTTOM w0.076: U0300.M4 107.73,105.34 107.38,104.99 v3(107.38,104.97)
  BOTTOM w0.165: v2(101.81,61.73) 101.81,62.29 100.63,63.47 CON1601.233
M_CHA_DQ57: length 71.4
  TOP w0.165: v2(101.86,59.09) 101.91,59.09 102.62,58.37 CON1600.233
  IN1 w0.114: v2(101.86,59.09) 101.61,59.09 101.35,58.83 101.35,56.62 101.48,56.5 102.8,56.5 102.93,56.62 102.93,60.27 104.89,62.23 105.85,62.23 111.74,68.12 111.74,69.24 116.12,73.61 116.12,76.54 116.83,77.25 116.83,88.01 118.22,89.4 118.22,97.58 113.99,101.8 110.23,101.8 109.95,101.52 v3(109.95,101.4)
  BOTTOM w0.076: v3(109.95,101.4) 109.95,101.4 109.47,101.4 107.8,103.07 U0300.M1
  BOTTOM w0.165: CON1601.236 101.38,58.83 101.63,59.09 v2(101.86,59.09)
M_CHA_DQ58: length 72.3
  TOP w0.165: v2(105.97,59.42) 106.09,59.54 106.48,59.54 106.78,59.24 106.78,58.55 106.62,58.39 CON1600.249
  IN1 w0.114: v3(108.99,105.01) 109.92,104.07 113.69,104.07 122.1,95.67 122.1,85.82 119.95,83.68 119.95,77.69 118.1,75.84 118.1,73.06 113.71,68.67 113.71,67.31 111.7,65.3 111.7,62.4 111.41,62.11 111.05,62.11 110.93,61.99 110.93,61.52 111.05,61.4 111.41,61.4 111.51,61.3 111.51,60.08 111.18,59.75 110.18,59.75 109.74,60.18 109.09,60.18 108.76,59.84 107.96,59.84 107.73,60.08 107.3,60.08 106.97,59.75 106.3,59.75 v2(105.97,59.42)
  BOTTOM w0.076: U0300.L4 108.86,105.01 v3(108.99,105.01)
  BOTTOM w0.165: CON1601.246 103.88,57.46 105.83,59.42 v2(105.97,59.42)
M_CHA_DQ59: length 74.1
  TOP w0.165: v2(105.98,60.19) 106.75,60.19 106.88,60.32 106.88,64.8 CON1600.250
  IN1 w0.114: v2(105.98,60.19) 106.57,60.19 107.94,61.56 108.98,61.56 109.58,62.16 109.75,62.16 110.18,61.73 110.39,61.73 110.51,61.85 110.51,62.04 110.07,62.49 110.07,62.65 110.23,62.81 110.39,62.81 110.69,62.52 110.85,62.52 111.01,62.68 111.01,62.84 110.72,63.13 110.72,63.3 111.36,63.94 111.36,65.44 113.37,67.45 113.37,68.82 117.75,73.2 117.75,75.98 118.35,76.57 118.35,82.56 121.75,85.97 121.75,95.53 113.64,103.64 109.76,103.64 109.05,102.93 v3(109.05,102.84)
  BOTTOM w0.076: U0300.L2 108.54,104.03 108.89,103.68 108.89,103 v3(109.05,102.84)
  BOTTOM w0.165: v2(105.98,60.19) 106.41,60.62 106.41,61.32 104.63,63.1 CON1601.249
M_CHA_DQ60: length 72.9
  TOP w0.165: v2(101.83,61.07) 102.13,61.07 103.37,62.32 CON1600.236
  IN1 w0.076: 109.7,100.31 109.42,100.31 107.77,101.96 107.77,105.24 107.38,105.62 v3(107.38,105.63)
  IN1 w0.114: v2(101.83,61.07) 102.08,60.83 102.51,60.83 104.59,62.92 105.56,62.92 110.07,67.42 110.07,68.53 115.43,73.9 115.43,76.87 116.14,77.58 116.14,91.55 116.26,91.67 117.07,91.67 117.19,91.78 117.19,92.01 117.07,92.13 116.26,92.13 116.14,92.24 116.14,92.47 116.31,92.63 117.05,92.63 117.14,92.72 117.14,92.95 117,93.09 116.2,93.09 116.14,93.16 116.14,93.5 117.81,95.17 117.81,97.41 114.91,100.31 109.7,100.31
  BOTTOM w0.076: U0300.M5 107.61,105.8 107.54,105.8 v3(107.38,105.63)
  BOTTOM w0.165: v2(101.83,61.07) 102.36,61.6 102.36,62.72 101.63,63.46 CON1601.237
M_CHA_DQ61: length 72.6
  TOP w0.165: v2(101.86,59.7) 101.97,59.7 103.62,58.04 CON1600.237
  IN1 w0.114: v3(110.51,101.4) 114.11,101.4 118.01,97.49 118.01,94.73 117.51,94.22 117.51,93.48 117.87,93.11 117.87,91.32 117.81,91.26 116.68,91.26 116.56,91.14 116.56,90.8 116.7,90.66 117.73,90.66 117.87,90.52 117.87,90.29 117.76,90.17 116.6,90.17 116.48,90.06 116.48,89.68 116.6,89.57 117.45,89.57 117.56,89.46 117.56,89.23 117.45,89.11 116.6,89.11 116.48,89 116.48,77.44 115.77,76.73 115.77,73.75 111.08,69.06 111.08,68.89 111.4,68.57 111.4,68.41 111.24,68.25 111.09,68.25 110.78,68.56 110.58,68.56 110.41,68.39 110.41,67.94 110.65,67.7 110.65,67.52 105.71,62.57 104.74,62.57 v2(101.86,59.7)
  BOTTOM w0.076: U0300.M2 108.18,103.66 108.18,102.94 108.85,102.27 109.64,102.27 v3(110.51,101.4)
  BOTTOM w0.165: v2(101.86,59.7) 101.66,59.7 100.9,58.94 100.9,58.26 100.38,57.74 CON1601.232
M_CHA_DQ62: length 71.3
  TOP w0.165: CON1600.245 105.62,57.7 105.3,58.02 105.3,58.61 105.49,58.81 v2(105.97,58.81)
  IN1 w0.114: v3(108.99,105.66) 110.02,104.63 113.62,104.63 122.44,95.81 122.44,85.68 120.29,83.54 120.29,77.55 118.49,75.74 118.49,72.97 114.05,68.53 114.05,67.16 112.05,65.16 112.05,64.81 112.22,64.64 112.22,63.89 112.33,63.78 112.52,63.78 112.69,63.62 112.69,63.39 112.63,63.33 112.16,63.33 112.05,63.21 112.05,60.13 111.32,59.41 106.56,59.41 v2(105.97,58.81)
  BOTTOM w0.076: U0300.L5 108.86,105.66 v3(108.99,105.66)
  BOTTOM w0.165: v2(105.97,58.81) 105.78,58.81 104.88,57.9 CON1601.250
M_CHA_DQ63: length 73.7
  TOP w0.165: v2(105.98,60.96) 106.34,60.96 106.48,61.09 106.48,62.29 106.33,62.44 105.72,62.44 105.6,62.56 105.6,62.86 105.87,63.13 CON1600.246
  IN1 w0.114: v3(109.65,102.81) 113.98,102.81 121.41,95.38 121.41,86.11 118.01,82.7 118.01,76.72 117.41,76.12 117.41,73.35 113.02,68.96 113.02,67.59 110.57,65.14 110.57,64.98 110.95,64.6 110.95,64.43 110.79,64.27 110.63,64.27 110.25,64.65 110.09,64.65 109.84,64.41 109.84,64.3 110.23,63.91 110.23,63.75 110.07,63.58 109.91,63.58 109.57,63.92 109.36,63.92 109.2,63.76 109.2,63.6 109.69,63.11 109.69,62.97 109.53,62.81 109.34,62.81 108.87,63.28 108.71,63.28 108.55,63.12 108.55,62.95 109.12,62.39 109.12,62.22 108.96,62.06 108.79,62.06 108.23,62.63 108.06,62.63 106.39,60.96 v2(105.98,60.96)
  BOTTOM w0.076: U0300.L1 108.54,102.83 108.9,102.47 109.31,102.47 v3(109.65,102.81)
  BOTTOM w0.165: CON1601.245 103.63,63.11 105.78,60.96 v2(105.98,60.96)
M_CHA_DQS0: length 80.8
  TOP w0.146: CON1600.13 45.62,57.55 44.87,58.3 44.87,58.63 46.03,59.8 46.03,60.35 45.52,60.87 44.89,60.87 44.64,60.61 v2(44.33,60.61)
  IN1 w0.076: 72.17,103.79 72.48,103.79 72.98,104.29 72.98,104.65 72.96,104.67 v3(72.96,104.99)
  IN1 w0.127: 72.17,103.79 70.19,103.79 69.88,104.1 69.08,104.1 41.37,76.39 41.37,76.13 41.49,76.01 42.16,76.01 42.42,75.75 42.42,75.18 42.16,74.92 41.49,74.92 41.37,74.8 41.37,71.46 41.5,71.34 41.94,71.34 42.2,71.08 42.2,70.51 41.94,70.24 41.5,70.24 41.37,70.12 41.37,69.55 41.56,69.36 41.92,69.36 42.42,68.86 42.42,63 43.81,61.62 43.81,60.74 44.07,60.48 44.2,60.48 v2(44.33,60.61)
  BOTTOM w0.076: U0300.BP5 75.25,105.76 75.11,105.9 73.51,105.9 73.16,105.55 73.16,105.19 v3(72.96,104.99)
  BOTTOM w0.146: v2(44.33,60.61) 43.92,60.2 43.19,60.2 43.06,60.33 43.06,63.3 43.21,63.46 43.52,63.46 43.63,63.56 CON1601.13
M_CHA_DQS0#: length 80.7
  TOP w0.146: v2(44.28,59.95) 44.71,59.95 44.89,60.13 44.89,60.51 45,60.62 45.42,60.62 45.78,60.25 45.78,59.9 44.62,58.74 44.62,58.2 45.12,57.7 CON1600.11
  IN1 w0.076: 72.2,104.02 72.46,104.02 72.74,104.3 72.74,104.41 v3(72.61,104.54)
  IN1 w0.127: 72.2,104.02 70.29,104.02 69.98,104.32 68.99,104.32 41.15,76.48 41.15,76.03 41.4,75.78 42.07,75.78 42.2,75.65 42.2,75.27 42.07,75.15 41.39,75.15 41.15,74.9 41.15,71.37 41.41,71.11 41.84,71.11 41.97,70.98 41.97,70.6 41.84,70.47 41.41,70.47 41.15,70.21 41.15,69.46 41.47,69.13 41.82,69.13 42.2,68.76 42.2,62.91 43.58,61.52 43.58,60.65 v2(44.28,59.95)
  BOTTOM w0.076: U0300.BR5 74.86,105.72 73.58,105.72 73.33,105.48 73.33,104.8 73.08,104.54 v3(72.61,104.54)
  BOTTOM w0.146: CON1601.11 43.13,63.73 43.03,63.63 43.02,63.63 42.81,63.42 42.81,60.22 43.08,59.95 v2(44.28,59.95)
M_CHA_DQS1: length 78.9
  TOP w0.146: CON1600.34 50.87,63.99 49.91,63.03 49.33,63.03 48.25,61.94 48.25,59.94 48.4,59.78 48.66,59.78 48.72,59.85 48.72,60.08 48.8,60.15 v2(49.04,60.15)
  IN1 w0.127: v2(49.04,60.15) 48.75,60.15 48.67,60.08 48.67,59.8 48.62,59.75 48.39,59.75 48.05,60.09 48.05,77.28 71.19,100.41 72.87,100.41 74.96,102.5 76.22,102.5 76.71,102.98 77,102.98 77.13,102.85 77.13,102.76 76.66,102.3 76.66,102.12 76.77,102.01 v3(76.97,102.01)
  BOTTOM w0.076: U0300.BK3 78.5,104.69 78.92,104.26 78.92,103.81 78.47,103.36 78.47,102.78 77.58,101.89 77.1,101.89 v3(76.97,102.01)
  BOTTOM w0.146: CON1601.34 48.88,57.72 51.03,59.88 51.03,60.68 50.7,61.02 50.17,61.02 49.31,60.15 v2(49.04,60.15)
M_CHA_DQS1#: length 78.9
  TOP w0.146: v2(49.04,59.52) 48.32,59.52 48,59.84 48,62.05 49.23,63.28 49.81,63.28 50.37,63.84 CON1600.32
  IN1 w0.127: v2(49.04,59.52) 48.3,59.52 47.82,59.99 47.82,77.37 71.09,100.64 72.78,100.64 74.86,102.72 76.13,102.72 76.61,103.21 77.1,103.21 77.35,102.95 77.35,102.42 v3(77.36,102.42)
  BOTTOM w0.076: U0300.BL3 77.96,104.36 78.57,104.36 78.75,104.19 78.75,103.89 78.3,103.44 78.3,102.86 77.62,102.18 77.41,102.18 77.35,102.24 77.35,102.41 v3(77.36,102.42)
  BOTTOM w0.146: CON1601.32 48.38,57.57 50.79,59.99 50.79,60.58 50.6,60.77 50.27,60.77 49.43,59.93 49.43,59.63 49.32,59.52 v2(49.04,59.52)
M_CHA_DQS2: length 70.4
  TOP w0.146: CON1600.55 56.12,57.5 54.71,58.92 54.71,59.41 54.97,59.67 54.97,60.33 54.66,60.65 53.25,60.65 v2(53.12,60.78)
  IN1 w0.076: v3(79.69,103.05) 78.94,103.05 78.59,102.71 78.59,102.13 76.42,99.96 76.21,99.96
  IN1 w0.127: v2(53.12,60.78) 53.46,60.78 53.55,60.87 53.55,61.14 52.38,62.31 52.38,63.96 52.74,64.31 52.74,65.18 52.38,65.54 52.38,67.16 53.73,68.52 53.73,77.48 75.71,99.45 76.21,99.96
  BOTTOM w0.076: v3(79.69,103.05) 79.69,103.36 79.82,103.5 79.82,104.19 79.99,104.35 80.55,104.35 U0300.BF3
  BOTTOM w0.146: CON1601.55 54.13,63.58 53.95,63.41 53.21,63.41 52.88,63.07 52.88,62 52.25,61.37 52.25,60.94 52.63,60.57 52.91,60.57 v2(53.12,60.78)
M_CHA_DQS2#: length 70.4
  TOP w0.146: CON1600.53 55.62,57.65 54.46,58.82 54.46,59.51 54.72,59.77 54.72,60.23 54.55,60.4 53.69,60.4 53.64,60.34 53.64,60.04 53.5,59.9 53.34,59.9 v2(53.07,60.17)
  IN1 w0.076: v3(79.27,102.59) 79.06,102.8 78.94,102.8 78.77,102.64 78.77,102.06 76.44,99.73 76.3,99.73
  IN1 w0.127: v2(53.07,60.17) 53.26,60.17 53.78,60.69 53.78,61.23 52.61,62.4 52.61,63.86 52.97,64.22 52.97,65.28 52.61,65.63 52.61,67.07 53.96,68.42 53.96,77.38 76.26,99.68 76.3,99.73
  BOTTOM w0.076: U0300.BG3 79.99,104.54 79.92,104.54 79.65,104.27 79.65,103.57 79.33,103.25 79.33,103.13 79.27,103.07 v3(79.27,102.59)
  BOTTOM w0.146: CON1601.53 53.62,63.8 53.48,63.65 53.11,63.65 52.63,63.17 52.63,62.1 52,61.47 52,60.84 52.52,60.32 52.92,60.32 v2(53.07,60.17)
M_CHA_DQS3: length 67.8
  TOP w0.146: v2(58.39,60.29) 58.84,60.29 59.24,60.69 59.24,61.32 59.9,61.98 60.07,61.98 61.37,63.29 CON1600.76
  IN1 w0.127: v3(81.67,101.3) 81.67,100.5 80.15,98.98 80.15,97.8 58.71,76.36 58.71,69.55 59.2,69.06 59.2,64.87 58.81,64.48 58.81,63.18 59.25,62.73 59.25,60.55 58.99,60.29 v2(58.39,60.29)
  BOTTOM w0.076: v3(81.67,101.3) 82.33,101.96 82.33,104.2 82.49,104.36 83.07,104.36 83.39,104.68 U0300.BC3
  BOTTOM w0.146: CON1601.76 59.38,57.73 59.29,57.82 58.81,57.82 58.38,58.25 58.38,58.91 57.85,59.44 57.85,60.44 57.97,60.56 58.12,60.56 v2(58.39,60.29)
M_CHA_DQS3#: length 67.6
  TOP w0.146: CON1600.74 60.87,63.67 60.94,63.61 61.04,63.61 61.13,63.52 61.13,63.39 59.97,62.23 59.8,62.23 58.99,61.43 58.99,60.79 58.79,60.59 58.73,60.59 v2(58.39,60.92)
  IN1 w0.127: v2(58.39,60.92) 58.8,60.52 58.9,60.52 59.02,60.64 59.02,62.64 58.58,63.08 58.58,64.57 58.97,64.97 58.97,68.96 58.48,69.46 58.48,76.45 79.92,97.9 79.92,99.08 81.44,100.59 81.44,100.95 81.32,101.07 81.18,101.07 v3(81.08,100.97)
  BOTTOM w0.076: U0300.BD3 82.51,104.53 82.41,104.53 82.15,104.27 82.15,102.03 81.78,101.67 81.51,101.67 81.08,101.24 v3(81.08,100.97)
  BOTTOM w0.146: v2(58.39,60.92) 57.98,60.92 57.6,60.54 57.6,59.34 58.13,58.8 58.13,58.15 58.88,57.41 CON1601.74
M_CHA_DQS4: length 70.4
  TOP w0.146: CON1600.179 89.12,57.54 88.88,57.78 88.88,57.94 89.8,58.85 89.8,59.54 89.44,59.9 89.14,59.9 88.91,60.13 88.91,61.1 89.22,61.41 89.42,61.41 89.93,60.91 89.93,60.65 v2(90.36,60.22)
  IN1 w0.127: v3(99.45,100.92) 99.59,101.06 99.95,101.06 100.36,100.66 100.36,100.1 104.65,95.8 104.65,82.01 93.96,71.32 93.96,70.56 90.2,66.8 90.2,64.75 89.6,64.15 89.6,60.55 89.79,60.36 90.21,60.36 v2(90.36,60.22)
  BOTTOM w0.076: v3(99.45,100.92) 99.1,101.27 99.1,101.63 99.31,101.84 99.66,101.84 99.79,101.98 99.79,103.07 99.75,103.11 99.75,104.24 100.06,104.55 100.12,104.55 U0300.AB3
  BOTTOM w0.146: v2(90.36,60.22) 90.79,60.22 91.22,60.65 91.22,61.53 90.63,62.11 89.23,62.11 88.27,63.08 88.04,63.08 87.13,63.99 CON1601.179
M_CHA_DQS4#: length 70.4
  TOP w0.146: CON1600.177 88.62,58.03 89.55,58.95 89.55,59.44 89.34,59.65 89.03,59.65 88.66,60.03 88.66,61.2 89.12,61.66 89.52,61.66 89.98,61.21 v2(90.36,60.83)
  IN1 w0.127: v3(99.47,101.48) 99.65,101.29 100.05,101.29 100.58,100.75 100.58,100.19 104.88,95.89 104.88,81.92 94.19,71.23 94.19,70.47 90.43,66.7 90.43,64.66 89.83,64.06 89.83,60.68 89.91,60.59 90.12,60.59 v2(90.36,60.83)
  BOTTOM w0.076: v3(99.47,101.48) 99.87,101.48 99.97,101.57 99.97,103.14 99.93,103.18 99.93,104.17 100.12,104.36 100.41,104.36 100.59,104.54 100.59,104.73 100.68,104.82 100.86,104.82 U0300.AA3
  BOTTOM w0.146: CON1601.177 86.63,63.9 86.77,63.75 87.02,63.75 87.94,62.83 88.17,62.83 89.13,61.87 90.53,61.87 90.97,61.43 90.97,60.75 90.75,60.54 90.65,60.54 v2(90.36,60.83)
M_CHA_DQS5: length 68.6
  TOP w0.146: CON1600.200 94.37,63.84 94.28,63.75 94.23,63.75 94.23,63.75 94.02,63.75 93.4,63.13 93.4,62.26 93.63,62.03 93.63,61.66 93.4,61.43 93.4,60.41 93.59,60.22 93.92,60.22 v2(94.3,60.61)
  IN1 w0.127: v2(94.3,60.61) 93.9,60.21 93.74,60.21 93.57,60.38 93.57,62.02 94.7,63.14 94.7,63.72 97.42,66.44 97.42,67.3 101.2,71.09 101.2,71.72 102.25,72.77 102.25,73.5 108.97,80.22 108.97,82.34 109.4,82.77 109.4,94.3 103.86,99.84 103.86,101.02 103.95,101.11 104.13,101.11 v3(104.37,100.87)
  BOTTOM w0.076: v3(104.37,100.87) 104.11,101.14 103.84,101.14 102.28,102.7 102.28,104.24 102.57,104.53 102.62,104.53 U0300.V3
  BOTTOM w0.146: CON1601.200 92.38,57.52 93.5,58.65 93.99,58.65 95.18,59.84 95.18,60.33 94.89,60.61 v2(94.3,60.61)
M_CHA_DQS5#: length 68.5
  TOP w0.146: CON1600.198 93.87,63.95 93.16,63.24 93.16,62.16 93.38,61.93 93.38,61.76 93.16,61.53 93.16,60.31 93.49,59.98 v2(94.3,59.98)
  IN1 w0.127: v2(94.3,59.98) 93.65,59.98 93.34,60.28 93.34,62.11 94.47,63.24 94.47,63.81 97.19,66.53 97.19,67.39 100.97,71.18 100.97,71.82 102.02,72.86 102.02,73.59 108.74,80.32 108.74,82.44 109.18,82.87 109.18,94.21 103.63,99.75 103.63,101.12 103.79,101.27 103.97,101.46 v3(103.97,101.56)
  BOTTOM w0.076: U0300.U3 103.51,104.41 103.46,104.36 102.65,104.36 102.46,104.17 102.46,102.78 103.68,101.56 v3(103.97,101.56)
  BOTTOM w0.146: CON1601.198 91.88,57.53 92.11,57.76 92.27,57.76 93.4,58.9 93.89,58.9 94.93,59.94 94.93,60.22 94.82,60.33 94.66,60.33 v2(94.3,59.98)
M_CHA_DQS6: length 66.7
  TOP w0.146: CON1600.221 99.62,61.3 99.27,61.65 v2(98.82,61.65)
  IN1 w0.127: v2(98.82,61.65) 99.01,61.65 99.09,61.57 99.09,61.17 99.2,61.05 99.34,61.05 99.43,61.15 99.43,62.8 101.13,64.5 101.76,64.5 103.23,65.98 103.23,66.4 104.98,68.15 104.98,68.87 112.07,75.96 112.07,77.63 113.26,78.83 113.26,93.77 107.62,99.42 107.62,100.19 106.98,100.82 106.79,100.82 106.71,100.75 v3(106.71,100.57)
  BOTTOM w0.076: U0300.R3 105.14,104.54 105.02,104.54 104.79,104.32 104.79,102.79 105.51,102.07 105.51,101.66 106.06,101.12 106.06,100.84 106.33,100.57 v3(106.71,100.57)
  BOTTOM w0.146: v2(98.82,61.65) 98.82,61.43 98.29,60.91 98.04,60.91 97.87,61.08 97.87,61.25 98.18,61.56 98.18,62.72 97.46,63.44 97.46,63.6 97.63,63.76 CON1601.221
M_CHA_DQS6#: length 66.7
  TOP w0.146: CON1600.219 99.12,57.61 99.38,57.87 99.38,61.19 99.23,61.34 99.11,61.34 98.82,61.04 v2(98.82,60.82)
  IN1 w0.127: v3(106.43,101.05) 107.08,101.05 107.84,100.28 107.84,99.52 113.49,93.87 113.49,78.73 113.46,78.7 112.85,78.09 112.3,77.54 112.3,75.86 105.21,68.77 105.21,68.06 103.46,66.31 103.46,65.88 101.85,64.27 101.23,64.27 99.66,62.71 99.66,61.06 99.43,60.82 v2(98.82,60.82)
  BOTTOM w0.076: U0300.P3 105.7,104.36 105.09,104.36 104.97,104.24 104.97,102.87 105.69,102.14 105.69,101.74 106.21,101.22 106.26,101.22 v3(106.43,101.05)
  BOTTOM w0.146: CON1601.219 97.13,63.73 97.21,63.64 97.21,63.33 97.93,62.61 97.93,61.66 97.62,61.36 97.62,60.98 97.94,60.66 98.4,60.66 98.56,60.82 v2(98.82,60.82)
