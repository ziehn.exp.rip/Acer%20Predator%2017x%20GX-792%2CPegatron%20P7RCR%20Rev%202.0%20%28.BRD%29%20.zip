# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D<28>: length 40.2
  IN1 w0.127: v5(176.28,101.63) 176.78,102.13 179.57,102.13 186.02,108.58 186.02,113.34 190.26,117.58 194.32,117.58 194.99,116.92 199.63,116.92 200.32,116.24 202.33,116.24 202.9,115.67 203.26,115.67 204.22,114.71 v5(204.31,114.71)
  BOTTOM w0.1: U7700.F4 204.3,114.02 204.3,114.71 v5(204.31,114.71)
  BOTTOM w0.184: v5(176.28,101.63) 176.27,101.63 U7000.F38
FBB_D<29>: length 39.6
  IN1 w0.127: v5(177.01,101.64) 177.15,101.78 178.41,101.78 178.65,101.54 179.72,101.54 186.49,108.31 186.49,113.15 190.16,116.81 194.35,116.81 194.86,116.3 199.59,116.3 200.17,115.72 202.05,115.72 203.3,114.46 203.86,114.46 v5(204.93,113.39)
  BOTTOM w0.17: U7700.F3 v5(204.93,113.39)
  BOTTOM w0.184: U7000.E38 176.96,101.64 v5(177.01,101.64)
FBB_D<30>: length 36.7
  IN1 w0.127: v5(177.71,100.86) 177.91,100.66 178.4,100.66 178.73,100.99 179.84,100.99 186.96,108.12 186.96,112.62 189.94,115.6 199.62,115.6 200.14,115.08 201.94,115.08 v5(203.63,113.39)
  BOTTOM w0.17: v5(203.63,113.39) 203.63,113.39 U7700.G4
  BOTTOM w0.184: v5(177.71,100.86) 177.66,100.86 U7000.D36
FBB_D<31>: length 39.5
  IN1 w0.075: 203.41,112.44 203.44,112.41 203.96,112.41 v5(204.28,112.09)
  IN1 w0.127: v5(177,100.86) 177.64,100.22 178.6,100.22 178.91,100.53 180.16,100.53 187.43,107.8 187.43,112.43 190.14,115.13 199.43,115.13 200.09,114.47 201.78,114.47 203.06,113.19 203.06,112.79 203.41,112.44
  BOTTOM w0.1: U7700.G3 204.28,112.74 v5(204.28,112.09)
  BOTTOM w0.184: v5(177,100.86) 176.96,100.86 U7000.E36
FBB_D<32>: length 22.3
  IN4 w0.127: v5(179.08,127.72) 179.08,127.03 177.96,125.91 177.96,125.48 172.35,119.87 172.35,114.56 v5(171.75,113.97)
  BOTTOM w0.1: v5(179.08,127.72) 178.99,127.81 178.99,128.6 U7701.B4
  BOTTOM w0.102: v5(171.75,113.97) 171.15,113.37 171.15,111.5 171.4,111.25 171.4,110.92 171.75,110.57 U7000.M50
FBB_D<33>: length 23.5
  IN4 w0.102: v5(170.68,109.33) 170.57,109.44 170.57,110.73
  IN4 w0.127: v5(178.32,128.58) 177.93,128.19 177.93,127.64 176.15,125.86 176.15,125.04 171.35,120.24 171.35,115.43 170.87,114.95 170.87,111.03 170.57,110.73
  BOTTOM w0.17: U7701.B3 178.65,128.9 v5(178.32,128.58)
  BOTTOM w0.184: U7000.P48 170.68,109.28 v5(170.68,109.33)
FBB_D<34>: length 22.6
  IN4 w0.127: v5(179.62,128.58) 179.99,128.21 179.99,127.2 178.86,126.06 178.86,125.62 172.82,119.58 172.82,113.88 171.79,112.85 v5(171.73,112.85)
  BOTTOM w0.1: U7701.C4 179.62,129.23 v5(179.62,128.58)
  BOTTOM w0.102: U7000.M51 171.75,111.25 171.36,111.64 171.36,112.47 v5(171.73,112.85)
FBB_D<35>: length 23.5
  IN4 w0.127: v5(171.43,109.99) 171.58,110.14 171.58,111.32 171.28,111.62 171.28,114.63 171.85,115.2 171.85,120.05 177.09,125.29 177.09,126.11 178.7,127.73 178.7,128.96 v5(178.97,129.23)
  BOTTOM w0.17: v5(178.97,129.23) U7701.C3 ; U7000.M49 171.43,109.97 v5(171.43,109.99)
FBB_D<36>: length 29.3
  IN4 w0.075: 177.29,129.56 177.3,129.55 177.84,129.55 178,129.71 178,131.39
  IN4 w0.102: v5(170.69,108.56) 170.27,108.98 170.27,111.13
  IN4 w0.127: 177.29,129.56 177,129.27 175.89,129.27 175.38,128.77 175.38,124.98 170.86,120.45 170.86,115.89 170.46,115.49 170.46,111.32 170.27,111.13 ; 178,131.39 178.44,131.83 v5(178.97,131.83)
  BOTTOM w0.17: U7701.F4 179.3,131.5 v5(178.97,131.83)
  BOTTOM w0.184: U7000.P47 170.66,108.56 v5(170.69,108.56)
FBB_D<37>: length 25.6
  IN4 w0.075: v5(177.67,131.83) 177.35,131.5 177.35,130.99 177.21,130.85 176.78,130.85
  IN4 w0.127: 176.78,130.85 175.96,130.85 174.37,129.26 174.37,125.27 170.31,121.2 170.31,116.56 169.62,115.87 169.62,112.99 169.91,112.69 v5(170.04,112.69)
  BOTTOM w0.1: U7701.F3 178.32,131.83 v5(177.67,131.83)
  BOTTOM w0.102: U7000.P52 170.35,112.38 v5(170.04,112.69)
FBB_D<38>: length 35
  IN4 w0.102: v5(169.32,107.17) 169.7,107.55 169.7,110.47
  IN4 w0.127: v5(179.62,132.48) 178.44,133.66 176.56,133.66 172.36,129.46 172.36,124.82 168.54,121 168.54,115.88 168.76,115.67 168.76,111.41 169.7,110.47
  BOTTOM w0.17: v5(179.62,132.48) U7701.G4
  BOTTOM w0.184: v5(169.32,107.17) 169.32,107.22 U7000.R46
FBB_D<39>: length 31.1
  IN4 w0.075: 176.95,132.29 177.46,132.8 178,132.8 v5(178.32,132.48)
  IN4 w0.102: 169.98,110.85 169.98,108.6 v5(170.67,107.91)
  IN4 w0.127: 176.95,132.29 176.29,131.63 176.01,131.63 173.38,129 173.38,125.17 169.08,120.87 169.08,111.75 169.98,110.85
  BOTTOM w0.17: U7701.G3 v5(178.32,132.48)
  BOTTOM w0.184: v5(170.67,107.91) 170.67,107.87 U7000.P46
FBB_D<40>: length 25.1
  IN1 w0.127: v5(184.18,127.68) 183.92,127.68 183.07,126.83 183.07,125.37 176.8,119.11 175.5,119.11 172.5,116.12 172.5,113 v5(173.25,112.26)
  BOTTOM w0.1: U7701.B11 184.18,128.57 v5(184.18,127.68)
  BOTTOM w0.102: v5(173.25,112.26) 173.25,112.09 173.02,111.86 173.02,111.42 172.8,111.2 172.8,110.93 172.45,110.58 U7000.L50
FBB_D<41>: length 24.4
  IN1 w0.127: v5(185.46,127.25) 185.91,126.81 185.91,125.54 175.08,114.71 175.08,114.03 174.27,113.22 173.8,113.22 v5(173.64,113.06)
  BOTTOM w0.1: U7701.B12 184.82,128.58 184.82,127.89 v5(185.46,127.25)
  BOTTOM w0.102: U7000.L51 172.45,111.21 172.79,111.55 172.79,112.39 173.11,112.71 173.29,112.71 v5(173.64,113.06)
FBB_D<42>: length 24
  IN1 w0.127: v5(184.17,129.23) 184.58,128.82 184.58,126.6 183.76,125.77 183.76,125.16 174.38,115.78 173.47,115.78 173.16,115.48 173.16,115.25 172.87,114.96 172.87,113.99 v5(173.15,113.71)
  BOTTOM w0.102: U7000.L52 172.45,112.5 172.7,112.75 172.7,113.46 172.95,113.71 v5(173.15,113.71)
  BOTTOM w0.17: v5(184.17,129.23) U7701.C11
FBB_D<43>: length 27.2
  IN1 w0.127: v5(185.47,129.23) 185.07,128.83 185.07,126.83 185.26,126.65 185.26,125.68 174.42,114.84 v5(173.31,114.84)
  BOTTOM w0.1: v5(185.47,129.23) 184.82,129.23 U7701.C12
  BOTTOM w0.102: v5(173.31,114.84) 173.26,114.84 172.2,113.78 172.2,112.03 172.1,111.93 172.1,110 U7000.L49
FBB_D<44>: length 31.5
  IN1 w0.075: 183.31,130.85 183.85,130.85 v5(184.17,131.18)
  IN1 w0.127: v5(171.43,107.2) 172.42,108.19 172.42,111.12 172.14,111.4 172.14,116.42 175.31,119.59 176.28,119.59 182.29,125.59 182.29,130.07 183.06,130.85 183.31,130.85
  BOTTOM w0.17: v5(184.17,131.18) U7701.F11
  BOTTOM w0.184: v5(171.43,107.2) 171.43,107.23 U7000.M46
FBB_D<45>: length 31.3
  IN1 w0.127: v5(185.47,131.18) 185.88,130.77 185.88,129.35 186.7,128.53 186.7,124.95 177.22,115.48 177.22,114.9 174.05,111.73 174.05,108.81 173.55,108.31 173.11,108.31 v5(172.82,108.6)
  BOTTOM w0.1: U7701.F12 184.82,131.18 v5(185.47,131.18)
  BOTTOM w0.17: v5(172.82,108.6) 172.8,108.6 U7000.L47
FBB_D<46>: length 32.2
  IN1 w0.127: v5(171.45,109.3) 171.23,109.3 170.55,109.98 170.55,110.48 170.9,110.83 170.9,114.75 171.3,115.16 171.3,117.34 172.04,118.08 172.04,119.21 174.63,121.8 176.7,121.8 180.95,126.05 180.95,130.6 182.58,132.23 183.93,132.23 v5(184.17,132.48)
  BOTTOM w0.17: v5(184.17,132.48) U7701.G11 ; v5(171.45,109.3) 171.45,109.25 U7000.M48
FBB_D<47>: length 33.1
  IN1 w0.075: v5(184.82,131.83) 184.5,131.5 183.29,131.5
  IN1 w0.127: v5(171.45,107.91) 171.85,108.31 171.85,110.5 171.36,110.99 171.36,114.63 171.73,115 171.73,116.67 172.57,117.52 172.57,119.03 174.83,121.29 177.1,121.29 181.65,125.85 181.65,130.38 182.77,131.5 183.29,131.5
  BOTTOM w0.17: v5(184.82,131.83) U7701.G12
  BOTTOM w0.184: U7000.M47 171.45,107.95 171.45,107.91 v5(171.45,107.91)
FBB_D<48>: length 50.3
  IN1 w0.127: v5(183.52,139.63) 183.32,139.83 183.32,140.7 183.78,141.15 187.35,141.15 193.24,135.26 193.24,125.51 182.56,114.82 182.56,110.78 180.03,108.25 177.39,108.25 v5(176.99,108.65)
  BOTTOM w0.17: U7701.V11 183.85,139.3 v5(183.52,139.63)
  BOTTOM w0.184: v5(176.99,108.65) 177.05,108.65 U7000.D48
FBB_D<49>: length 39.9
  IN1 w0.075: 185.73,139.3 185.15,139.3 v5(184.82,139.63)
  IN1 w0.127: 185.73,139.3 186.44,138.59 186.82,138.59 186.92,138.68 187.82,138.68 191.25,135.26 191.25,125.5 180.46,114.71 180.46,111.47 180.05,111.06 178.76,111.06 v5(178.38,110.68)
  BOTTOM w0.17: U7701.V12 v5(184.82,139.63)
  BOTTOM w0.184: U7000.C50 v5(178.38,110.68)
FBB_D<50>: length 47.6
  IN1 w0.075: 183.85,139.96 183.85,138.65 v5(183.52,138.33)
  IN1 w0.127: v5(178.4,109.3) 178.4,109.02 178.67,108.75 179.7,108.75 181.49,110.54 181.49,114.42 192.57,125.5 192.57,135.27 187.43,140.4 186.96,140.4 186.54,140.82 184.72,140.82 183.85,139.96
  BOTTOM w0.17: v5(183.52,138.33) 183.85,138.65 U7701.U11
  BOTTOM w0.184: U7000.C48 v5(178.4,109.3)
FBB_D<51>: length 43.2
  IN1 w0.075: v5(184.17,138.98) 184.5,139.3 184.5,139.84 184.65,139.99 185.53,139.99
  IN1 w0.127: v5(178.39,109.99) 180.1,109.99 181.01,110.9 181.01,114.6 191.91,125.5 191.91,135.26 187.63,139.54 186.93,139.54 186.48,139.99 185.53,139.99
  BOTTOM w0.17: U7701.U12 v5(184.17,138.98)
  BOTTOM w0.184: U7000.C49 v5(178.39,109.99)
FBB_D<52>: length 40
  IN1 w0.075: 184.02,136.7 184.02,136.7 185.74,136.7
  IN1 w0.102: 176.67,109.63 176.67,111 176.57,111.25
  IN1 w0.127: v5(183.52,137.03) 183.53,137.02 U7701.P11 184.02,136.7 ; 176.57,111.25 176.57,111.58 177.21,112.22 177.21,112.72 177.58,113.09 178.54,113.09 179.25,113.79 179.25,114.83 189.79,125.37 189.79,134.84 188.75,135.87 188.75,136.06 188.26,136.55 186.56,136.55 186.35,136.76 185.8,136.76 185.74,136.7 ; v5(176.99,109.3) 176.67,109.63
  BOTTOM w0.17: U7701.P11 183.53,137.02 v5(183.52,137.03)
  BOTTOM w0.184: U7000.E49 v5(176.99,109.3)
FBB_D<53>: length 38.2
  IN1 w0.075: 185.68,137.35 185.15,137.35 v5(184.82,137.03)
  IN1 w0.102: 177.46,111.77 177.33,111.64 177.33,111 v5(177.03,110.7)
  IN1 w0.123: 179.85,114.26 179.85,114.77
  IN1 w0.127: 177.46,111.77 178.12,111.77 179.85,113.49 179.85,114.26 ; 185.68,137.35 186.18,137.85 187.63,137.85 189.23,136.25 189.23,136.06 190.26,135.03 190.26,125.18 179.85,114.77
  BOTTOM w0.17: U7701.P12 184.82,137.03 v5(184.82,137.03)
  BOTTOM w0.184: U7000.E50 177,110.7 v5(177.03,110.7)
FBB_D<54>: length 37.7
  IN1 w0.127: v5(175.58,109.32) 175.58,109.33 175.22,109.68 174.76,109.68 174.58,109.86 174.58,110.46 175.15,111.03 175.15,112.12 177.2,114.17 177.74,114.17 178.11,114.54 178.11,115.59 188.29,125.77 188.29,133.77 187.04,135.02 184.23,135.02 v5(183.52,135.73)
  BOTTOM w0.17: v5(183.52,135.73) U7701.N11
  BOTTOM w0.184: v5(175.58,109.32) 175.58,109.32 175.62,109.32 U7000.F49
FBB_D<55>: length 37.8
  IN1 w0.102: 175.94,108.93 175.94,110.93
  IN1 w0.127: v5(175.61,108.59) 175.94,108.93 ; 175.94,110.93 176.1,111.09 176.1,112.03 176.56,112.49 176.56,112.71 177.41,113.56 178.18,113.56 178.64,114.02 178.64,115.46 188.97,125.78 188.97,134.57 187.89,135.64 186.79,135.64 186.5,135.35 185.2,135.35 v5(184.82,135.73)
  BOTTOM w0.17: v5(184.82,135.73) U7701.N12
  BOTTOM w0.184: U7000.F48 175.61,108.61 v5(175.61,108.59)
FBB_D<56>: length 41.3
  IN4 w0.127: v5(179.62,139.63) 180.01,140.01 181.48,140.01 182.4,139.1 182.4,135.84 182.46,135.57 182.77,135.26 182.9,135.22 185.23,135.22 185.84,134.61 185.84,133.58 186.68,132.73 186.68,127.12 183.29,123.73 183.29,118.89 178,113.6 177.81,113.6 177.06,112.85 177.06,112.1 175.93,110.97 175.93,110.33 175.65,110.05 v5(175.55,110.05)
  BOTTOM w0.17: v5(179.62,139.63) U7701.V4
  BOTTOM w0.184: v5(175.55,110.05) 175.65,110.05 U7000.F50
FBB_D<57>: length 43.8
  IN4 w0.127: v5(177.74,112.72) 178,112.99 178.32,112.99 183.76,118.43 183.76,123.51 187.15,126.91 187.15,135.2 187.85,135.9 187.85,140.18 187.22,140.82 180.02,140.82 179.36,140.16 178.86,140.16 v5(178.32,139.63)
  BOTTOM w0.102: U7000.D52 177.3,111.8 177.3,112.33 177.7,112.72 v5(177.74,112.72)
  BOTTOM w0.17: U7701.V3 178.65,139.3 v5(178.32,139.63)
FBB_D<58>: length 35.3
  IN4 w0.127: v5(173.54,110.7) 173.55,110.69 173.59,110.69 178.15,115.25 178.15,116.29 182.07,120.21 182.07,125.85 183.09,126.87 183.09,132.27 183.15,132.47 183.16,132.78 182.02,133.92 181.58,134.77 181.33,135.89 181.33,137.94 180.73,138.53 v5(180.73,139.04)
  BOTTOM w0.1: v5(180.73,139.04) 180.68,139 179.64,139 U7701.U4
  BOTTOM w0.184: U7000.J50 173.54,110.66 v5(173.54,110.7)
FBB_D<59>: length 41.6
  IN4 w0.127: v5(178.97,138.98) 180.14,138.98 180.59,139.43 181.14,139.43 181.88,138.69 181.88,135.9 182.31,134.42 182.94,133.69 183.46,133.23 185.28,133.23 185.84,132.67 185.84,130.8 185.26,130.22 185.26,129.75 184.59,129.08 184.59,126.9 182.7,125 182.7,119.56 178.63,115.49 178.63,115.01 176.46,112.84 176.46,112.22 176.07,111.83 175.38,111.83 174.5,110.95 174.5,109.66 v5(174.86,109.29)
  BOTTOM w0.17: v5(178.97,138.98) U7701.U3
  BOTTOM w0.184: v5(174.86,109.29) 174.86,109.26 U7000.H48
FBB_D<60>: length 31.1
  IN4 w0.127: v5(180.52,136.47) 180.8,136.19 180.8,135.56 181.04,134.61 181.35,134.02 182.02,133.35 182.17,132.98 182.45,132.05 182.45,126.89 181.49,125.93 181.49,121.55 178.89,118.95 178.89,117.69 177.41,116.21 177.41,115 176.22,113.81 175.48,113.81 v5(175.47,113.82)
  BOTTOM w0.1: v5(180.52,136.47) 180.43,136.38 179.62,136.38 U7701.P4
  BOTTOM w0.102: v5(175.47,113.82) 175.19,113.54 175.19,111.92 174.55,111.28 U7000.H51
FBB_D<61>: length 33.2
  IN4 w0.075: 179.24,136.7 178.65,136.7
  IN4 w0.127: 178.65,136.7 178.32,137.03 v5(177.67,137.03) ; v5(173.45,111.45) 173.6,111.45 174.44,112.29 174.44,113.34 175.05,113.95 175.05,114.87 176.06,115.88 176.35,115.88 178.25,117.77 178.25,119.28 180.84,121.88 180.84,125.95 181.8,126.91 181.8,132.23 181.59,133.06 180.6,134.06 180.01,135.21 180.01,135.93 179.24,136.7
  BOTTOM w0.1: v5(177.67,137.03) 178.32,137.03 U7701.P3
  BOTTOM w0.184: U7000.J51 v5(173.45,111.45)
FBB_D<62>: length 30.7
  IN4 w0.127: v5(179.62,135.73) 179.62,135.29 179.81,134.56 180.2,133.89 180.38,133.58 181.09,132.88 181.21,132.45 181.21,126.99 180.26,126.04 180.26,122.18 177.57,119.48 177.57,118.2 174.66,115.3 174.66,114.66 174.36,114.36 v5(173.94,114.36)
  BOTTOM w0.102: v5(173.94,114.36) 174.45,113.85 174.45,112.25 174.2,112 174.2,110 U7000.H49
  BOTTOM w0.17: v5(179.62,135.73) U7701.N4
FBB_D<63>: length 28.3
  IN4 w0.127: v5(178.32,135.73) 178.32,135.64 179.28,134.69 179.38,134.5 179.43,134.35 179.6,133.89 179.71,133.59 180.58,132.72 180.65,132.52 180.65,127.09 179.66,126.09 179.66,122.55 176.79,119.68 176.79,118.26 174.19,115.66 v5(174.19,115.24)
  BOTTOM w0.102: U7000.H52 174.79,111.99 174.79,114.64 v5(174.19,115.24)
  BOTTOM w0.17: v5(178.32,135.73) U7701.N3
FBB_DBI<0>: length 30.1
  IN2 w0.075: 197.67,111.65 197.72,111.69 197.95,111.69 198.11,111.85 198.11,112.41 v5(198.43,112.74)
  IN2 w0.127: 197.67,111.65 197.51,111.49 197.51,111.22 197.23,110.94 195.58,110.94 195.26,111.26 192.89,111.26 192.03,110.39 192.03,108.48 183.15,99.59 183.15,98.46 v5(182.3,97.62)
  BOTTOM w0.102: U7000.C32 178.38,97.42 178.88,97.42 179.12,97.18 179.73,97.18 179.81,97.09 181.78,97.09 v5(182.3,97.62)
  BOTTOM w0.17: U7700.R3 v5(198.43,112.74)
FBB_DBI<1>: length 33.4
  IN2 w0.075: v5(198.43,118.59) 198.11,118.26 198.11,117.66
  IN2 w0.127: 198.11,117.66 196.97,116.52 192.84,116.52 189.8,113.47 189.8,110.07 179.1,99.38 179.1,99.1 178.44,98.43 177.37,98.43 v5(177.02,98.79)
  BOTTOM w0.17: v5(198.43,118.59) U7700.R12
  BOTTOM w0.184: U7000.E33 176.99,98.79 v5(177.02,98.79)
FBB_DBI<2>: length 46.4
  IN2 w0.075: 205.15,118.91 204.77,118.91 204.61,119.08 204.61,120.75
  IN2 w0.127: v5(206.23,118.59) 205.97,118.85 205.91,118.91 205.15,118.91 ; v5(176.99,105.83) 177.14,105.98 178.43,105.98 185.85,113.39 185.85,118.64 192.14,124.94 202.08,124.94 202.97,124.05 202.97,123.86 204.46,122.37 204.46,120.9 204.61,120.75
  BOTTOM w0.1: v5(206.23,118.59) 205.58,118.59 U7700.E12
  BOTTOM w0.184: v5(176.99,105.83) 176.97,105.83 U7000.E44
FBB_DBI<3>: length 56.2
  IN2 w0.127: v5(206.32,115.54) 206.32,115.72 205.23,116.81 203.59,116.81 203.26,117.15 203.26,120.1 203.46,120.3 203.62,120.3 203.84,120.52 203.84,121.56 201.45,123.96 192.3,123.96 186.39,118.07 186.39,112.26 178.61,104.48 174.51,104.48 173.88,103.85 173.88,103.54 174.1,103.32 174.57,103.32 v5(174.91,102.97)
  BOTTOM w0.1: v5(206.32,115.54) 205.78,115 205.78,114.76 205.58,114.56 205.58,113.39 U7700.E3
  BOTTOM w0.184: U7000.G39 174.93,102.97 v5(174.91,102.97)
FBB_DBI<4>: length 25.9
  IN2 w0.075: 178.53,130.4 178.65,130.28 178.65,129.01 178.69,128.97
  IN2 w0.127: 178.69,128.97 178.69,127.68 171.21,120.2 171.21,112.62 v5(170,111.41) ; 178.53,130.4 178.34,130.59 178.34,131.15 v5(178.32,131.18)
  BOTTOM w0.102: U7000.P49 170,110 v5(170,111.41)
  BOTTOM w0.17: U7701.E3 178.65,130.85 v5(178.32,131.18)
FBB_DBI<5>: length 29.1
  IN2 w0.075: 183.17,130.67 183.17,130.68 183.34,130.85 183.85,130.85 v5(184.17,130.53)
  IN2 w0.127: v5(172.84,110.06) 172.62,110.28 172.62,111.18 173.29,111.85 173.95,111.85 174.42,112.32 174.42,112.58 175.22,113.38 175.84,113.38 178.31,115.85 178.31,119.71 183.47,124.87 183.47,127.24 183.07,127.65 183.07,130.57 183.17,130.67
  BOTTOM w0.102: v5(172.84,110.06) 172.82,110.04 172.82,109.56 172.45,109.19 U7000.L48
  BOTTOM w0.17: v5(184.17,130.53) 184.35,130.71 U7701.E12
FBB_DBI<6>: length 38.4
  IN2 w0.075: 185.78,137.35 184.5,137.35 v5(184.17,137.68)
  IN2 w0.102: 176.66,110.39 176.66,110.85
  IN2 w0.127: 176.66,110.85 176.66,110.87 176.51,111.01 176.51,111.48 176.81,111.78 178.14,111.78 183.31,116.95 183.31,120.44 183.76,120.9 189.28,126.41 189.28,132.5 188.99,132.79 188.99,134.54 188.32,135.21 188.32,136.03 187.79,136.56 186.56,136.56 185.78,137.35 ; v5(177.03,110.02) 176.66,110.39
  BOTTOM w0.17: v5(184.17,137.68) U7701.R12
  BOTTOM w0.184: v5(177.03,110.02) 177.03,110.03 U7000.D50
FBB_DBI<7>: length 31.3
  IN2 w0.075: 179.3,136.03 179.3,135.36 179.28,135.34
  IN2 w0.127: v5(178.97,137.03) 178.97,136.91 179.36,136.53 179.36,136.09 179.3,136.03 ; v5(175.88,114.9) 175.63,115.15 175.63,116.12 176.99,117.48 176.99,121.73 181.49,126.23 181.49,132.26 179.51,134.24 179.51,134.58 179.28,134.81 179.28,135.34
  BOTTOM w0.102: U7000.H50 174.9,110.7 174.9,111.25 175.54,111.89 175.54,112.63 175.88,112.97 v5(175.88,114.9)
  BOTTOM w0.17: v5(178.97,137.03) 178.97,137.03 U7701.R3
FBB_EDC<0>: length 27.6
  IN2 w0.075: v5(197.78,112.09) 197.46,112.41 196.8,112.41
  IN2 w0.127: 196.8,112.41 196.45,112.76 195.46,112.76 195.28,112.94 193.75,112.94 191.4,110.59 191.4,108.87 181.78,99.25 180.81,99.25 v5(180.37,98.81)
  BOTTOM w0.1: v5(197.78,112.09) 197.78,112.74 U7700.T3
  BOTTOM w0.184: U7000.B33 179.24,98.94 180.25,98.94 v5(180.37,98.81)
FBB_EDC<1>: length 33.4
  IN2 w0.127: v5(197.78,119.23) 196.55,119.23 195.21,117.89 191.97,117.89 189.16,115.08 189.16,110.81 179.63,101.27 179.63,100.92 178.61,99.9 176.67,99.9 v5(176.27,99.51)
  BOTTOM w0.17: U7700.T12 197.79,119.23 v5(197.78,119.23)
  BOTTOM w0.184: v5(176.27,99.51) 176.31,99.51 U7000.E35
FBB_EDC<2>: length 48.6
  IN2 w0.075: 205.3,120.86 205.3,120.17
  IN2 w0.127: 205.3,120.17 205.58,119.89 v5(205.59,119.89) ; 205.3,120.86 205.3,123.12 202.66,125.76 192.02,125.76 185.46,119.2 185.22,118.96 185.22,114.52 178.78,108.08 178.78,107.35 178.06,106.63 175.56,106.63 175.36,106.43 174.78,106.43 v5(174.39,106.04)
  BOTTOM w0.1: v5(205.59,119.89) 205.59,119.23 U7700.D12
  BOTTOM w0.184: v5(174.39,106.04) 174.55,106.2 175.19,106.2 U7000.G44
FBB_EDC<3>: length 53
  IN2 w0.127: v5(174.2,101.65) 174.21,101.65 174.25,101.61 174.56,101.3 174.56,100.64 174.91,100.29 176.02,100.29 176.18,100.45 178.19,100.45 178.71,100.97 178.71,101.7 188.35,111.34 188.35,116.73 191.97,120.35 193.94,120.35 194.94,121.35 201.05,121.35 201.48,120.92 201.48,118.47 201.2,118.19 201.2,116.38 203.07,114.51 203.88,114.51 204.09,114.3 204.49,114.3 204.64,114.44 205.11,114.44 205.58,113.96 v5(205.58,112.74)
  BOTTOM w0.17: v5(205.58,112.74) U7700.D3
  BOTTOM w0.184: U7000.H38 174.25,101.65 v5(174.2,101.65)
FBB_EDC<4>: length 25.1
  IN2 w0.075: 177.38,129.55 178,129.55
  IN2 w0.127: 178,129.55 v5(178.32,129.88) ; v5(170.01,113.86) 170.39,114.24 170.39,122.55 172.8,124.96 172.8,126.14 175.9,129.24 177.07,129.24 177.38,129.55
  BOTTOM w0.102: U7000.P50 170.72,110.72 170.72,111.18 170.91,111.37 170.91,112.13 170.85,112.19
  BOTTOM w0.17: 170.85,112.19 170.85,113.01 v5(170.01,113.86) ; v5(178.32,129.88) U7701.D3
FBB_EDC<5>: length 26.5
  IN2 w0.114: v5(173.55,109.3) 173.55,109.57 173.84,109.85 173.84,110.31 173.95,110.42 173.95,111.13 175.64,112.82 176.16,112.82 178.16,114.83
  IN2 w0.121: 178.76,115.42 178.16,114.83
  IN2 w0.127: 178.76,115.42 178.9,115.56 178.9,118.9 184.82,124.82 v5(184.82,129.88)
  BOTTOM w0.17: v5(184.82,129.88) U7701.D12
  BOTTOM w0.184: v5(173.55,109.3) 173.55,109.25 U7000.J48
FBB_EDC<6>: length 39.3
  IN2 w0.075: v5(184.82,138.33) 185.15,138 185.94,138
  IN2 w0.127: v5(177.71,111.38) 177.95,111.14 178.42,111.14 178.51,111.06 179.94,111.06 184.66,115.78 184.66,120.44 190.35,126.13 190.35,136.33 188.78,137.9 186.04,137.9 185.94,138
  BOTTOM w0.17: v5(184.82,138.33) U7701.T12
  BOTTOM w0.184: v5(177.71,111.38) 177.68,111.38 U7000.D51
FBB_EDC<7>: length 32.2
  IN2 w0.075: v5(178.32,138.33) U7701.T3 179.13,138 179.3,137.83 179.3,137.5
  IN2 w0.127: v5(176.77,114.97) 176.77,115.68 177.58,116.5 177.58,120.6 182.2,125.22 182.2,132.83 179.98,135.05 179.98,136.82 179.3,137.5
  BOTTOM w0.102: U7000.F51 176.32,111.42 176.32,112.03 176.38,112.09
  BOTTOM w0.17: v5(178.32,138.33) 178.65,138 U7701.T3 ; 176.38,112.09 176.38,113.08 176.77,113.47 v5(176.77,114.97)
FBB_VREFC: length 31.8
  TOP w0.432: v2(202.5,123.88) 202.29,123.68 202.29,122.56 202.53,122.32 C7704.1 202.99,122.23 202.99,120.44 202.44,119.89 v5(202.33,119.89)
  TOP w0.508: v5(187.74,135.11) 187.56,134.93 185.98,134.93 v5(185.47,134.43)
  BOTTOM w0.3: v5(185.47,134.43) U7701.K13 ; v5(202.33,119.89) U7700.K13
  BOTTOM w0.432: v2(202.5,123.88) 201.61,124.77 201.61,124.87 v1(200.97,125.51) 201.78,126.32 R7709.2 R7710.1 R7711.2 192.92,126.42 190.84,128.51 190.84,132.35 188.58,134.6 188.53,134.6 C7703.1 188.02,135.11 v5(187.74,135.11)
FBB_VREFC_Q: length 3.9
  BOTTOM w0.432: v1(202.72,125.74) 202.72,126.73 202.16,127.29 R7709.1 202.19,127.69 202.7,127.69 Q7700.3
FBB_WCK01: length 36.2
  IN2 w0.114: v5(173.51,98.79) 173.68,98.62 173.68,98.38 174.18,97.88 176.84,97.88 177.03,97.68 178.7,97.68 190.58,109.56 190.58,113.19 191.56,114.16 194.47,114.16 195.39,115.08 197.26,115.08 198.11,114.24 198.23,114.24 v5(198.43,114.04)
  BOTTOM w0.122: U7700.T4 198.11,113.71 v5(198.43,114.04)
  BOTTOM w0.14: U7000.J33 v5(173.51,98.79)
FBB_WCK01*: length 36.1
  IN2 w0.114: v5(198.43,114.69) 198.43,114.54 198.35,114.45 198.2,114.45 197.35,115.3 195.3,115.3 194.38,114.38 191.47,114.38 190.37,113.28 190.37,109.65 178.62,97.9 177.12,97.9 176.92,98.09 174.27,98.09 173.89,98.47 173.89,98.56 174.12,98.78 v5(174.22,98.78)
  BOTTOM w0.122: v5(198.43,114.69) U7700.T5
  BOTTOM w0.14: U7000.H33 v5(174.22,98.78)
FBB_WCK23: length 53
  IN2 w0.075: v5(206.23,114.04) 205.94,114.34 205.89,114.34 205.84,114.39 205.71,114.51 205.71,114.69 205.71,114.87 205.71,115.09 205.64,115.16
  IN2 w0.114: v5(173.51,102.95) 173.7,102.75 173.7,102.56 174.21,102.05 178.17,102.05 187.27,111.14 187.27,117.37 192.32,122.41 201.74,122.41 202.78,121.37 202.78,116.29 203.4,115.67 205.13,115.67 205.46,115.34 205.64,115.16
  BOTTOM w0.122: v5(206.23,114.04) U7700.D4
  BOTTOM w0.14: U7000.J39 173.55,102.95 173.51,102.95 v5(173.51,102.95)
FBB_WCK23*: length 53.1
  IN2 w0.075: v5(206.23,114.69) 206.23,114.59 206.15,114.51 205.96,114.51 205.89,114.58 205.89,114.69 205.89,115.19 205.87,115.21 205.87,115.24 205.86,115.24
  IN2 w0.114: v5(174.2,102.95) 174.02,102.95 173.92,102.85 173.92,102.65 174.3,102.26 178.08,102.26 187.05,111.23 187.05,117.46 192.23,122.63 201.83,122.63 203,121.46 203,116.38 203.49,115.89 205.22,115.89 205.86,115.24
  BOTTOM w0.122: U7700.D5 206.07,114.36 206.23,114.53 v5(206.23,114.69)
  BOTTOM w0.14: v5(174.2,102.95) 174.2,102.68 174.22,102.65 U7000.H39
FBB_WCK45: length 31
  IN2 w0.075: v5(179.62,130.53) 179.78,130.69 179.78,130.77 179.79,130.78 180.14,131.13
  IN2 w0.114: 180.14,131.13 180.59,131.13 180.94,130.78 180.94,127.81 179.46,126.32 179.46,126.32 172.45,119.31 172.45,111.89 171.78,111.23 171.78,110.45 172.29,109.94 172.29,107.07 172.37,106.99 172.49,106.99 172.72,107.22 v5(172.78,107.22)
  BOTTOM w0.122: U7000.L46 v5(172.78,107.22) ; v5(179.62,130.53) U7701.D4
FBB_WCK45*: length 31
  IN2 w0.075: 180.2,130.92 180.17,130.92 179.97,130.71 179.97,130.59 180.07,130.49 180.23,130.49 v5(180.27,130.53)
  IN2 w0.114: v5(172.78,106.52) 172.77,106.53 172.52,106.77 172.28,106.77 172.22,106.84 172.08,106.98 172.08,109.86 171.57,110.36 171.57,111.32 172.23,111.98 172.23,119.4 179.3,126.47 180.73,127.9 180.73,130.69 180.5,130.92 180.2,130.92
  BOTTOM w0.122: v5(180.27,130.53) U7701.D5 ; U7000.L45 v5(172.78,106.52)
FBB_WCK67: length 45
  IN2 w0.114: v5(179.62,138.33) 179.99,138.69 180.6,138.69 181.69,137.6 181.69,135.92 182.38,135.23 187,135.23 188.21,134.01 188.21,133.06 188.42,132.85 188.42,126.75 181.69,120.02 181.69,117.02 180.42,115.75 180.25,115.75 176.27,111.78 175.4,111.78 175.08,111.45 175.08,110.68 174.49,110.09 174.49,108.56 174.57,108.48 174.73,108.48 v5(174.85,108.6)
  BOTTOM w0.122: v5(179.62,138.33) U7701.T4
  BOTTOM w0.14: v5(174.85,108.6) 174.85,108.55 U7000.H47
FBB_WCK67*: length 44.8
  IN2 w0.114: v5(180.27,138.33) 180.42,138.48 180.51,138.48 181.48,137.51 181.48,135.83 182.29,135.01 186.91,135.01 188,133.92 188,132.97 188.21,132.76 188.21,126.84 181.48,120.11 181.48,117.11 180.33,115.97 180.16,115.97 176.18,111.99 175.31,111.99 174.86,111.54 174.86,110.77 174.27,110.18 174.27,108.47 174.5,108.24 174.86,108.24 174.91,108.19 v5(174.91,107.85)
  BOTTOM w0.122: U7701.T5 179.95,138.19 180.08,138.33 v5(180.27,138.33)
  BOTTOM w0.14: U7000.H46 174.55,107.73 174.67,107.85 v5(174.91,107.85)
FBB_ZQ_1_B: length 2.9
  TOP w0.432: v5(203.63,119.89) 203.63,121.06 v1(203.86,121.29) 203.86,121.78 203.82,121.83 R7712.2
  BOTTOM w0.254: v5(203.63,119.89) 203.31,119.56 U7700.H13
FBB_ZQ_2_B: length 3.6
  TOP w0.432: v5(185.47,132.48) 185.47,132.59 186.09,133.2 186.95,133.2 v1(186.98,133.23) 187.32,133.58 R7713.2
  BOTTOM w0.254: v5(185.47,132.48) 185.47,132.48 U7701.H13
FBC_CLK0: length 34.3
  IN1 w0.114: v5(174.92,86.17) 174.92,86.16 175.36,85.72 178.26,85.72 178.49,85.96 189.41,85.96 191.27,87.81 199.56,87.81 199.7,87.66 199.7,87.47 v5(199.43,87.2)
  IN4 w0.075: 201.34,83.5 201.94,82.91 201.94,82.8 201.8,82.66 201.65,82.66 v5(201.43,82.88)
  IN4 w0.114: v5(199.43,87.2) 199.66,86.97 199.66,86.71 199.55,86.6 199.55,86.14 199.79,85.9 200.91,85.9 201.34,85.46 201.34,83.5
  BOTTOM w0.122: v5(201.43,82.88) U7800.K11
  BOTTOM w0.14: v5(174.92,86.17) 174.93,86.17 U7000.G15
FBC_CLK0*: length 34.1
  IN1 w0.114: v5(200.18,87.2) 199.92,87.46 199.92,87.75 199.64,88.03 191.18,88.03 189.32,86.17 178.4,86.17 178.17,85.94 175.85,85.94 v5(175.62,86.17)
  IN4 w0.075: v5(201.43,82.23) 201.68,82.48 201.87,82.48 202.11,82.73 202.11,82.98 201.56,83.54 201.56,83.56
  IN4 w0.114: 201.56,83.56 201.56,85.55 201,86.11 199.88,86.11 199.76,86.23 199.76,86.51 199.88,86.62 199.88,86.9 v5(200.18,87.2)
  BOTTOM w0.122: v5(201.43,82.23) U7800.K10
  BOTTOM w0.14: U7000.F15 175.63,86.17 v5(175.62,86.17)
FBC_CLK1: length 37.4
  IN1 w0.114: v5(200.15,93.89) 200.15,93.9 200.44,94.19 200.44,94.42 200.56,94.55 200.78,94.76 200.78,98.41 200.97,98.6 201.15,98.78 201.59,98.78 201.84,98.54 201.84,98.35 v5(202.08,98.11)
  IN4 w0.114: v5(174.2,90.34) 173.95,90.09 173.95,89.94 174.05,89.84 174.44,89.84 174.56,89.96 179.89,89.96 180.81,89.03 186.26,89.03 190.44,93.21 200.2,93.21 200.44,93.45 200.44,93.6 v5(200.15,93.89)
  BOTTOM w0.122: v5(202.08,98.11) U7801.K11
  BOTTOM w0.14: v5(174.2,90.34) 174.25,90.34 U7000.H21
FBC_CLK1*: length 37.4
  IN1 w0.114: v5(201.43,98.11) 201.62,98.3 201.62,98.45 201.5,98.57 201.24,98.57 201,98.32 201,94.67 200.65,94.33 200.65,94.19 v5(200.95,93.89)
  IN4 w0.114: v5(200.95,93.89) 200.65,93.59 200.65,93.36 200.29,93 190.53,93 186.35,88.82 180.72,88.82 179.8,89.74 174.65,89.74 174.53,89.62 173.96,89.62 173.73,89.85 173.73,90.12 v5(173.49,90.37)
  BOTTOM w0.122: v5(201.43,98.11) U7801.K10
  BOTTOM w0.14: U7000.J21 173.53,90.37 v5(173.49,90.37)
FBC_CMD<0>: length 34.6
  BOTTOM w0.1: U7800.H4 202.73,78.33 202.73,76.58 202.62,76.48 202.62,75.62 202.38,75.38
  BOTTOM w0.102: 182.19,80.65 182.19,81.49 181.19,82.5 179.1,82.5 178.89,82.7 178.4,82.7 U7000.C11
  BOTTOM w0.14: 202.38,75.38 200.82,73.82 186.11,73.82 182.19,77.74 182.19,80.65
FBC_CMD<1>: length 31.1
  TOP w0.102: 201.53,75.38 v5(201.53,75.42)
  TOP w0.14: R7117.1 201.53,75.38
  BOTTOM w0.1: v5(201.53,75.42) 201.5,75.45 201.5,76.35 201.45,76.4 201.45,77.05 U7800.K2
  BOTTOM w0.102: U7000.B11 178.9,83.05 179.25,82.7 181.31,82.7 182.61,81.41 182.61,80.57
  BOTTOM w0.104: v5(201.53,75.42) 201.49,75.38
  BOTTOM w0.14: 201.49,75.38 200.67,74.56 186.65,74.56 182.61,78.59 182.61,80.57
FBC_CMD<2>: length 28.6
  BOTTOM w0.1: U7800.M4 200.79,78.32 200.79,76.04 200.46,75.7
  BOTTOM w0.102: 183.02,80.47 183.02,81.31 181.28,83.05 U7000.A11
  BOTTOM w0.136: 200.42,75.67 200.46,75.7
  BOTTOM w0.14: 183.02,80.47 183.02,79.13 186.49,75.67 200.42,75.67
FBC_CMD<3>: length 29
  BOTTOM w0.1: 195.16,79.75 195.42,80 198.98,80 199.34,79.64 200.95,79.64 201.1,79.48 U7800.L5
  BOTTOM w0.102: 183.24,81.46 181.3,83.4 177.7,83.4 U7000.D11
  BOTTOM w0.14: 183.24,81.46 183.46,81.24 183.46,79.74 185.7,77.5 193.59,77.5 195.16,79.07 195.16,79.75
FBC_CMD<4>: length 27.3
  BOTTOM w0.1: U7800.L4 201.43,78.98 201.43,79.7 201.29,79.84 199.47,79.84 199.11,80.2 195.29,80.2 194.85,79.77
  BOTTOM w0.102: U7000.A12 181.33,83.75 183.24,81.84
  BOTTOM w0.14: 183.24,81.84 183.87,81.21 183.87,80.24 186.04,78.07 193.46,78.07 194.85,79.47 194.85,79.77
FBC_CMD<5>: length 27.2
  BOTTOM w0.1: 194.99,80.33 195.07,80.41 199.21,80.41 199.58,80.04 201.45,80.04 201.75,79.73 U7800.K5
  BOTTOM w0.102: 183.24,82.19 181.33,84.1 179.3,84.1 178.95,83.75 U7000.B12
  BOTTOM w0.111: 194.19,79.53 194.99,80.33
  BOTTOM w0.14: 183.24,82.19 184.3,81.13 184.3,80.54 186.21,78.63 193.29,78.63 194.19,79.53
FBC_CMD<6>: length 28.4
  BOTTOM w0.1: 194.19,79.97 194.83,80.61 199.29,80.61 199.57,80.33 201.67,80.33 202.08,79.92 202.08,78.98 U7800.K4
  BOTTOM w0.102: 181.61,84.19 181.49,84.3 179.15,84.3 178.95,84.1 178.64,84.1 178.29,83.75 U7000.C12
  BOTTOM w0.14: 181.61,84.19 186.37,79.43 193.65,79.43 194.19,79.97
FBC_CMD<7>: length 27.9
  BOTTOM w0.1: 194.57,80.81 199.38,80.81 199.63,80.55 201.95,80.55 202.4,80.1 U7800.J5
  BOTTOM w0.102: 181.4,84.55 179.15,84.55 178.9,84.8 178.4,84.8 U7000.C14
  BOTTOM w0.14: 181.4,84.55 181.71,84.55 184.8,81.46 185.07,81.46 186.53,80.01 193.77,80.01 194.57,80.81
FBC_CMD<8>: length 28.1
  BOTTOM w0.1: 194.19,80.88 194.34,81.03 199.44,81.03 199.67,80.8 202.21,80.8 202.73,80.28 202.73,78.98 U7800.J4
  BOTTOM w0.102: 181.61,84.8 179.25,84.8 178.9,85.15 U7000.B14
  BOTTOM w0.14: 181.61,84.8 181.97,84.8 184.78,81.99 185.31,81.99 186.72,80.58 193.88,80.58 194.19,80.88
FBC_CMD<9>: length 26.9
  BOTTOM w0.1: U7800.J11 202.73,82.88 202.73,81.76 202,81.03 199.73,81.03 199.51,81.24 194.22,81.24
  BOTTOM w0.14: U7000.A14 182.14,85.15 184.73,82.56 185.67,82.56 186.98,81.24 194.22,81.24
FBC_CMD<10>: length 28
  BOTTOM w0.1: U7800.J10 202.46,82.5 202.46,81.89 201.84,81.27 199.78,81.27 199.52,81.52 194.24,81.52
  BOTTOM w0.102: 182.29,85.5 177.7,85.5 U7000.D14
  BOTTOM w0.14: 182.29,85.5 184.71,83.08 186.23,83.08 187.54,81.76 193.71,81.76 193.96,81.52 194.24,81.52
FBC_CMD<11>: length 24.3
  BOTTOM w0.1: 194.27,81.77 199.56,81.77 199.81,81.52 200.73,81.52 201.06,81.85 201.06,82.52 U7800.L10
  BOTTOM w0.102: U7000.A15 182.5,85.85
  BOTTOM w0.14: 182.5,85.85 184.76,83.6 186.91,83.6 188.22,82.28 193.75,82.28 194.27,81.77
FBC_CMD<12>: length 25.5
  BOTTOM w0.1: 194.24,82.44 194.67,82.01 199.85,82.01 200.11,81.75 200.57,81.75 200.78,81.95 200.78,82.88 U7800.L11
  BOTTOM w0.102: 179.78,86.2 179.3,86.2 178.95,85.85 U7000.B15
  BOTTOM w0.14: 194.24,82.44 193.82,82.86 188.56,82.86 187.31,84.12 184.9,84.12 182.82,86.2 179.78,86.2
FBC_CMD<13>: length 25.2
  BOTTOM w0.1: 194.47,82.79 195,82.25 199.93,82.25 200.13,82.45 200.13,82.88
  BOTTOM w0.102: U7000.C15 178.25,85.85 178.6,86.2 178.95,86.2 179.25,86.5 179.42,86.5
  BOTTOM w0.136: 200.13,82.88 U7800.M11
  BOTTOM w0.14: 194.47,82.79 194.47,82.96 193.63,83.8 R7104.1 188.52,83.8 187.68,84.64 184.98,84.64 183.12,86.5 179.42,86.5
FBC_CMD<14>: length 29.6
  BOTTOM w0.1: 201,85.84 201.43,85.41 201.43,84.18 U7800.K12
  BOTTOM w0.134: 199.09,87.41 199.05,87.37 199.05,86.81 199.42,86.44 200.18,86.44 ; 201,85.84 200.39,86.44
  BOTTOM w0.136: 178.62,86.9 178.61,86.91 178.61,86.91 178.41,87.11 178.41,87.11 178.27,87.25 U7000.C17
  BOTTOM w0.14: 199.09,87.41 199.17,87.48 199.17,88.25 198.87,88.55 194.07,88.55 190.77,85.25 184.9,85.25 183.25,86.9 178.62,86.9 ; 200.39,86.44 200.18,86.44
FBC_CMD<15>: length 31.3
  BOTTOM w0.1: 202.75,86.5 202.75,83.51 U7800.H11
  BOTTOM w0.136: U7000.B17 179.1,87.6 179.66,87.6 179.99,87.27
  BOTTOM w0.14: 179.99,87.27 183.46,87.27 184.96,85.77 190.49,85.77 194.03,89.31 200.47,89.31 202.75,87.03 202.75,86.5
FBC_CMD<16>: length 36.6
  BOTTOM w0.1: 202.75,105.63 202.75,102.64 U7801.M4
  BOTTOM w0.102: U7000.B24 178.95,92.15 179.3,92.5 182.58,92.5
  BOTTOM w0.14: 182.58,92.5 183.1,92.5 184.07,93.47 184.07,94.39 186.82,97.14 186.82,99.43 194.95,107.55 201.12,107.55 202.75,105.93 202.75,105.63
FBC_CMD<17>: length 33.7
  TOP w0.14: R7116.1 202.03,105.53 v5(202.03,105.52)
  BOTTOM w0.1: U7801.K2 202.06,103.94 202.06,104.55 202.03,104.57 v5(202.03,105.52)
  BOTTOM w0.102: 183.2,92.16 183.19,92.15 U7000.A24
  BOTTOM w0.14: v5(202.03,105.52) 202.03,105.83 201.11,106.75 194.89,106.75 187.39,99.25 187.39,96.97 184.48,94.06 184.48,93.44 183.2,92.16
FBC_CMD<18>: length 35.9
  BOTTOM w0.1: 201.28,105.63 201.28,104.7 201.41,104.58 201.41,102.86 201.23,102.67 200.8,102.67 U7801.H4
  BOTTOM w0.102: 183.24,91.8 177.7,91.8 U7000.D23
  BOTTOM w0.14: 183.24,91.8 183.33,91.8 184.89,93.37 184.89,93.68 187.95,96.74 187.95,99.08 195.1,106.23 200.82,106.23 201.28,105.76 201.28,105.63
FBC_CMD<19>: length 29
  BOTTOM w0.1: 194.24,102.59 195.82,101.02 200.44,101.02 U7801.J5
  BOTTOM w0.102: 194.19,102.64 194.24,102.59 ; U7000.A23 179.49,91.49 183.24,91.49
  BOTTOM w0.14: 194.19,102.64 193.76,103.08 192.69,103.08 188.52,98.91 188.52,96.57 183.44,91.49 183.24,91.49
FBC_CMD<20>: length 30.8
  BOTTOM w0.1: U7801.J4 201.43,102.01 201.43,101.55 200.7,100.82 195.56,100.82 194.19,102.18
  BOTTOM w0.102: 183.24,91.2 179.73,91.2 179.65,91.12 179.22,91.12 178.9,91.45 U7000.B23
  BOTTOM w0.14: 194.19,102.18 193.86,102.52 192.86,102.52 189.26,98.91 189.26,96.57 183.88,91.2 183.24,91.2
FBC_CMD<21>: length 31.2
  BOTTOM w0.1: 194.19,101.72 195.3,100.61 201.03,100.61 201.75,101.33 U7801.K5
  BOTTOM w0.102: 183.24,90.9 179.1,90.9 178.9,91.1 178.4,91.1 U7000.C23
  BOTTOM w0.14: 194.19,101.72 193.96,101.95 193.03,101.95 189.82,98.74 189.82,96.18 185.35,91.7 185,91.7 184.2,90.9 183.24,90.9
FBC_CMD<22>: length 32.2
  BOTTOM w0.1: U7801.K4 202.08,102.01 202.08,101.16 201.33,100.41 195.1,100.41 194.19,101.33
  BOTTOM w0.102: U7000.C21 178.2,90.05 178.55,90.4 178.95,90.4 179.15,90.6 182.88,90.6
  BOTTOM w0.14: 194.19,101.33 194.19,101.33 193.15,101.33 190.39,98.57 190.39,96 185.56,91.18 185.21,91.18 184.63,90.6 182.88,90.6
FBC_CMD<23>: length 30.9
  BOTTOM w0.1: 194.45,100.61 194.85,100.21 201.58,100.21 202.4,101.04 U7801.L5
  BOTTOM w0.102: 182.89,90.34 179.65,90.34 179.61,90.37 179.31,90.37 178.99,90.05 U7000.B21 ; 194.25,100.81 194.45,100.61
  BOTTOM w0.14: 194.25,100.81 193.36,100.81 190.95,98.4 190.95,95.83 185.46,90.34 182.89,90.34
FBC_CMD<24>: length 31
  BOTTOM w0.1: 194.23,100.27 194.49,100.01 201.76,100.01 202.62,100.87 202.62,101.44 202.73,101.55 202.73,102.01 U7801.L4
  BOTTOM w0.102: U7000.A21 182.83,90.05
  BOTTOM w0.14: 194.23,100.27 193.57,100.27 191.52,98.22 191.52,95.66 185.91,90.05 182.83,90.05
FBC_CMD<25>: length 33.1
  BOTTOM w0.1: U7801.L11 202.73,98.11 202.73,98.99 201.91,99.81 194.47,99.81 194.42,99.75 194.19,99.75
  BOTTOM w0.102: U7000.D20 177.7,89.7 182.68,89.7 182.76,89.62
  BOTTOM w0.14: 194.19,99.75 193.78,99.75 192.08,98.05 192.08,95.31 186.39,89.62 182.76,89.62
FBC_CMD<26>: length 31.1
  BOTTOM w0.1: 194.23,99.22 194.62,99.61 201.78,99.61 202.41,98.98 202.41,98.44 U7801.L10
  BOTTOM w0.102: 182.26,89.28 182.19,89.35 U7000.A20
  BOTTOM w0.104: 194.19,99.22 194.23,99.22
  BOTTOM w0.14: 182.26,89.28 185.71,89.28 185.94,89.05 187.75,89.05 188.46,89.76 189.3,89.76 192.65,93.1 192.65,97.88 193.99,99.22 194.19,99.22
FBC_CMD<27>: length 30.9
  BOTTOM w0.1: U7801.J10 201.1,99.1 200.8,99.4 195.01,99.4 194.29,98.69
  BOTTOM w0.102: U7000.B20 178.9,89.35 179.22,89.02 179.65,89.02 179.71,89.09 181.79,89.09 181.97,88.91 182.95,88.91
  BOTTOM w0.14: 182.95,88.91 185.34,88.91 185.73,88.53 188.87,88.53 193.21,92.87 193.21,97.71 194.19,98.69 194.29,98.69
FBC_CMD<28>: length 32.3
  BOTTOM w0.1: 194.39,98.15 195.44,99.2 200.64,99.2 200.78,99.07 200.78,98.11 U7801.J11
  BOTTOM w0.102: U7000.C20 178.4,89 178.9,89 179.1,88.8 180.52,88.8 180.73,88.59
  BOTTOM w0.14: 194.39,98.15 193.78,97.54 193.78,92.63 189.15,88 185.51,88 184.93,88.59 180.73,88.59
FBC_CMD<29>: length 31.5
  BOTTOM w0.1: 200.13,98.11 200.13,98.54 199.93,98.74 195.36,98.74
  BOTTOM w0.102: 180.54,88.27 180.25,88.56 179.21,88.56 178.95,88.3 178.55,88.3 178.2,87.95 U7000.C18
  BOTTOM w0.136: 200.13,98.11 U7801.H11
  BOTTOM w0.14: 180.54,88.27 184.51,88.27 185.29,87.48 189.43,87.48 194.34,92.4 R7105.1 194.34,97.72 195.36,98.74
FBC_CMD<30>: length 29.9
  BOTTOM w0.1: U7801.K12 201.43,96.81 200.88,96.81 200.78,96.71 200.78,95.3 200.41,94.93
  BOTTOM w0.102: U7000.B18 178.95,87.95 179.3,88.3 179.92,88.3 180.26,87.96
  BOTTOM w0.14: 200.41,94.93 200.29,94.8 196.25,94.8 195.99,94.55 195.99,92.58 195.41,91.99 194.74,91.99 189.71,86.96 185.08,86.96 184.08,87.96 180.26,87.96
FBC_CMD<31>: length 30.7
  BOTTOM w0.1: 202.73,95.64 202.73,97.46 U7801.M11
  BOTTOM w0.102: 202.73,95.64 202.73,94.78 202.14,94.19 201.94,93.99 201.94,93.78 201.58,93.43
  BOTTOM w0.14: 201.58,93.43 199.17,91.02 194.62,91.02 189.95,86.34 185.03,86.34 183.75,87.62 180.11,87.62 179.78,87.95 U7000.A18
FBC_D<0>: length 20.6
  IN1 w0.127: v5(177.71,79.85) 177.71,79.85 178.44,79.12 180.11,79.12 180.55,78.68 181.86,78.68 182.01,78.53 184.41,78.53 185.17,77.77 195.66,77.77 v5(196.23,78.33)
  BOTTOM w0.17: U7800.V4 v5(196.23,78.33)
  BOTTOM w0.184: v5(177.71,79.85) 177.75,79.85 U7000.C6
FBC_D<1>: length 21.9
  IN2 w0.127: v5(194.95,77.06) 194.39,77.62 191.72,77.62 190.65,76.55 182.25,76.55 181.09,77.71 v5(181.09,78.31)
  BOTTOM w0.1: v5(194.95,77.06) 195.58,77.68 196.23,77.68 U7800.V3
  BOTTOM w0.102: U7000.D6 177.71,79.19 179.82,79.19
  BOTTOM w0.184: 179.82,79.19 180.21,79.19 v5(181.09,78.31)
FBC_D<2>: length 19.1
  IN1 w0.075: 196.05,79.31 196.55,79.31 v5(196.88,78.98)
  IN1 w0.127: v5(180.27,79.89) 180.95,79.21 182.41,79.21 182.52,79.32 184.77,79.32 185.53,78.56 194.6,78.56 195.29,79.24 195.98,79.24 196.05,79.31
  BOTTOM w0.17: U7800.U4 v5(196.88,78.98)
  BOTTOM w0.184: v5(180.27,79.89) 180.01,79.62 179.93,79.55 U7000.A6
FBC_D<3>: length 21.9
  IN2 w0.075: v5(197.53,78.33) 197.85,78.66 197.85,79.35
  IN2 w0.127: 197.85,79.35 196.97,80.23 189.76,80.23 188.71,79.18 180.76,79.18 180.47,79.47 179.48,79.47 v5(179.09,79.85)
  BOTTOM w0.17: U7800.U3 v5(197.53,78.33)
  BOTTOM w0.184: v5(179.09,79.85) 179.05,79.85 U7000.B6
FBC_D<4>: length 26.7
  IN1 w0.075: 199.15,76.84 U7800.P4
  IN1 w0.127: 199.15,76.84 199.28,76.71 199.28,75.88 198.66,75.26 198.66,74.82 198.28,74.44 183.94,74.44 181.41,76.97 179.93,76.97 v5(179.1,77.8) ; U7800.P4 v5(199.48,78.98)
  BOTTOM w0.17: U7800.P4 v5(199.48,78.98)
  BOTTOM w0.184: U7000.B4 v5(179.1,77.8)
FBC_D<5>: length 23
  IN1 w0.075: 198.5,76.86 198.5,78.01
  IN1 w0.127: 198.5,76.86 198.55,76.82 198.55,76.13 198.23,75.81 185.24,75.81 183.63,77.42 180.7,77.42 v5(180.6,77.52) ; 198.5,78.01 v5(198.83,78.33)
  BOTTOM w0.17: U7800.P3 v5(198.83,78.33)
  BOTTOM w0.184: v5(180.6,77.52) 180.26,77.86 179.74,77.86 U7000.A4
FBC_D<6>: length 29.4
  IN1 w0.127: v5(180.42,75.89) 180.42,75.63 183.16,72.88 198.89,72.88 200.77,74.76 200.77,77.69 v5(200.13,78.33)
  BOTTOM w0.102: U7000.B3 179.1,77.1 179.7,77.1 180.42,76.38 v5(180.42,75.89)
  BOTTOM w0.17: U7800.N4 v5(200.13,78.33)
FBC_D<7>: length 28.4
  IN1 w0.075: 199.8,76.84 199.8,77.36 v5(199.48,77.68)
  IN1 w0.102: 178.74,77.53 178.74,78.13 v5(178.39,78.49)
  IN1 w0.127: 199.8,76.84 200.03,76.62 200.03,75.54 199.79,75.3 199.79,74.98 198.49,73.68 183.63,73.68 180.8,76.51 179.55,76.51 178.74,77.32 178.74,77.53
  BOTTOM w0.102: U7000.C4 v5(178.39,78.49)
  BOTTOM w0.17: U7800.N3 199.8,78.01 v5(199.48,77.68)
FBC_D<8>: length 21.1
  IN4 w0.127: v5(177.74,81.99) 178.18,81.55 179.31,81.55 179.91,82.15 186.54,82.15 188.45,84.06 193.46,84.06 193.73,84.34 194.47,84.34 v5(194.86,83.95)
  BOTTOM w0.1: v5(194.86,83.95) 195.28,83.53 196.23,83.53 U7800.V11
  BOTTOM w0.184: U7000.D9 177.69,81.99 v5(177.74,81.99)
FBC_D<9>: length 21
  IN4 w0.127: v5(195,84.75) 194.02,85.73 189.46,85.73 186.61,82.88 179.33,82.88 178.4,81.95 v5(178.4,81.95)
  BOTTOM w0.1: U7800.V12 196.23,84.18 195.64,84.18 195.07,84.75 v5(195,84.75)
  BOTTOM w0.184: U7000.C9 178.35,81.95 178.38,81.95 v5(178.4,81.95)
FBC_D<10>: length 23.2
  IN4 w0.123: 196.72,83.37 v5(196.88,83.53)
  IN4 w0.127: 196.72,83.37 194.48,83.37 194.24,83.14 188.19,83.14 186.74,81.68 182.91,81.68 181.96,80.73 178.93,80.73 178.67,81 177.25,81 v5(176.3,81.95)
  BOTTOM w0.17: U7800.U11 v5(196.88,83.53)
  BOTTOM w0.184: v5(176.3,81.95) 176.35,81.95 U7000.E9
FBC_D<11>: length 20.8
  IN2 w0.127: v5(180.12,81.72) 180.69,82.29 187.37,82.29 189.43,84.36 196.32,84.36 196.52,84.56 196.61,84.56 v5(196.88,84.83)
  BOTTOM w0.1: v5(196.88,84.83) 196.88,84.18 U7800.U12
  BOTTOM w0.184: v5(180.12,81.72) 179.7,81.3 179.1,81.3 U7000.B9
FBC_D<12>: length 24.5
  IN4 w0.075: v5(199.48,83.53) 199.15,83.21 199.15,82.65 199.15,82.65
  IN4 w0.127: v5(181.13,79.58) 181.74,78.98 185.36,78.98 187.8,81.42 198.36,81.42 199.15,82.21 199.15,82.65
  BOTTOM w0.102: U7000.B8 179.08,80.62 179.57,80.62 179.62,80.57 179.7,80.49 180.26,80.49
  BOTTOM w0.17: v5(199.48,83.53) U7800.P11
  BOTTOM w0.184: 180.26,80.49 181.13,79.61 v5(181.13,79.58)
FBC_D<13>: length 22.6
  IN4 w0.075: 198.5,82.58 198.5,83.85 v5(198.83,84.18)
  IN4 w0.127: v5(181.78,80.16) 185.87,80.16 187.82,82.11 198.02,82.11 198.5,82.58
  BOTTOM w0.102: U7000.A8 180.98,80.95
  BOTTOM w0.17: v5(198.83,84.18) U7800.P12
  BOTTOM w0.184: 180.98,80.95 v5(181.78,80.16)
FBC_D<14>: length 30.9
  IN4 w0.127: v5(200.78,83.53) 200.78,81.95 198.9,80.07 192.23,80.07 189.49,77.32 181.35,77.32 180.69,77.98 180.69,78.4 180.14,78.96 177.19,78.96 v5(176.28,79.87)
  BOTTOM w0.1: U7800.N11 200.13,83.53 v5(200.78,83.53)
  BOTTOM w0.184: v5(176.28,79.87) 176.27,79.87 U7000.F6
FBC_D<15>: length 29.9
  IN4 w0.075: 199.8,82.59 199.8,83.14
  IN4 w0.127: 199.8,83.14 199.93,83.26 199.93,83.73 199.48,84.18 v5(199.48,84.83) ; v5(176.99,79.86) 177.53,79.32 180.68,79.32 182.06,77.94 184.99,77.94 187.82,80.77 198.52,80.77 199.8,82.06 199.8,82.59
  BOTTOM w0.1: v5(199.48,84.83) 199.48,84.18 U7800.N12
  BOTTOM w0.184: v5(176.99,79.86) 176.96,79.86 U7000.E6
FBC_D<16>: length 43.9
  IN4 w0.102: 175.95,89.27 175.95,88.6 v5(175.6,88.24)
  IN4 w0.127: v5(208.14,83.52) 208.54,83.92 208.54,87.56 203.92,92.18 190.48,92.18 186.45,88.15 180.29,88.15 179.5,88.94 178.32,88.94 177.84,89.42 176.11,89.42 175.95,89.27
  BOTTOM w0.1: v5(208.14,83.52) 207.27,83.52 U7800.B11
  BOTTOM w0.184: U7000.F18 175.66,88.24 v5(175.6,88.24)
FBC_D<17>: length 39.7
  IN4 w0.075: 206.95,85.18 206.95,84.46 207.24,84.18 v5(207.28,84.18)
  IN4 w0.127: 206.95,85.18 206.8,85.34 206.8,87.1 203.15,90.74 190.37,90.74 186.45,86.82 180.12,86.82 179.3,87.64 177.23,87.64 177.06,87.81 175.4,87.81 v5(174.93,88.28)
  BOTTOM w0.17: v5(207.28,84.18) U7800.B12
  BOTTOM w0.184: U7000.G18 174.93,88.27 v5(174.93,88.28)
FBC_D<18>: length 40.3
  IN4 w0.127: v5(176.98,88.26) 177.15,88.26 177.48,87.93 178.23,87.93 178.57,88.27 179.41,88.27 180.19,87.49 186.46,87.49 190.31,91.35 203.46,91.35 207.73,87.08 207.73,84.03 206.62,82.93 206.62,82.89 v5(206.63,82.88)
  BOTTOM w0.17: v5(206.63,82.88) U7800.C11
  BOTTOM w0.184: U7000.E18 176.96,88.26 v5(176.98,88.26)
FBC_D<19>: length 39.7
  IN4 w0.127: v5(174.19,88.26) 175.01,87.44 177.02,87.44 177.17,87.29 178.84,87.29 179.97,86.16 186.45,86.16 190.45,90.16 202.77,90.16 205.91,87.01 205.91,85.45 206.53,84.83 v5(206.63,84.83)
  BOTTOM w0.1: U7800.C12 206.63,84.18 v5(206.63,84.83)
  BOTTOM w0.184: U7000.H18 174.24,88.26 v5(174.19,88.26)
FBC_D<20>: length 35.4
  IN4 w0.075: 205.09,84.23 205,84.31 205,85.14
  IN4 w0.127: 205,85.14 205.12,85.25 205.12,86.94 204.39,87.67 203.75,87.67 202.77,88.65 202.77,88.96 202.15,89.58 196.64,89.58 195.83,89.25 190.2,89.25 186.53,85.57 179.71,85.57 179.07,86.21 178,86.21 v5(177.82,86.39) ; 205.09,84.23 205.09,83.94 v5(204.68,83.53)
  BOTTOM w0.17: v5(204.68,83.53) U7800.F11
  BOTTOM w0.184: v5(177.82,86.39) 177.82,86.32 U7000.D15
FBC_D<21>: length 34.7
  IN4 w0.075: 204.35,85.66 204.35,84.63
  IN4 w0.127: 204.35,85.66 204.28,85.73 204.28,86.45 203.61,87.13 202.75,87.13 200.9,88.97 197.13,88.97 196.69,88.53 190.15,88.53 186.53,84.91 179.61,84.91 178.77,85.75 177.65,85.75 177.4,86 176.68,86 v5(176.38,86.3) ; 204.35,84.63 204.35,84.51 v5(204.03,84.18)
  BOTTOM w0.17: v5(204.03,84.18) U7800.F12
  BOTTOM w0.184: U7000.E15 176.38,86.12 v5(176.38,86.3)
FBC_D<22>: length 36.2
  IN4 w0.075: v5(204.03,82.88) U7800.G11 203.7,85.11
  IN4 w0.127: 203.7,85.11 203.67,85.14 203.67,85.89 202.95,86.62 202.59,86.62 200.87,88.34 197.82,88.34 197.28,87.79 190.08,87.79 186.55,84.26 179.49,84.26 178.48,85.27 177.43,85.27 177.06,85.64 176.48,85.64 175.99,86.13 175.99,86.53 v5(175.59,86.93)
  BOTTOM w0.17: v5(204.03,82.88) U7800.G11
  BOTTOM w0.184: U7000.G17 175.56,86.93 v5(175.59,86.93)
FBC_D<23>: length 36.8
  IN4 w0.127: v5(203.38,83.53) 202.85,84.06 202.85,85.7 200.73,87.81 198.63,87.81 198.2,87.38 198.2,87 197.82,86.61 189.57,86.61 186.6,83.65 179.1,83.65 178.74,84.02 178.74,84.4 178.42,84.72 177.37,84.72 176.81,85.28 175.21,85.28 174.55,85.94 174.55,86.6 v5(174.2,86.95)
  BOTTOM w0.17: U7800.G12 203.7,83.86 v5(203.38,83.53)
  BOTTOM w0.184: v5(174.2,86.95) 174.25,86.95 U7000.H17
FBC_D<24>: length 42.8
  IN1 w0.102: 178.3,85.49 175.66,85.49
  IN1 w0.127: v5(173.49,86.19) 174.43,85.25 175.42,85.25 175.66,85.49 ; v5(207.28,78.98) 207.66,79.37 207.66,80.69 206.61,81.74 203.27,81.74 202.93,82.08 202.93,85.83 201.99,86.77 200.94,86.77 200.78,86.61 190.82,86.61 189.63,85.42 179.29,85.42 179.22,85.49 178.3,85.49
  BOTTOM w0.17: v5(207.28,78.98) U7800.B4
  BOTTOM w0.184: v5(173.49,86.19) 173.51,86.19 U7000.J15
FBC_D<25>: length 47.5
  IN1 w0.102: 174.56,86.5 174.56,87.18
  IN1 w0.127: 174.56,86.5 174.23,86.17 v5(174.17,86.17) ; v5(207.28,77.68) 207.68,77.68 208.55,78.55 208.55,86.21 207.83,86.92 203.13,86.92 201.46,88.59 190.9,88.59 189.02,86.71 178.87,86.71 178.23,87.35 174.73,87.35 174.56,87.18
  BOTTOM w0.17: U7800.B3 207.28,77.68 v5(207.28,77.68)
  BOTTOM w0.184: v5(174.17,86.17) 174.23,86.17 U7000.H15
FBC_D<26>: length 36.3
  IN1 w0.075: v5(206.63,78.33) U7800.C4 206.3,79.23 ; 197.13,84.51 197.78,84.51 ; 198.64,84.51 199.21,84.51
  IN1 w0.102: v5(176.39,84.77) 176.6,84.97 177.15,84.97 177.47,84.65 178.43,84.65
  IN1 w0.127: 178.43,84.65 178.67,84.41 187.51,84.41 188.27,83.65 193.12,83.65 193.8,84.32 196.94,84.32 197.13,84.51 ; 199.21,84.51 200.97,82.75 200.97,81.61 201.27,81.32 202.33,81.32 202.91,80.74 203.78,80.74 204.19,80.32 205.9,80.32 206.33,79.89 206.33,79.25 206.3,79.23 ; 197.78,84.51 197.9,84.63 198.52,84.63 198.64,84.51
  BOTTOM w0.17: v5(206.63,78.33) U7800.C4
  BOTTOM w0.184: U7000.E14 176.39,84.89 v5(176.39,84.77)
FBC_D<27>: length 41.3
  IN1 w0.075: 206.95,79.19 206.95,78
  IN1 w0.102: 177.58,85.05 177.41,85.22 175.97,85.22
  IN1 w0.127: 206.95,79.19 206.82,79.33 206.82,79.71 207.01,79.91 207.01,80.55 206.6,80.97 204.41,80.97 204.13,81.25 203.06,81.25 202.44,81.87 202.44,82.56 201.24,83.76 201.24,85.61 200.79,86.06 190.94,86.06 189.83,84.95 179.02,84.95 178.92,85.05 177.58,85.05 ; v5(175.6,84.85) 175.6,84.85 175.97,85.22 ; 206.95,78 206.63,77.67 v5(206.63,77.03)
  BOTTOM w0.1: U7800.C3 206.63,77.68 v5(206.63,77.03)
  BOTTOM w0.184: U7000.F14 175.65,84.85 v5(175.6,84.85)
FBC_D<28>: length 33.6
  IN1 w0.102: 175.79,83.7 175.81,83.72 178.76,83.72
  IN1 w0.127: v5(203.95,79.69) 203.42,80.23 202.75,80.23 202.13,80.85 201,80.85 199.36,82.48 194.65,82.48 193.99,83.14 187.97,83.14 187.2,83.9 178.95,83.9 178.76,83.72 ; 175.79,83.7 175.19,83.7 v5(174.23,82.73)
  BOTTOM w0.1: U7800.F4 204.04,78.97 204.04,79.6 v5(203.95,79.69)
  BOTTOM w0.184: v5(174.23,82.73) 174.25,82.75 U7000.H11
FBC_D<29>: length 33.9
  IN1 w0.102: 176.11,83.42 178.62,83.42
  IN1 w0.127: v5(175.1,82.19) 175.23,82.32 175.23,82.89 175.6,83.26 175.95,83.26 176.11,83.42 ; v5(204.68,78.33) 204.68,78.33 204.59,78.33 203.54,79.39 202.93,79.39 201.98,80.34 200.51,80.34 198.95,81.89 194.25,81.89 193.58,82.56 187.74,82.56 186.98,83.33 178.71,83.33 178.62,83.42
  BOTTOM w0.102: v5(175.1,82.19) 175.22,82.31 175.22,82.85 175.25,82.88 U7000.G11
  BOTTOM w0.17: U7800.F3 204.68,78.33 v5(204.68,78.33)
FBC_D<30>: length 30.1
  IN1 w0.102: 176.64,83.09 178.45,83.09
  IN1 w0.127: v5(176.29,82.74) 176.64,83.09 ; v5(203.38,78.33) 203.32,78.33 201.78,79.87 200.09,79.87 198.56,81.4 193.57,81.4 193.11,81.86 187.59,81.86 186.82,82.62 178.92,82.62 178.45,83.09
  BOTTOM w0.17: U7800.G4 v5(203.38,78.33)
  BOTTOM w0.184: U7000.F11 176.26,82.74 v5(176.29,82.74)
FBC_D<31>: length 32.8
  IN1 w0.102: v5(176.98,82.72) 177.38,82.32 177.38,81.78 177.58,81.57
  IN1 w0.127: v5(204.03,77.03) 203.64,76.65 203.16,76.65 202.8,77.01 202.8,78.16 202.11,78.85 201.49,78.85 200.98,79.36 199.69,79.36 198.23,80.82 194.12,80.82 194.02,80.72 192.89,80.72 192.24,81.37 187.2,81.37 186.44,82.13 179.95,82.13 179.38,81.57 177.58,81.57
  BOTTOM w0.1: v5(204.03,77.03) 204.03,77.68 U7800.G3
  BOTTOM w0.184: U7000.E11 v5(176.98,82.72)
FBC_D<32>: length 27.1
  IN4 w0.102: 177.36,95.83 175.9,95.83 175.68,96.05 174.91,96.05
  IN4 w0.127: 177.36,95.83 177.6,95.59 179.44,95.59 179.75,95.9 186.25,95.9 192.61,102.26 195.08,102.26 v5(195.37,102.55) ; 174.91,96.05 174.78,95.91 174.07,95.91 v5(173.5,95.35)
  BOTTOM w0.1: v5(195.37,102.55) 195.46,102.64 196.25,102.64 U7801.B4
  BOTTOM w0.184: v5(173.5,95.35) 173.55,95.35 U7000.J29
