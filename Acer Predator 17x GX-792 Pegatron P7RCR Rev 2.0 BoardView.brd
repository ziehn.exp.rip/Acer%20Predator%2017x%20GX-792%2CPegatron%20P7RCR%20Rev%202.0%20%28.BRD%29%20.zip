# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Nets (continued)
IFP_IOVDD: C7204.1 C7205.1 C7220.1 C7221.1 C7223.1 C7230.1 C7235.1 C7301.1 C7302.1 SR7209.2 SR7210.2 SR7211.2 U7000.BB15(IFP_IOVDD_1) U7000.BB17(IFP_IOVDD_2) U7000.BB18(IFP_IOVDD_3) U7000.BB20(IFP_IOVDD_4) U7000.BB21(IFP_IOVDD_5) U7000.BB23(IFP_IOVDD_6) U7000.BC15(IFP_IOVDD_7) U7000.BC17(IFP_IOVDD_8) U7000.BC18(IFP_IOVDD_9) U7000.BC20(IFP_IOVDD_10) U7000.BC21(IFP_IOVDD_11) U7000.BC23(IFP_IOVDD_12)
IFP_PLLVDD: C7225.1 C7226.1 L7202.2 SR7204.1 SR7205.1 SR7206.1
IFPAB_PLLVDD_R: C7202.2 SR7206.2 U7000.BD21(IFPAB_PLLVDD)
IFPAB_RSET: R7204.2 U7000.BD23(IFPAB_RSET)
IFPCD_PLLVDD_R: C7222.1 SR7205.2 U7000.BD18(IFPCD_PLLVDD)
IFPCD_RSET: R7212.2 U7000.BD20(IFPCD_RSET)
IFPCDEF_PLLVDD_R: C7234.1 SR7204.2 U7000.BD15(IFPEF_PLLVDD)
IFPEF_RSET: R7221.2 U7000.BD17(IFPEF_RSET)
ILIM_SEL: R5206.1 R5207.2 U5200.4(ILIM_SEL)
ILIM_SEL_TBT: R1205.2 R1206.1 U1202.4(ILIM_SEL)
IMON_A: C8035.2 R8092.2 U8000.14(IMON_A)
IMON_B: C8014.2 R8029.2 U8000.2(IMON_B)
IMON_C: C8004.1 R8038.1 U8000.28(IMON_C)
IN+1: C9708.2 R9731.2 U9702.12(IN+1)
IN+1_R: R9702.2 R9731.1
IN+2: C9707.1 R9709.2 U9702.15(IN+2)
IN+2_R: R9709.1 R9715.2
IN+3: C9726.1 R9734.2 U9702.2(IN+3)
IN+3_R: R9732.2 R9734.1
IN-1: C9708.1 R9704.2 U9702.11(IN-1)
IN-1_R: R9702.3 R9704.1
IN-2: C9707.2 R9703.2 U9702.14(IN-2)
IN-2_R: R9703.1 R9715.3
IN-3: C9726.2 R9733.2 U9702.1(IN-3)
IN-3_R: R9732.3 R9733.1
INT_SERIRQ: R3013.2 SR2207.1 U3002.5(SERIRQ/GPM6) U6200.27(SERIRQ)
ISEN1_A: C8017.2 R8006.2 R80125.1 U8000.21(ISEN1_A)
ISEN1_B: C8029.1 R80103.2 R80140.1 U8000.9(ISEN1_B)
ISEN2_A: C8019.2 R8007.2 R80130.1 U8000.22(ISEN2_A)
ISEN2_B: C8030.1 R8091.2 R80145.1 U8000.10(ISEN2_B)
ISEN3_A: C8011.2 R8034.2 R80135.1 U8000.23(ISEN3_A)
ISH_I2C0_SCL: R2417.2 U2000.BC38(GPP_H20/ISH_I2C0_SCL)
ISH_I2C0_SDA: R2416.2 U2000.BB38(GPP_H19/ISH_I2C0_SDA)
ISH_I2C1_SCL: R2415.2 U2000.BD38(GPP_H22/ISH_I2C1_SCL)
ISH_I2C1_SDA: R2414.2 U2000.BE39(GPP_H21/ISH_I2C1_SDA)
ISUMN_A: C8018.1 R8008.2 R8098.1 U8000.20(ISUMN_A)
ISUMN_A_R: C8011.1 C8017.1 C8019.1 C8020.2 C8026.1 R8057.1 R8059.1 R8061.1 R8082.1 R8083.1 R8098.2 R80102.2 SR8018.2
ISUMN_B: C8034.1 R8045.2 SR8017.2 U8000.8(ISUMN_B)
ISUMN_B_R: C8027.2 C8028.1 C8029.2 C8030.2 R8040.2 R8043.1 R8044.2 R8045.1 R8064.1 R8066.1 R8088.2
ISUMN_C: C80106.1 R8032.2 R8035.1 U8000.33(ISUMN_C)
ISUMN_C_R: C80104.2 C80105.1 R8025.1 R8026.1 R8035.2 R8036.2 SR8016.1 SR8019.2
ISUMP_A: C8026.2 C80109.2 C80133.2 R8056.1 R8058.1 R8060.1 R8083.2 R80101.2 U8000.19(ISUMP_A)
ISUMP_B: C8027.1 C8036.1 C80110.1 R8044.1 R8062.1 R8063.1 R8094.1 U8000.7(ISUMP_B)
ISUMP_C: C80103.2 C80105.2 C80111.2 R8024.2 R8025.2 R8067.1 U8000.32(ISUMP_C)
ITP_PMODE: SR4406.2 U2000.AT2(ITP_PMODE)
JD_PCH: SR2410.2 U3600.48(SPDIF-OUT/GPIO2)
JTAG_TCLK: T7406.1 U7000.BK24(JTAG_TCK)
JTAG_TDI: T7408.1 U7000.BM23(JTAG_TDI)
JTAG_TDO: T7409.1 U7000.BM24(JTAG_TDO)
JTAG_TMS: T7407.1 U7000.BL23(JTAG_TMS)
JTAG_TRST#: R7470.2 T7410.1 U7000.BL24(JTAG_TRST_N)
KBL_A_0: R3141.2 R3142.1 U3102.2(A0)
KBL_A_1: R3143.2 R3144.1 U3102.3(A1)
KBL_A_2: R3145.2 R3146.1 U3102.4(A2)
KBL_A_3: R3147.2 R3148.1 U3102.5(A3)
KBL_B_1: CON3110.5 U3102.8(OUT2#)
KBL_B_2: CON3110.8 U3102.13(OUT6#)
KBL_B_3: CON3110.11 U3102.17(OUT10#)
KBL_B_4: CON3110.14 U3102.22(OUT14#)
KBL_G_1: CON3110.4 U3102.7(OUT1#)
KBL_G_2: CON3110.7 U3102.12(OUT5#)
KBL_G_3: CON3110.10 U3102.16(OUT9#)
KBL_G_4: CON3110.13 U3102.21(OUT13#)
KBL_R_1: CON3110.3 U3102.6(OUT0#)
KBL_R_2: CON3110.6 U3102.11(OUT4#)
KBL_R_3: CON3110.9 U3102.15(OUT8#)
KBL_R_4: CON3110.12 U3102.20(OUT12#)
KBL_RESET#_R: R3137.1 R3172.1 U3102.25(RESET#)
KSI0: CN5.1(X) CON3100.19 U3002.58(KSI0/STB#)
KSI1: CN5.3(X) CON3100.20 U3002.59(KSI1/AFD#)
KSI2: CN5.5(X) CON3100.21 U3002.60(KSI2/INIT#)
KSI3: CN5.7(X) CON3100.22 U3002.61(KSI3/SLIN#)
KSI4: CN6.1(X) CON3100.23 U3002.62(KSI4)
KSI5: CN6.3(X) CON3100.24 U3002.63(KSI5)
KSI6: CN6.5(X) CON3100.25 U3002.64(KSI6)
KSI7: CN6.7(X) CON3100.26 U3002.65(KSI7)
KSO0: CN1.1(X) CON3100.1 U3002.36(KSO0/PD0)
KSO1: CN1.3(X) CON3100.2 U3002.37(KSO1/PD1)
KSO2: CN1.5(X) CON3100.3 U3002.38(KSO2/PD2)
KSO3: CN1.7(X) CON3100.4 U3002.39(KSO3/PD3)
KSO4: CN2.1(X) CON3100.5 U3002.40(KSO4/PD4)
KSO5: CN2.3(X) CON3100.6 U3002.41(KSO5/PD5)
KSO6: CN2.5(X) CON3100.7 U3002.42(KSO6/PD6)
KSO7: CN2.7(X) CON3100.8 U3002.43(KSO7/PD7)
KSO8: CN3.1(X) CON3100.9 U3002.44(KSO8/ACK#)
KSO9: CN3.3(X) CON3100.10 U3002.45(KSO9/BUSY)
KSO10: CN3.5(X) CON3100.11 U3002.46(KSO10/PE)
KSO11: CN3.7(X) CON3100.12 U3002.51(KSO11/ERR#)
KSO12: CN4.1(X) CON3100.13 U3002.52(KSO12/SLCT)
KSO13: CN4.3(X) CON3100.14 U3002.53(KSO13)
KSO14: CN4.5(X) CON3100.15 U3002.54(KSO14)
KSO15: CN4.7(X) CON3100.16 U3002.55(KSO15)
KSO16: CN7.1(X) CON3100.17 U3002.56(KSO16/SMOSI/GPC3)
KSO17: CN7.3(X) CON3100.18 U3002.57(KSO17/SMISO/GPC5)
L1+: CON5500.3(D+) D5502.1(ANODE) L5501.2 RN5501.4(Y)
L1-: CON5500.2(D-) D5501.1(ANODE) L5501.3 RN5501.2(Y)
L2+: CON5501.3(D+) D5504.1(ANODE) L5504.2 RN5504.4(Y)
L2-: CON5501.2(D-) D5503.1(ANODE) L5504.3 RN5504.2(Y)
LAD0_ESPI_IO0: SR2202.2 U2000.AT22(GPP_A1/LAD0/ESPI_IO0)
LAD0_ESPI_IO1: SR2203.2 U2000.AV22(GPP_A2/LAD1/ESPI_IO1)
LAD0_ESPI_IO2: SR2204.2 U2000.AT19(GPP_A3/LAD2/ESPI_IO2)
LAD0_ESPI_IO3: SR2205.2 U2000.BD16(GPP_A4/LAD3/ESPI_IO3)
LAN_CLKREQ#: R2432.2 SR3302.1 U2000.BB31(GPP_H4/SRCCLKREQ10#)
LAN_GND: C3401.2 C3402.2 C3403.2 C3404.2 CON3400.9(P_GND2) CON3400.10(P_GND1) D3400.2(CATHODE) R3404.2
LAN_MDI0_N: U3300.12(TRXN0) U3401.3(TD1-)
LAN_MDI0_N_C: CON3400.2 L3403.3 RN3403.2(Y)
LAN_MDI0_N_L: L3403.4 RN3403.1(X) U3401.22(MX1-)
LAN_MDI0_P: U3300.11(TRXP0) U3401.2(TD1+)
LAN_MDI0_P_C: CON3400.1 L3403.2 RN3403.4(Y)
LAN_MDI0_P_L: L3403.1 RN3403.3(X) U3401.23(MX1+)
LAN_MDI1_N: U3300.15(TRXN1) U3401.6(TD2-)
LAN_MDI1_N_C: CON3400.6 L3402.3 RN3402.2(Y)
LAN_MDI1_N_L: L3402.4 RN3402.1(X) U3401.19(MX2-)
LAN_MDI1_P: U3300.14(TRXP1) U3401.5(TD2+)
LAN_MDI1_P_C: CON3400.3 L3402.2 RN3402.4(Y)
LAN_MDI1_P_L: L3402.1 RN3402.3(X) U3401.20(MX2+)
LAN_MDI2_N: U3300.18(TRXN2) U3401.9(TD3-)
LAN_MDI2_N_C: CON3400.5 L3401.3 RN3401.2(Y)
LAN_MDI2_N_L: L3401.4 RN3401.1(X) U3401.16(MX3-)
LAN_MDI2_P: U3300.17(TRXP2) U3401.8(TD3+)
LAN_MDI2_P_C: CON3400.4 L3401.2 RN3401.4(Y)
LAN_MDI2_P_L: L3401.1 RN3401.3(X) U3401.17(MX3+)
LAN_MDI3_N: U3300.21(TRXN3) U3401.12(TD4-)
LAN_MDI3_N_C: CON3400.8 L3400.3 RN3400.2(Y)
LAN_MDI3_N_L: L3400.4 RN3400.1(X) U3401.13(MX4-)
LAN_MDI3_P: U3300.20(TRXP3) U3401.11(TD4+)
LAN_MDI3_P_C: CON3400.7 L3400.2 RN3400.4(Y)
LAN_MDI3_P_L: L3400.1 RN3400.3(X) U3401.14(MX4+)
LAN_RXN: C3314.2 U2000.E20(PCIE4_RXN/USB3_10_RXN)
LAN_RXN_C: C3314.1 U3300.29(TX_N)
LAN_RXP: C3313.2 U2000.G19(PCIE4_RXP/USB3_10_RXP)
LAN_RXP_C: C3313.1 U3300.30(TX_P)
LAN_TXN: C2013.1 U3300.36(RX_N)
LAN_TXP: C2012.1 U3300.35(RX_P)
LCD_BKLTEN_EC: D4503.2(CATHODE) R4593.2 U3002.118(SMDAT2/PECIRQT#/GPF7)
LCD_BLEN: D4502.1(CATHODE1) R4518.2 U7408.3(D)
LCD_VCC_EN: SR4506.1 U7407.3(D)
LFRAME#_ESPI_CS0#: SR2206.2 U2000.BE16(GPP_A5/LFRAME#/ESPI_CS0#)
LG_C: Q8001.4(G) U8005.5(LGATE)
LGF_LED_ON: Q4501.1(GATE) SR3018.2
LGF_LED_ON#: CON4500.36 Q4501.3(DRAIN)
LID_SW#: CON5602.25 D4502.2(CATHODE2) R4592.2 U3002.17(LPCPD#/GPE6)
LINE1_JD#: CON6700.22 R3624.2
LINE1_L: C3639.2 L6701.1 R6737.2
LINE1_R: C3640.2 L6700.1 R6738.2
LINE1_VREFO_L: R6737.1 U3600.31(LINE1-VREFO-L)
LINE1_VREFO_R: R6738.1 U3600.30(LINE1-VREFO-R)
LP9+: CON4500.32 L4500.3 RN4500.2(Y) U4501.3(I/O2)
LP9-: CON4500.33 L4500.2 RN4500.4(Y) U4501.4(I/O3)
LPC_AD0: CON4400.11 SR2202.1 SR3007.1 U6200.26(LAD0/MISO)
LPC_AD0_EC: SR3007.2 U3002.10(LAD0/GPM0)
LPC_AD1: CON4400.9 SR2203.1 SR3006.1 U6200.23(LAD1/MOSI)
LPC_AD1_EC: SR3006.2 U3002.9(LAD1/GPM1)
LPC_AD2: CON4400.7 SR2204.1 SR3005.1 U6200.20(LAD2/SPI_IRQ#)
LPC_AD2_EC: SR3005.2 U3002.8(LAD2/GPM2)
LPC_AD3: CON4400.5 SR2205.1 SR3009.1 U6200.17(LAD3)
LPC_AD3_EC: SR3009.2 U3002.7(LAD3/GPM3)
LPC_FRAME#: CON4400.3 SR2206.1 SR3008.1 U6200.22(LFRAME#/SCS#)
LPC_FRAME#_EC: SR3008.2 U3002.6(LFRAME#/GPM5)
LPCPD#: SR2209.1 U6200.28(LPCPD#)
M2_SSD_PEDET: CON5102.69 R2105.2 R2110.1 R5115.2 U2000.AG36(GPP_E0/SATAXPCIE0/SATAGP0)
M_CHA_ACT#: CON1600.114(ACT_N) CON1601.114(ACT_N) U0300.AU3(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
M_CHA_ALERT#: CON1600.116(ALERT_N) CON1601.116(ALERT_N) U0300.AU5(DDR0_ALERT#)
M_CHA_BA0: CON1600.150(BA0) CON1601.150(BA0) U0300.AH5(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
M_CHA_BA1: CON1600.145(BA1) CON1601.145(BA1) U0300.AH1(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
M_CHA_BG0: CON1600.115(BG0) CON1601.115(BG0) U0300.AU1(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
M_CHA_BG1: CON1600.113(BG1) CON1601.113(BG1) U0300.AU2(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
M_CHA_CKE0: CON1600.109(CKE0) U0300.AT1(DDR0_CKE[0])
M_CHA_CKE1: CON1600.110(CKE1) U0300.AT2(DDR0_CKE[1])
M_CHA_CKE2: CON1601.109(CKE0) U0300.AT3(DDR0_CKE[2])
M_CHA_CKE3: CON1601.110(CKE1) U0300.AT5(DDR0_CKE[3])
M_CHA_CLK0: CON1600.137(CK0_T) U0300.AG1(DDR0_CKP[0])
M_CHA_CLK0#: CON1600.139(CK0_C) U0300.AG2(DDR0_CKN[0])
M_CHA_CLK1: CON1600.138(CK1_T/NF) U0300.AK2(DDR0_CKP[1])
M_CHA_CLK1#: CON1600.140(CK1_C/NF) U0300.AK1(DDR0_CKN[1])
M_CHA_CLK2: CON1601.137(CK0_T) U0300.AL3(DDR0_CLKP[2])
M_CHA_CLK2#: CON1601.139(CK0_C) U0300.AK3(DDR0_CLKN[2])
M_CHA_CLK3: CON1601.138(CK1_T/NF) U0300.AL2(DDR0_CLKP[3])
M_CHA_CLK3#: CON1601.140(CK1_C/NF) U0300.AL1(DDR0_CLKN[3])
M_CHA_CS#0: CON1600.149(CS0_N) U0300.AD5(DDR0_CS#[0])
M_CHA_CS#1: CON1600.157(CS1_N) U0300.AE2(DDR0_CS#[1])
M_CHA_CS#2: CON1601.149(CS0_N) U0300.AD2(DDR0_CS#[2])
M_CHA_CS#3: CON1601.157(CS1_N) U0300.AE5(DDR0_CS#[3])
M_CHA_DQ0: CON1600.8(DQ0) CON1601.7(DQ1) U0300.BR6(DDR0_DQ[0])
M_CHA_DQ1: CON1600.7(DQ1) CON1601.8(DQ0) U0300.BT6(DDR0_DQ[1])
M_CHA_DQ2: CON1600.17(DQ7) CON1601.16(DQ6) U0300.BP3(DDR0_DQ[2])
M_CHA_DQ3: CON1600.20(DQ2) CON1601.21(DQ3) U0300.BR3(DDR0_DQ[3])
M_CHA_DQ4: CON1600.3(DQ5) CON1601.4(DQ4) U0300.BN5(DDR0_DQ[4])
M_CHA_DQ5: CON1600.4(DQ4) CON1601.3(DQ5) U0300.BP6(DDR0_DQ[5])
M_CHA_DQ6: CON1600.21(DQ3) CON1601.20(DQ2) U0300.BP2(DDR0_DQ[6])
M_CHA_DQ7: CON1600.16(DQ6) CON1601.17(DQ7) U0300.BN3(DDR0_DQ[7])
M_CHA_DQ8: CON1600.24(DQ12) CON1601.25(DQ13) U0300.BL4(DDR0_DQ[8])
M_CHA_DQ9: CON1600.28(DQ8) CON1601.29(DQ9) U0300.BL5(DDR0_DQ[9])
M_CHA_DQ10: CON1600.37(DQ15) CON1601.38(DQ14) U0300.BL2(DDR0_DQ[10])
M_CHA_DQ11: CON1600.41(DQ10) CON1601.42(DQ11) U0300.BM1(DDR0_DQ[11])
M_CHA_DQ12: CON1600.29(DQ9) CON1601.28(DQ8) U0300.BK4(DDR0_DQ[12])
M_CHA_DQ13: CON1600.25(DQ13) CON1601.24(DQ12) U0300.BK5(DDR0_DQ[13])
M_CHA_DQ14: CON1600.42(DQ11) CON1601.41(DQ10) U0300.BK1(DDR0_DQ[14])
M_CHA_DQ15: CON1600.38(DQ14) CON1601.37(DQ15) U0300.BK2(DDR0_DQ[15])
M_CHA_DQ16: CON1600.45(DQ21) CON1601.46(DQ20) U0300.BG4(DDR0_DQ[16]/DDR0_DQ[32])
M_CHA_DQ17: CON1600.49(DQ17) CON1601.50(DQ16) U0300.BG5(DDR0_DQ[17]/DDR0_DQ[33])
M_CHA_DQ18: CON1600.50(DQ16) CON1601.49(DQ17) U0300.BF4(DDR0_DQ[18]/DDR0_DQ[34])
M_CHA_DQ19: CON1600.46(DQ20) CON1601.45(DQ21) U0300.BF5(DDR0_DQ[19]/DDR0_DQ[35])
M_CHA_DQ20: CON1600.58(DQ22) CON1601.59(DQ23) U0300.BG2(DDR0_DQ[20]/DDR0_DQ[36])
M_CHA_DQ21: CON1600.62(DQ18) CON1601.63(DQ19) U0300.BG1(DDR0_DQ[21]/DDR0_DQ[37])
M_CHA_DQ22: CON1600.59(DQ23) CON1601.58(DQ22) U0300.BF1(DDR0_DQ[22]/DDR0_DQ[38])
M_CHA_DQ23: CON1600.63(DQ19) CON1601.62(DQ18) U0300.BF2(DDR0_DQ[23]/DDR0_DQ[39])
M_CHA_DQ24: CON1600.67(DQ29) CON1601.66(DQ28) U0300.BD2(DDR0_DQ[24]/DDR0_DQ[40])
M_CHA_DQ25: CON1600.71(DQ25) CON1601.70(DQ24) U0300.BD1(DDR0_DQ[25]/DDR0_DQ[41])
M_CHA_DQ26: CON1600.84(DQ27) CON1601.83(DQ26) U0300.BC4(DDR0_DQ[26]/DDR0_DQ[42])
M_CHA_DQ27: CON1600.80(DQ31) CON1601.79(DQ30) U0300.BC5(DDR0_DQ[27]/DDR0_DQ[43])
M_CHA_DQ28: CON1600.66(DQ28) CON1601.67(DQ29) U0300.BD5(DDR0_DQ[28]/DDR0_DQ[44])
M_CHA_DQ29: CON1600.70(DQ24) CON1601.71(DQ25) U0300.BD4(DDR0_DQ[29]/DDR0_DQ[45])
M_CHA_DQ30: CON1600.79(DQ30) CON1601.80(DQ31) U0300.BC1(DDR0_DQ[30]/DDR0_DQ[46])
M_CHA_DQ31: CON1600.83(DQ26) CON1601.84(DQ27) U0300.BC2(DDR0_DQ[31]/DDR0_DQ[47])
M_CHA_DQ32: CON1600.187(DQ34) CON1601.182(DQ39) U0300.AB1(DDR0_DQ[32]/DDR1_DQ[0])
M_CHA_DQ33: CON1600.183(DQ38) CON1601.186(DQ35) U0300.AB2(DDR0_DQ[33]/DDR1_DQ[1])
M_CHA_DQ34: CON1600.169(DQ37) CON1601.174(DQ32) U0300.AA4(DDR0_DQ[34]/DDR1_DQ[2])
M_CHA_DQ35: CON1600.173(DQ33) CON1601.170(DQ36) U0300.AA5(DDR0_DQ[35]/DDR1_DQ[3])
M_CHA_DQ36: CON1600.174(DQ32) CON1601.169(DQ37) U0300.AB5(DDR0_DQ[36]/DDR1_DQ[4])
M_CHA_DQ37: CON1600.170(DQ36) CON1601.173(DQ33) U0300.AB4(DDR0_DQ[37]/DDR1_DQ[5])
M_CHA_DQ38: CON1600.182(DQ39) CON1601.187(DQ34) U0300.AA2(DDR0_DQ[38]/DDR1_DQ[6])
M_CHA_DQ39: CON1600.186(DQ35) CON1601.183(DQ38) U0300.AA1(DDR0_DQ[39]/DDR1_DQ[7])
M_CHA_DQ40: CON1600.190(DQ45) CON1601.195(DQ40) U0300.V5(DDR0_DQ[40]/DDR1_DQ[8])
M_CHA_DQ41: CON1600.208(DQ43) CON1601.207(DQ42) U0300.V2(DDR0_DQ[41]/DDR1_DQ[9])
M_CHA_DQ42: CON1600.191(DQ44) CON1601.194(DQ41) U0300.U1(DDR0_DQ[42]/DDR1_DQ[10])
M_CHA_DQ43: CON1600.207(DQ42) CON1601.208(DQ43) U0300.U2(DDR0_DQ[43]/DDR1_DQ[11])
M_CHA_DQ44: CON1600.204(DQ47) CON1601.203(DQ46) U0300.V1(DDR0_DQ[44]/DDR1_DQ[12])
M_CHA_DQ45: CON1600.194(DQ41) CON1601.191(DQ44) U0300.V4(DDR0_DQ[45]/DDR1_DQ[13])
M_CHA_DQ46: CON1600.195(DQ40) CON1601.190(DQ45) U0300.U5(DDR0_DQ[46]/DDR1_DQ[14])
M_CHA_DQ47: CON1600.203(DQ46) CON1601.204(DQ47) U0300.U4(DDR0_DQ[47]/DDR1_DQ[15])
M_CHA_DQ48: CON1600.228(DQ50) CON1601.229(DQ51) U0300.R2(DDR0_DQ[48]/DDR1_DQ[32])
M_CHA_DQ49: CON1600.216(DQ48) CON1601.215(DQ49) U0300.P5(DDR0_DQ[49]/DDR1_DQ[33])
M_CHA_DQ50: CON1600.212(DQ53) CON1601.211(DQ52) U0300.R4(DDR0_DQ[50]/DDR1_DQ[34])
M_CHA_DQ51: CON1600.215(DQ49) CON1601.216(DQ48) U0300.P4(DDR0_DQ[51]/DDR1_DQ[35])
M_CHA_DQ52: CON1600.225(DQ55) CON1601.228(DQ50) U0300.R5(DDR0_DQ[52]/DDR1_DQ[36])
M_CHA_DQ53: CON1600.229(DQ51) CON1601.224(DQ54) U0300.P2(DDR0_DQ[53]/DDR1_DQ[37])
M_CHA_DQ54: CON1600.211(DQ52) CON1601.212(DQ53) U0300.R1(DDR0_DQ[54]/DDR1_DQ[38])
M_CHA_DQ55: CON1600.224(DQ54) CON1601.225(DQ55) U0300.P1(DDR0_DQ[55]/DDR1_DQ[39])
M_CHA_DQ56: CON1600.232(DQ60) CON1601.233(DQ61) U0300.M4(DDR0_DQ[56]/DDR1_DQ[40])
M_CHA_DQ57: CON1600.233(DQ61) CON1601.236(DQ57) U0300.M1(DDR0_DQ[57]/DDR1_DQ[41])
M_CHA_DQ58: CON1600.249(DQ58) CON1601.246(DQ63) U0300.L4(DDR0_DQ[58]/DDR1_DQ[42])
M_CHA_DQ59: CON1600.250(DQ59) CON1601.249(DQ58) U0300.L2(DDR0_DQ[59]/DDR1_DQ[43])
M_CHA_DQ60: CON1600.236(DQ57) CON1601.237(DQ56) U0300.M5(DDR0_DQ[60]/DDR1_DQ[44])
M_CHA_DQ61: CON1600.237(DQ56) CON1601.232(DQ60) U0300.M2(DDR0_DQ[61]/DDR1_DQ[45])
M_CHA_DQ62: CON1600.245(DQ62) CON1601.250(DQ59) U0300.L5(DDR0_DQ[62]/DDR1_DQ[46])
M_CHA_DQ63: CON1600.246(DQ63) CON1601.245(DQ62) U0300.L1(DDR0_DQ[63]/DDR1_DQ[47])
M_CHA_DQS0: CON1600.13(DQS0_T) CON1601.13(DQS0_T) U0300.BP5(DDR0_DQSP[0])
M_CHA_DQS0#: CON1600.11(DQS0_C) CON1601.11(DQS0_C) U0300.BR5(DDR0_DQSN[0])
M_CHA_DQS1: CON1600.34(DQS1_T) CON1601.34(DQS1_T) U0300.BK3(DDR0_DQSP[1])
M_CHA_DQS1#: CON1600.32(DQS1_C) CON1601.32(DQS1_C) U0300.BL3(DDR0_DQSN[1])
M_CHA_DQS2: CON1600.55(DQS2_T) CON1601.55(DQS2_T) U0300.BF3(DDR0_DQSP[2]/DDR0_DQSP[4])
M_CHA_DQS2#: CON1600.53(DQS2_C) CON1601.53(DQS2_C) U0300.BG3(DDR0_DQSN[2]/DDR0_DQSN[4])
M_CHA_DQS3: CON1600.76(DQS3_T) CON1601.76(DQS3_T) U0300.BC3(DDR0_DQSP[3]/DDR0_DQSP[5])
M_CHA_DQS3#: CON1600.74(DQS3_C) CON1601.74(DQS3_C) U0300.BD3(DDR0_DQSN[3]/DDR0_DQSN[5])
M_CHA_DQS4: CON1600.179(DQS4_T) CON1601.179(DQS4_T) U0300.AB3(DDR0_DQSP[4]/DDR1_DQSP[0])
M_CHA_DQS4#: CON1600.177(DQS4_C) CON1601.177(DQS4_C) U0300.AA3(DDR0_DQSN[4]/DDR1_DQSN[0])
M_CHA_DQS5: CON1600.200(DQS5_T) CON1601.200(DQS5_T) U0300.V3(DDR0_DQSP[5]/DDR1_DQSP[1])
M_CHA_DQS5#: CON1600.198(DQS5_C) CON1601.198(DQS5_C) U0300.U3(DDR0_DQSN[5]/DDR1_DQSN[1])
M_CHA_DQS6: CON1600.221(DQS6_T) CON1601.221(DQS6_T) U0300.R3(DDR0_DQSP[6]/DDR1_DQSP[4])
M_CHA_DQS6#: CON1600.219(DQS6_C) CON1601.219(DQS6_C) U0300.P3(DDR0_DQSN[6]/DDR1_DQSN[4])
M_CHA_DQS7: CON1600.242(DQS7_T) CON1601.242(DQS7_T) U0300.M3(DDR0_DQSP[7]/DDR1_DQSP[5])
M_CHA_DQS7#: CON1600.240(DQS7_C) CON1601.240(DQS7_C) U0300.L3(DDR0_DQSN[7]/DDR1_DQSN[5])
M_CHA_MAA0: CON1600.144(A0) CON1601.144(A0) U0300.AH3(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
M_CHA_MAA1: CON1600.133(A1) CON1601.133(A1) U0300.AP4(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
M_CHA_MAA2: CON1600.132(A2) CON1601.132(A2) U0300.AN4(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
M_CHA_MAA3: CON1600.131(A3) CON1601.131(A3) U0300.AP5(DDR0_MA[3])
M_CHA_MAA4: CON1600.128(A4) CON1601.128(A4) U0300.AP2(DDR0_MA[4])
M_CHA_MAA5: CON1600.126(A5) CON1601.126(A5) U0300.AP1(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
M_CHA_MAA6: CON1600.127(A6) CON1601.127(A6) U0300.AP3(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
M_CHA_MAA7: CON1600.122(A7) CON1601.122(A7) U0300.AN1(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
M_CHA_MAA8: CON1600.125(A8) CON1601.125(A8) U0300.AN3(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
M_CHA_MAA9: CON1600.121(A9) CON1601.121(A9) U0300.AT4(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
M_CHA_MAA10: CON1600.146(A10/AP) CON1601.146(A10/AP) U0300.AH2(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
M_CHA_MAA11: CON1600.120(A11) CON1601.120(A11) U0300.AN2(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
M_CHA_MAA12: CON1600.119(A12) CON1601.119(A12) U0300.AU4(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
M_CHA_MAA13: CON1600.158(A13) CON1601.158(A13) U0300.AE3(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
M_CHA_MAA14: CON1600.151(WE_N/A14) CON1601.151(WE_N/A14) U0300.AG4(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
M_CHA_MAA15: CON1600.156(CAS_N/A15) CON1601.156(CAS_N/A15) U0300.AD1(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
M_CHA_MAA16: CON1600.152(RAS_N/A16) CON1601.152(RAS_N/A16) U0300.AH4(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
M_CHA_ODT0: CON1600.155(ODT0) U0300.AD3(DDR0_ODT[0])
M_CHA_ODT1: CON1600.161(ODT1) U0300.AE4(DDR0_ODT[1])
M_CHA_ODT2: CON1601.155(ODT0) U0300.AE1(DDR0_ODT[2])
M_CHA_ODT3: CON1601.161(ODT1) U0300.AD4(DDR0_ODT[3])
M_CHA_PAR: CON1600.143(PARITY) CON1601.143(PARITY) U0300.AG3(DDR0_PAR)
M_CHB_ACT#: CON1700.114(ACT_N) CON1701.114(ACT_N) U0300.AT9(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
M_CHB_ALERT#: CON1700.116(ALERT_N) CON1701.116(ALERT_N) U0300.AR8(DDR1_ALERT#)
M_CHB_BA0: CON1700.150(BA0) CON1701.150(BA0) U0300.AH8(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
M_CHB_BA1: CON1700.145(BA1) CON1701.145(BA1) U0300.AH9(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
M_CHB_BG0: CON1700.115(BG0) CON1701.115(BG0) U0300.AR9(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
M_CHB_BG1: CON1700.113(BG1) CON1701.113(BG1) U0300.AR7(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
M_CHB_CKE0: CON1700.109(CKE0) U0300.AT8(DDR1_CKE[0])
M_CHB_CKE1: CON1700.110(CKE1) U0300.AT10(DDR1_CKE[1])
M_CHB_CKE2: CON1701.109(CKE0) U0300.AT7(DDR1_CKE[2])
M_CHB_CKE3: CON1701.110(CKE1) U0300.AT11(DDR1_CKE[3])
M_CHB_CLK0: CON1700.137(CK0_T) U0300.AM9(DDR1_CKP[0])
M_CHB_CLK0#: CON1700.139(CK0_C) U0300.AN9(DDR1_CKN[0])
M_CHB_CLK1: CON1700.138(CK1_T/NF) U0300.AM7(DDR1_CKP[1])
M_CHB_CLK1#: CON1700.140(CK1_C/NF) U0300.AM8(DDR1_CKN[1])
M_CHB_CLK2: CON1701.137(CK0_T) U0300.AM11(DDR1_CLKP[2])
M_CHB_CLK2#: CON1701.139(CK0_C) U0300.AM10(DDR1_CLKN[2])
M_CHB_CLK3: CON1701.138(CK1_T/NF) U0300.AJ10(DDR1_CLKP[3])
M_CHB_CLK3#: CON1701.140(CK1_C/NF) U0300.AJ11(DDR1_CLKN[3])
M_CHB_CS#0: CON1700.149(CS0_N) U0300.AF11(DDR1_CS#[0])
M_CHB_CS#1: CON1700.157(CS1_N) U0300.AE7(DDR1_CS#[1])
M_CHB_CS#2: CON1701.149(CS0_N) U0300.AF10(DDR1_CS#[2])
M_CHB_CS#3: CON1701.157(CS1_N) U0300.AE10(DDR1_CS#[3])
M_CHB_DQ0: CON1700.3(DQ5) CON1701.8(DQ0) U0300.BT11(DDR1_DQ[0]/DDR0_DQ[16])
M_CHB_DQ1: CON1700.7(DQ1) CON1701.4(DQ4) U0300.BR11(DDR1_DQ[1]/DDR0_DQ[17])
M_CHB_DQ2: CON1700.21(DQ3) CON1701.16(DQ6) U0300.BT8(DDR1_DQ[2]/DDR0_DQ[18])
M_CHB_DQ3: CON1700.17(DQ7) CON1701.20(DQ2) U0300.BR8(DDR1_DQ[3]/DDR0_DQ[19])
M_CHB_DQ4: CON1700.4(DQ4) CON1701.7(DQ1) U0300.BP11(DDR1_DQ[4]/DDR0_DQ[20])
M_CHB_DQ5: CON1700.8(DQ0) CON1701.3(DQ5) U0300.BN11(DDR1_DQ[5]/DDR0_DQ[21])
M_CHB_DQ6: CON1700.16(DQ6) CON1701.21(DQ3) U0300.BP8(DDR1_DQ[6]/DDR0_DQ[22])
M_CHB_DQ7: CON1700.20(DQ2) CON1701.17(DQ7) U0300.BN8(DDR1_DQ[7]/DDR0_DQ[23])
M_CHB_DQ8: CON1700.28(DQ8) CON1701.25(DQ13) U0300.BL12(DDR1_DQ[8]/DDR0_DQ[24])
M_CHB_DQ9: CON1700.24(DQ12) CON1701.29(DQ9) U0300.BL11(DDR1_DQ[9]/DDR0_DQ[25])
M_CHB_DQ10: CON1700.29(DQ9) CON1701.24(DQ12) U0300.BL8(DDR1_DQ[10]/DDR0_DQ[26])
M_CHB_DQ11: CON1700.41(DQ10) CON1701.38(DQ14) U0300.BJ8(DDR1_DQ[11]/DDR0_DQ[27])
M_CHB_DQ12: CON1700.42(DQ11) CON1701.41(DQ10) U0300.BJ11(DDR1_DQ[12]/DDR0_DQ[28])
M_CHB_DQ13: CON1700.38(DQ14) CON1701.37(DQ15) U0300.BJ10(DDR1_DQ[13]/DDR0_DQ[29])
M_CHB_DQ14: CON1700.25(DQ13) CON1701.28(DQ8) U0300.BL7(DDR1_DQ[14]/DDR0_DQ[30])
M_CHB_DQ15: CON1700.37(DQ15) CON1701.42(DQ11) U0300.BJ7(DDR1_DQ[15]/DDR0_DQ[31])
M_CHB_DQ16: CON1700.50(DQ16) CON1701.45(DQ21) U0300.BG11(DDR1_DQ[16]/DDR0_DQ[48])
M_CHB_DQ17: CON1700.46(DQ20) CON1701.49(DQ17) U0300.BG10(DDR1_DQ[17]/DDR0_DQ[49])
M_CHB_DQ18: CON1700.49(DQ17) CON1701.46(DQ20) U0300.BG8(DDR1_DQ[18]/DDR0_DQ[50])
M_CHB_DQ19: CON1700.63(DQ19) CON1701.62(DQ18) U0300.BF8(DDR1_DQ[19]/DDR0_DQ[51])
M_CHB_DQ20: CON1700.58(DQ22) CON1701.63(DQ19) U0300.BF11(DDR1_DQ[20]/DDR0_DQ[52])
M_CHB_DQ21: CON1700.62(DQ18) CON1701.59(DQ23) U0300.BF10(DDR1_DQ[21]/DDR0_DQ[53])
M_CHB_DQ22: CON1700.45(DQ21) CON1701.50(DQ16) U0300.BG7(DDR1_DQ[22]/DDR0_DQ[54])
M_CHB_DQ23: CON1700.59(DQ23) CON1701.58(DQ22) U0300.BF7(DDR1_DQ[23]/DDR0_DQ[55])
M_CHB_DQ24: CON1700.79(DQ30) CON1701.84(DQ27) U0300.BB11(DDR1_DQ[24]/DDR0_DQ[56])
M_CHB_DQ25: CON1700.70(DQ24) CON1701.71(DQ25) U0300.BC11(DDR1_DQ[25]/DDR0_DQ[57])
M_CHB_DQ26: CON1700.84(DQ27) CON1701.79(DQ30) U0300.BB8(DDR1_DQ[26]/DDR0_DQ[58])
M_CHB_DQ27: CON1700.71(DQ25) CON1701.66(DQ28) U0300.BC8(DDR1_DQ[27]/DDR0_DQ[59])
M_CHB_DQ28: CON1700.66(DQ28) CON1701.67(DQ29) U0300.BC10(DDR1_DQ[28]/DDR0_DQ[60])
M_CHB_DQ29: CON1700.83(DQ26) CON1701.80(DQ31) U0300.BB10(DDR1_DQ[29]/DDR0_DQ[61])
M_CHB_DQ30: CON1700.67(DQ29) CON1701.70(DQ24) U0300.BC7(DDR1_DQ[30]/DDR0_DQ[62])
M_CHB_DQ31: CON1700.80(DQ31) CON1701.83(DQ26) U0300.BB7(DDR1_DQ[31]/DDR0_DQ[63])
M_CHB_DQ32: CON1700.183(DQ38) CON1701.186(DQ35) U0300.AA11(DDR1_DQ[32]/DDR1_DQ[16])
M_CHB_DQ33: CON1700.187(DQ34) CON1701.182(DQ39) U0300.AA10(DDR1_DQ[33]/DDR1_DQ[17])
M_CHB_DQ34: CON1700.173(DQ33) CON1701.170(DQ36) U0300.AC11(DDR1_DQ[34]/DDR1_DQ[18])
M_CHB_DQ35: CON1700.169(DQ37) CON1701.174(DQ32) U0300.AC10(DDR1_DQ[35]/DDR1_DQ[19])
M_CHB_DQ36: CON1700.182(DQ39) CON1701.187(DQ34) U0300.AA7(DDR1_DQ[36]/DDR1_DQ[20])
M_CHB_DQ37: CON1700.186(DQ35) CON1701.183(DQ38) U0300.AA8(DDR1_DQ[37]/DDR1_DQ[21])
M_CHB_DQ38: CON1700.170(DQ36) CON1701.169(DQ37) U0300.AC8(DDR1_DQ[38]/DDR1_DQ[22])
M_CHB_DQ39: CON1700.174(DQ32) CON1701.173(DQ33) U0300.AC7(DDR1_DQ[39]/DDR1_DQ[23])
M_CHB_DQ40: CON1700.195(DQ40) CON1701.190(DQ45) U0300.W8(DDR1_DQ[40]/DDR1_DQ[24])
M_CHB_DQ41: CON1700.191(DQ44) CON1701.194(DQ41) U0300.W7(DDR1_DQ[41]/DDR1_DQ[25])
M_CHB_DQ42: CON1700.207(DQ42) CON1701.204(DQ47) U0300.V10(DDR1_DQ[42]/DDR1_DQ[26])
M_CHB_DQ43: CON1700.203(DQ46) CON1701.208(DQ43) U0300.V11(DDR1_DQ[43]/DDR1_DQ[27])
M_CHB_DQ44: CON1700.194(DQ41) CON1701.191(DQ44) U0300.W11(DDR1_DQ[44]/DDR1_DQ[28])
M_CHB_DQ45: CON1700.190(DQ45) CON1701.195(DQ40) U0300.W10(DDR1_DQ[45]/DDR1_DQ[29])
M_CHB_DQ46: CON1700.204(DQ47) CON1701.207(DQ42) U0300.V7(DDR1_DQ[46]/DDR1_DQ[30])
M_CHB_DQ47: CON1700.208(DQ43) CON1701.203(DQ46) U0300.V8(DDR1_DQ[47]/DDR1_DQ[31])
M_CHB_DQ48: CON1700.212(DQ53) CON1701.215(DQ49) U0300.R11(DDR1_DQ[48])
M_CHB_DQ49: CON1700.225(DQ55) CON1701.228(DQ50) U0300.P11(DDR1_DQ[49])
M_CHB_DQ50: CON1700.224(DQ54) CON1701.229(DQ51) U0300.P7(DDR1_DQ[50])
M_CHB_DQ51: CON1700.215(DQ49) CON1701.212(DQ53) U0300.R8(DDR1_DQ[51])
M_CHB_DQ52: CON1700.216(DQ48) CON1701.211(DQ52) U0300.R10(DDR1_DQ[52])
M_CHB_DQ53: CON1700.229(DQ51) CON1701.224(DQ54) U0300.P10(DDR1_DQ[53])
M_CHB_DQ54: CON1700.211(DQ52) CON1701.216(DQ48) U0300.R7(DDR1_DQ[54])
M_CHB_DQ55: CON1700.228(DQ50) CON1701.225(DQ55) U0300.P8(DDR1_DQ[55])
M_CHB_DQ56: CON1700.245(DQ62) CON1701.250(DQ59) U0300.L11(DDR1_DQ[56])
M_CHB_DQ57: CON1700.232(DQ60) CON1701.237(DQ56) U0300.M11(DDR1_DQ[57])
M_CHB_DQ58: CON1700.246(DQ63) CON1701.249(DQ58) U0300.L7(DDR1_DQ[58])
M_CHB_DQ59: CON1700.237(DQ56) CON1701.232(DQ60) U0300.M8(DDR1_DQ[59])
M_CHB_DQ60: CON1700.249(DQ58) CON1701.246(DQ63) U0300.L10(DDR1_DQ[60])
M_CHB_DQ61: CON1700.236(DQ57) CON1701.233(DQ61) U0300.M10(DDR1_DQ[61])
M_CHB_DQ62: CON1700.233(DQ61) CON1701.236(DQ57) U0300.M7(DDR1_DQ[62])
M_CHB_DQ63: CON1700.250(DQ59) CON1701.245(DQ62) U0300.L8(DDR1_DQ[63])
M_CHB_DQS0: CON1700.13(DQS0_T) CON1701.13(DQS0_T) U0300.BR9(DDR1_DQSP[0]/DDR0_DQSP[2])
M_CHB_DQS0#: CON1700.11(DQS0_C) CON1701.11(DQS0_C) U0300.BP9(DDR1_DQSN[0]/DDR0_DQSN[2])
M_CHB_DQS1: CON1700.34(DQS1_T) CON1701.34(DQS1_T) U0300.BJ9(DDR1_DQSP[1]/DDR0_DQSP[3])
M_CHB_DQS1#: CON1700.32(DQS1_C) CON1701.32(DQS1_C) U0300.BL9(DDR1_DQSN[1]/DDR0_DQSN[3])
M_CHB_DQS2: CON1700.55(DQS2_T) CON1701.55(DQS2_T) U0300.BF9(DDR1_DQSP[2]/DDR0_DQSP[6])
M_CHB_DQS2#: CON1700.53(DQS2_C) CON1701.53(DQS2_C) U0300.BG9(DDR1_DQSN[2]/DDR0_DQSN[6])
M_CHB_DQS3: CON1700.76(DQS3_T) CON1701.76(DQS3_T) U0300.BB9(DDR1_DQSP[3]/DDR0_DQSP[7])
M_CHB_DQS3#: CON1700.74(DQS3_C) CON1701.74(DQS3_C) U0300.BC9(DDR1_DQSN[3]/DDR0_DQSN[7])
M_CHB_DQS4: CON1700.179(DQS4_T) CON1701.179(DQS4_T) U0300.AA9(DDR1_DQSP[4]/DDR1_DQSP[2])
M_CHB_DQS4#: CON1700.177(DQS4_C) CON1701.177(DQS4_C) U0300.AC9(DDR1_DQSN[4]/DDR1_DQSN[2])
M_CHB_DQS5: CON1700.200(DQS5_T) CON1701.200(DQS5_T) U0300.V9(DDR1_DQSP[5]/DDR1_DQSP[3])
M_CHB_DQS5#: CON1700.198(DQS5_C) CON1701.198(DQS5_C) U0300.W9(DDR1_DQSN[5]/DDR1_DQSN[3])
M_CHB_DQS6: CON1700.221(DQS6_T) CON1701.221(DQS6_T) U0300.P9(DDR1_DQSP[6])
M_CHB_DQS6#: CON1700.219(DQS6_C) CON1701.219(DQS6_C) U0300.R9(DDR1_DQSN[6])
M_CHB_DQS7: CON1700.242(DQS7_T) CON1701.242(DQS7_T) U0300.L9(DDR1_DQSP[7])
M_CHB_DQS7#: CON1700.240(DQS7_C) CON1701.240(DQS7_C) U0300.M9(DDR1_DQSN[7])
M_CHB_MAA0: CON1700.144(A0) CON1701.144(A0) U0300.AJ9(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
M_CHB_MAA1: CON1700.133(A1) CON1701.133(A1) U0300.AK6(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
M_CHB_MAA2: CON1700.132(A2) CON1701.132(A2) U0300.AK5(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
M_CHB_MAA3: CON1700.131(A3) CON1701.131(A3) U0300.AL5(DDR1_MA[3])
M_CHB_MAA4: CON1700.128(A4) CON1701.128(A4) U0300.AL6(DDR1_MA[4])
M_CHB_MAA5: CON1700.126(A5) CON1701.126(A5) U0300.AM6(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
M_CHB_MAA6: CON1700.127(A6) CON1701.127(A6) U0300.AN7(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
M_CHB_MAA7: CON1700.122(A7) CON1701.122(A7) U0300.AN10(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
M_CHB_MAA8: CON1700.125(A8) CON1701.125(A8) U0300.AN8(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
M_CHB_MAA9: CON1700.121(A9) CON1701.121(A9) U0300.AR11(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
M_CHB_MAA10: CON1700.146(A10/AP) CON1701.146(A10/AP) U0300.AH7(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
M_CHB_MAA11: CON1700.120(A11) CON1701.120(A11) U0300.AN11(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
M_CHB_MAA12: CON1700.119(A12) CON1701.119(A12) U0300.AR10(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
M_CHB_MAA13: CON1700.158(A13) CON1701.158(A13) U0300.AF9(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
M_CHB_MAA14: CON1700.151(WE_N/A14) CON1701.151(WE_N/A14) U0300.AH11(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
M_CHB_MAA15: CON1700.156(CAS_N/A15) CON1701.156(CAS_N/A15) U0300.AF8(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
M_CHB_MAA16: CON1700.152(RAS_N/A16) CON1701.152(RAS_N/A16) U0300.AH10(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
M_CHB_ODT0: CON1700.155(ODT0) U0300.AF7(DDR1_ODT[0])
M_CHB_ODT1: CON1700.161(ODT1) U0300.AE8(DDR1_ODT[1])
M_CHB_ODT2: CON1701.155(ODT0) U0300.AE9(DDR1_ODT[2])
M_CHB_ODT3: CON1701.161(ODT1) U0300.AE11(DDR1_ODT[3])
M_CHB_PAR: CON1700.143(PARITY) CON1701.143(PARITY) U0300.AJ7(DDR1_PAR)
MB_ID0: R6117.2 R6118.1 U2000.U36(GPP_G4/FAN_TACH_4)
MB_ID1: R6119.2 R6120.1 U2000.P44(GPP_G5/FAN_TACH_5)
MB_ID2: R6101.2 R6102.1 U2000.T45(GPP_G6/FAN_TACH_6)
MB_ID3: R6103.2 R6104.1 U2000.T44(GPP_G7/FAN_TACH_7)
MB_ID4: R6121.2 R6122.1 U2000.R44(GPP_G8/FAN_PWM_0)
MB_ID5: R6123.2 R6124.1 U2000.R43(GPP_G9/FAN_PWM_1)
MB_ID6: R2145.1 U2000.AA44(GPP_F13/SDATAOUT0)
MCK_BUTTON1#: CON5602.14 U3002.108(RXD/SIN0/GPB0)
MCK_BUTTON2#: CON5602.12 U3002.109(TXD/SOUT0/GPB1)
MCK_BUTTON3#: CON5602.10 U3002.35(RTS1#/GPE5)
MCK_BUTTON4#: CON5602.8 U3002.20(L80LLAT/GPE7)
MCK_BUTTON5#: CON5602.6 U3002.86(PS2DAT0/TMB1/GPF1)
MCK_BUTTON6#: CON5602.2 U3002.88(PS2DAT1/RTS0#/GPF3)
MCK_LED1: CON5602.15 R30108.1 SR3021.2
MCK_LED1_EC: SR3021.1 U3002.70(ADC4/GPI4)
MCK_LED2: CON5602.13 R30107.1 SR3022.2
MCK_LED2_EC: SR3022.1 U3002.71(ADC5/DCD1#/GPI5)
MCK_LED3: CON5602.11 R30106.1 SR3019.2
MCK_LED3_EC: SR3019.1 U3002.72(ADC6/DSR1#/GPI6)
MCK_LED4: CON5602.9 R30105.1 SR3020.2
MCK_LED4_EC: SR3020.1 U3002.73(ADC7/CTS1#/GPI7)
MCK_LED5: CON5602.7 R30109.1 SR3026.2
MCK_LED5_EC: SR3026.1 U3002.99(GPH6/ID6)
MCK_LED_B: CON5602.3 R30102.1 SR3025.1
MCK_LED_B_EC: SR3025.2 U3002.78(DAC2/TACH0B/GPJ2)
MCK_LED_G: CON5602.4 R30103.1 SR3024.1
MCK_LED_G_EC: SR3024.2 U3002.77(GPJ1)
MCK_LED_R: CON5602.5 R30104.1 SR3023.1
MCK_LED_R_EC: SR3023.2 U3002.76(TACH2/GPJ0)
MCT0: R3400.1 U3401.24(MCT1)
MCT1: R3401.1 U3401.21(MCT2)
MCT2: R3402.1 U3401.18(MCT3)
MCT3: R3403.1 U3401.15(MCT4)
ME_AC_PRESENT: R2442.2 R2459.1 SR3012.2 U2000.BB15(GPD1/ACPRESENT)
MEM_VDD_CTL: R7459.2 R7460.2 SR8904.1 U7000.BH4(GPIO8)
MSM_TP: T1001.1 U0300.AW13(MSM#)
N17_REST_BACKUP#: R2465.2 R2481.1 U2000.BD34(GPP_H10/SML2CLK) U7002.1(A)
NC_B4: R1126.1 U1101.B4(PB_LSTX)
NC_B5: R1127.1 U1101.B5(PB_LSRX)
NC_F19: R1124.2 U1101.F19(PB_USB2_RBIAS)
NC_G2: R1125.1 U1101.G2(PB_DPSRC_HPD)
NO_REBOOT_MODE: R2405.1 R2413.2 U2000.BD28(GPP_B18/GSPI0_MOSI)
NTC_A: R8081.2 U8000.15(NTC_A)
NTC_B: R8031.2 U8000.3(NTC_B)
NVJTAG_SEL: R7425.2 U7000.BK23(NVJTAG_SEL)
NVVDD_EN: D7403.2(ANODE2) D8701.2(CATHODE) R8700.1 U7415.4(Y)
NVVDD_PSI: SR7409.2 SR8702.1
NVVDD_PWROK: R9206.1 SR8704.1 T9204.1
NVVDD_SCL: R7498.2 SR8706.1
NVVDD_SDA: R7499.2 SR8701.1
NVVDD_VDD_SENSE: SR8708.2 U7000.BK45(VDD_SENSE)
NVVDD_VID: SR7403.2 SR8703.1
NVVDD_VSS_SENSE: SR8707.2 U7000.BL45(GND_SENSE)
NVVDDS_EN: D9600.2(CATHODE) D9700.2(CATHODE) R5737.1 R5741.1 R5745.1 R9602.1 R9722.1 SR5701.1 SR5705.1 SR5707.1 U7416.4(Y)
NVVDDS_PSI: SR7418.2 SR9710.1
NVVDDS_PWROK: R7495.1 R9215.1 SR9700.1 T9212.1
NVVDDS_VDD_SENSE: SR9712.1 U7000.BM45(VDDS_SENSE)
NVVDDS_VDD_SENSE_IC: C9723.2 R9720.1 SR9712.2 U9700.11(VSNS)
NVVDDS_VID: SR7405.2 SR9703.1
NVVDDS_VSS_SENSE: SR9711.1 U7000.BM44(GNDS_SENSE)
NVVDDS_VSS_SENSE_IC: C9723.1 R9718.1 SR9705.2 SR9711.2 U9700.10(RGND)
OC0#: R2118.2 U1202.13(FAULT#) U2000.AD43(GPP_E9/USB2_OC0#) U5200.13(FAULT#)
OC1#: CON6700.24 R2117.2 U2000.AD42(GPP_E10/USB2_OC1#)
OC2#: R2119.2 U2000.AD39(GPP_E11/USB2_OC2#) U5501.3(OCB)
OE: C1318.1 U1301.36(OE)
OP_SD#: Q3601.2(G) R2420.2 U2000.BD24(GPP_B4/CPU_GP3)
OPC_RCOMP: R1014.1 U0300.BT29(OPC_RCOMP)
OPCE_RCOMP: R1015.1 U0300.BR25(OPCE_RCOMP)
OPCE_RCOMP2: R1016.1 U0300.BP25(OPCE_RCOMP2)
OUT_AUXN: C4627.2 CON4601.17 Q4601.3(D) R4607.2
OUT_AUXP: C4626.2 CON4601.15 Q4601.6(D) R4608.2
OVERT#: R7440.1 U7000.BG5(OVERT) U7417.1(S)
PCBEEP: R2449.1 R2460.2 R3606.2 U2000.BD26(GPP_B14/SPKR) U3002.34(PWM7/RIG1#/GPA7)
PCH_BATL#: R2444.2 U2000.BD13(GPD0/BATLOW#)
PCH_BKLT_EN: C2311.1 R2360.2 SR4507.1 U2000.AM44(GPP_D4/ISH_I2C2_SDA/ISH_I2C3_SD)
PCH_C1: T2502.1 U2000.C1(RSVD1)
PCH_CPUPWRGD: SR2406.2 U2000.AM3(PROCPWRGD)
PCH_D1: T2503.1 U2000.D1(RSVD2)
PCH_DEVSLP1: R2102.2 SR5101.1 U2000.AG43(GPP_E5/DEVSLP1)
PCH_DEVSLP3: SR5108.1 U2000.AB41(GPP_F5/DEVSLP3)
PCH_DGPU_EN: R2407.2 R2427.1 R2495.2 R2496.2 U2000.AL27(GPP_B1)
PCH_DRAM_RESET#: C2402.1 R2452.1 R2478.1 SR2407.2 U2000.BC14(DRAM_RESET#)
PCH_DSW_PWROK: R2476.1 SR2409.2 U2000.AV11(DSW_PWROK)
PCH_EN_PWR: D7401.1(ANODE1) R2495.1 R2498.1 U7411.1(A)
PCH_FLASH_DESCRIPTOR: D2301.1(ANODE) R3007.2 U3002.2(GPJ7)
PCH_GPP_F23: R2146.1 SR2101.2 U2000.V44(GPP_F23)
PCH_GSXDIN: R2261.1 U2000.R42(GPP_G14/GSXDIN)
PCH_GSXSLOAD: R2248.2 U2000.R36(GPP_G13/GSXSLOAD)
PCH_GSXSRST#: R2260.1 U2000.R41(GPP_G15/GSXSRESET#)
PCH_H_TRST#: SR2301.1 U2000.AY5(CPU_TRST#)
PCH_JTAG_TCK: R2350.1 SR4403.2 U2000.AN3(JTAG_TCK)
PCH_JTAG_TDI: SR2304.1 U2000.AP2(JTAG_TDI)
PCH_JTAG_TDO: SR2303.1 U2000.AP1(JTAG_TDO)
PCH_JTAG_TMS: SR2302.1 U2000.AR2(JTAG_TMS)
PCH_JTAGX: SR2305.1 U2000.AR3(JTAGX)
PCH_NMI#: R2205.2 U2000.N43(GPP_G18/NMI#)
PCH_OCB4: R2114.2 U2000.Y43(GPP_F15/USB2_OCB_4)
PCH_OCB5: R2113.2 U2000.Y41(GPP_F16/USB2_OCB_5)
PCH_OCB6: R2115.2 U2000.W44(GPP_F17/USB2_OCB_6)
PCH_OCB7: R2116.2 U2000.W43(GPP_F18/USB2_OCB_7)
PCH_PLTRST#: SR2405.2 U2000.BB27(GPP_B13/PLTRST#)
PCH_PME_IN#: R2250.2 U2000.BD17(GPP_A11/PME#)
PCH_PWROK: R2475.1 R2493.2 R2494.2 U2000.AW11(PCH_PWROK) U2402.4(Y)
PCH_RCIN#: C2200.1 R2202.2 SR2201.2 U2000.AT17(GPP_A0/RCIN#/ESPI_ALERT1#)
PCH_RSMRST#: R2477.1 SR2408.2 SR2409.1 U2000.BA11(RSMRST#)
PCH_SATALED#: D5601.1(CATHODE1) R2106.2 U2000.AD44(GPP_E8/SATALED#)
PCH_SLP_S3#: SR2401.2 T2407.1 U2000.AW15(GPD4/SLP_S3#)
PCH_SLP_S4#: SR2402.2 T2406.1 U2000.BD15(GPD5/SLP_S4#)
PCH_SLP_S5#: SR2403.2 T2405.1 U2000.BA13(GPD10/SLP_S5#)
PCH_SLP_WLAN#: SR2404.2 T2403.1 U2000.AV13(GPD9/SLP_WLAN#)
PCH_SML2ALERT#: R2464.2 R2484.2 U2000.BD35(GPP_H12/SML2ALERT#)
PCH_SRCCLKREQ2#: R2411.2 U2000.AT24(GPP_B7/SRCCLKREQ2#)
PCH_SRCCLKREQ4#: R2422.2 U2000.BB24(GPP_B9/SRCCLKREQ4#)
PCH_SRCCLKREQ5#: R2423.2 U2000.BE25(GPP_B10/SRCCLKREQ5#)
PCH_SRCCLKREQ6#: R2428.2 U2000.AT33(GPP_H0/SRCCLKREQ6#)
PCH_SRCCLKREQ11#: R2433.2 U2000.BC33(GPP_H5/SRCCLKREQ11#)
PCH_SUSACK#: T2205.1 U2000.BB19(GPP_A15/SUSACK#)
PCH_SYS_PWROK: R2479.1 R2489.2 R2491.2 U2000.AY1(SYS_PWROK) U2403.4(Y)
PCH_TGR_L900MIL: R2326.1 U2000.AL2(PCH_TRIGOUT)
PCH_THMTRIP#_R: R2454.1 U2000.AJ3(THERMTRIP#)
PCH_VR_ICC_THROTTLING: R2408.2 U2000.BD23(GPP_B2/VRALERT#)
PCH_VSS_AB10: SR2702.1 U2000.AB10(VSS152)
PCH_VSS_AB11: SR2701.1 U2000.AB11(VSS153)
PCHXDP_OBSDATA_A0_R: R2107.2 R2111.1 U2000.AG35(GPP_E1/SATAXPCIE1/SATAGP1)
PCHXDP_OBSDATA_A1_R: R2108.2 R2112.1 U2000.AG39(GPP_E2/SATAXPCIE2/SATAGP2)
PCHXDP_OBSDATA_A2_R: R2100.2 U2000.AF41(GPP_E3/CPU_GP0)
PCHXDP_OBSDATA_B1_R: R2103.2 U2000.AE45(GPP_E6/DEVSLP2)
PCHXDP_OBSDATA_B2_R: R2104.2 U2000.AE44(GPP_E7/CPU_GP1)
PCHXDP_PRDY#: R2325.1 U2000.AT4(PRDY#)
PCHXDP_PREQ_R#: R4403.2 U2000.AT3(PREQ#)
PCI_IRQA: R2206.2 SR2208.2 U2000.AW17(GPP_A7/PIRQA#/ESPI_ALERT0#)
PCIE_CLK_N_GPU: SR2516.2 U7000.BM27(PEX_REFCLK_N)
PCIE_CLK_N_GPU_R: SR2516.1 U2000.N3(CLKOUT_PCIE_N9)
PCIE_CLK_P_GPU: SR2515.2 U7000.BM26(PEX_REFCLK)
PCIE_CLK_P_GPU_R: SR2515.1 U2000.N2(CLKOUT_PCIE_P9)
PCIE_LAN_TXN: C2013.2 U2000.B21(PCIE4_TXN/USB3_10_TXN)
PCIE_LAN_TXP: C2012.2 U2000.A21(PCIE4_TXP/USB3_10_TXP)
PCIE_RCOMPN: R2516.2 U2000.B18(PCIE_RCOMPN)
PCIE_RCOMPP: R2516.1 U2000.C17(PCIE_RCOMPP)
PCIE_RXN7_WLAN: CON5300.43 U2000.L17(PCIE3_RXN/USB3_9_RXN)
PCIE_RXN8_WIGI: CON5300.65 U2000.E17(PCIE2_RXN/USB3_8_RXN)
PCIE_RXP7_WLAN: CON5300.41 U2000.K17(PCIE3_RXP/USB3_9_RXP)
PCIE_RXP8_WIGI: CON5300.67 U2000.G17(PCIE2_RXP/USB3_8_RXP)
PCIE_SATA_PEDET: CON5103.69 T5103.1
PCIE_SATA_PEDET1: CON5104.69 T5105.1
PCIE_SATA_RXN0: CON5102.43 U2000.G31(PCIE9_RXN/SATA0A_RXN)
PCIE_SATA_RXN1: CON5102.29 U2000.G29(PCIE10_RXN/SATA1A_RXN)
PCIE_SATA_RXN2: CON5102.17 U2000.L31(PCIE11_RXN)
PCIE_SATA_RXN3: CON5102.5 U2000.G33(PCIE12_RXN)
PCIE_SATA_RXP0: CON5102.41 U2000.H31(PCIE9_RXP/SATA0A_RXP)
PCIE_SATA_RXP1: CON5102.31 U2000.E29(PCIE10_RXP/SATA1A_RXP)
PCIE_SATA_RXP2: CON5102.19 U2000.K31(PCIE11_RXP)
PCIE_SATA_RXP3: CON5102.7 U2000.H33(PCIE12_RXP)
PCIE_SATA_TXN0: C5131.1 U2000.C31(PCIE9_TXN/SATA0A_TXN)
PCIE_SATA_TXN0_C: C5131.2 CON5102.47
PCIE_SATA_TXN1: C5150.1 U2000.C32(PCIE10_TXN/SATA1A_TXN)
PCIE_SATA_TXN1_C: C5150.2 CON5102.35
PCIE_SATA_TXN2: C5155.1 U2000.C33(PCIE11_TXN)
PCIE_SATA_TXN2_C: C5155.2 CON5102.23
PCIE_SATA_TXN3: C5158.1 U2000.B35(PCIE12_TXN)
PCIE_SATA_TXN3_C: C5158.2 CON5102.11
PCIE_SATA_TXP0: C5132.1 U2000.B31(PCIE9_TXP/SATA0A_TXP)
PCIE_SATA_TXP0_C: C5132.2 CON5102.49
PCIE_SATA_TXP1: C5151.1 U2000.B32(PCIE10_TXP/SATA1A_TXP)
PCIE_SATA_TXP1_C: C5151.2 CON5102.37
PCIE_SATA_TXP2: C5154.1 U2000.B33(PCIE11_TXP)
PCIE_SATA_TXP2_C: C5154.2 CON5102.25
PCIE_SATA_TXP3: C5159.1 U2000.A35(PCIE12_TXP)
PCIE_SATA_TXP3_C: C5159.2 CON5102.13
PCIE_TXN7_WLAN: C2021.1 CON5300.37
PCIE_TXN7_WLAN_C: C2021.2 U2000.B20(PCIE3_TXN/USB3_9_TXN)
PCIE_TXN8_WIGI: C2003.1 CON5300.59
PCIE_TXN8_WIGI_C: C2003.2 U2000.B19(PCIE2_TXN/USB3_8_TXN)
PCIE_TXP7_WLAN: C2020.1 CON5300.35
PCIE_TXP7_WLAN_C: C2020.2 U2000.C20(PCIE3_TXP/USB3_9_TXP)
PCIE_TXP8_WIGI: C2002.1 CON5300.61
PCIE_TXP8_WIGI_C: C2002.2 U2000.C19(PCIE2_TXP/USB3_8_TXP)
PDB: D3601.1(ANODE) Q3602.3(DRAIN) R3608.2 SR3701.1 U3600.47(PDB)
PECI_PCH: C2201.1 R0746.1 R2235.1 U2000.AL3(PECI)
PEG_RCOMP: R0600.2 U0300.G2(PEG_RCOMP)
PEG_RXN_0: C0631.2 U0300.E10(PEG_RXN[15])
PEG_RXN_1: C0629.2 U0300.E11(PEG_RXN[14])
PEG_RXN_2: C0627.2 U0300.E12(PEG_RXN[13])
PEG_RXN_3: C0625.2 U0300.E13(PEG_RXN[12])
PEG_RXN_4: C0623.2 U0300.E14(PEG_RXN[11])
PEG_RXN_5: C0621.2 U0300.E15(PEG_RXN[10])
PEG_RXN_6: C0619.2 U0300.E16(PEG_RXN[9])
PEG_RXN_7: C0617.2 U0300.E17(PEG_RXN[8])
PEG_RXN_8: C0615.2 U0300.F18(PEG_RXN[7])
PEG_RXN_9: C0613.2 U0300.D19(PEG_RXN[6])
PEG_RXN_10: C0611.2 U0300.F20(PEG_RXN[5])
PEG_RXN_11: C0605.2 U0300.D21(PEG_RXN[4])
PEG_RXN_12: C0609.2 U0300.F22(PEG_RXN[3])
PEG_RXN_13: C0608.2 U0300.D23(PEG_RXN[2])
PEG_RXN_14: C0602.2 U0300.F24(PEG_RXN[1])
PEG_RXN_15: C0600.2 U0300.D25(PEG_RXN[0])
PEG_RXP_0: C0630.2 U0300.F10(PEG_RXP[15])
PEG_RXP_1: C0628.2 U0300.D11(PEG_RXP[14])
PEG_RXP_2: C0626.2 U0300.F12(PEG_RXP[13])
PEG_RXP_3: C0624.2 U0300.D13(PEG_RXP[12])
PEG_RXP_4: C0622.2 U0300.F14(PEG_RXP[11])
PEG_RXP_5: C0620.2 U0300.D15(PEG_RXP[10])
PEG_RXP_6: C0618.2 U0300.F16(PEG_RXP[9])
PEG_RXP_7: C0616.2 U0300.D17(PEG_RXP[8])
PEG_RXP_8: C0614.2 U0300.E18(PEG_RXP[7])
PEG_RXP_9: C0612.2 U0300.E19(PEG_RXP[6])
PEG_RXP_10: C0606.2 U0300.E20(PEG_RXP[5])
PEG_RXP_11: C0610.2 U0300.E21(PEG_RXP[4])
PEG_RXP_12: C0604.2 U0300.E22(PEG_RXP[3])
PEG_RXP_13: C0603.2 U0300.E23(PEG_RXP[2])
PEG_RXP_14: C0601.2 U0300.E24(PEG_RXP[1])
PEG_RXP_15: C0607.2 U0300.E25(PEG_RXP[0])
PET0_N: C1102.2 U1101.V22(PCIE_TX0_N)
PET0_P: C1101.2 U1101.V23(PCIE_TX0_P)
PET1_N: C1104.2 U1101.P22(PCIE_TX1_N)
PET1_P: C1103.2 U1101.P23(PCIE_TX1_P)
PET2_N: C1106.2 U1101.K22(PCIE_TX2_N)
PET2_P: C1105.2 U1101.K23(PCIE_TX2_P)
PET3_N: C1108.2 U1101.F22(PCIE_TX3_N)
PET3_P: C1107.2 U1101.F23(PCIE_TX3_P)
PEX_CLKREQ#: R2431.2 R7007.2 U2000.BC32(GPP_H3/SRCCLKREQ9#) U7001.6(D)
PEX_CLKREQ#_Q: R7001.2 U7000.BL26(PEX_CLKREQ_N) U7001.1(S)
PEX_PLL_HVDD_SVDD: C7026.1 SR7002.1 U7000.BB30(PEX_PLL_HVDD)
PEX_RST#: R7005.2 R7006.1 R7496.1 U7000.BK26(PEX_RST_N) U7003.4(Y)
PEX_RST#_R: R7004.1 R7005.1 U7002.4(Y)
PEX_TERMP: R7009.1 U7000.BL44(PEX_TERMP)
PEX_VDD: C7000.1 C7001.1 C7002.1 C7003.1 C7007.1 C7011.1 C7012.1 C7019.1 C7054.1 C7203.1 C7219.1 C7231.1 C9606.1 JP9600.2 R5720.2 R5721.2 R5722.2 R5732.2 R5733.2 SR7209.1 SR7210.1 SR7211.1 U7000.BB33(PEX_DVDD_1) U7000.BB35(PEX_DVDD_2) U7000.BB36(PEX_DVDD_3) U7000.BC33(PEX_DVDD_4) U7000.BC35(PEX_DVDD_5) U7000.BC36(PEX_DVDD_6) U7000.BD33(PEX_DVDD_7) U7000.BD36(PEX_DVDD_8)
PH1_A: JP8050.2 L8000.1 R8053.2 T8050.1 U8001.16(SW1) U8001.17(SW2) U8001.18(SW3) U8001.19(SW4) U8001.20(SW5) U8001.21(SW6) U8001.22(SW7) U8001.23(SW8) U8001.24(SW9) U8001.25(SW10) U8001.26(SW11)
PH1_B: JP8058.2 L8003.1 R8073.2 T8054.1 U8006.16(SW1) U8006.17(SW2) U8006.18(SW3) U8006.19(SW4) U8006.20(SW5) U8006.21(SW6) U8006.22(SW7) U8006.23(SW8) U8006.24(SW9) U8006.25(SW10) U8006.26(SW11)
PH2_A: JP8052.2 L8001.1 R8054.2 T8051.1 U8002.16(SW1) U8002.17(SW2) U8002.18(SW3) U8002.19(SW4) U8002.20(SW5) U8002.21(SW6) U8002.22(SW7) U8002.23(SW8) U8002.24(SW9) U8002.25(SW10) U8002.26(SW11)
PH2_B: JP8059.2 L8004.1 R8072.2 T8055.1 U8004.16(SW1) U8004.17(SW2) U8004.18(SW3) U8004.19(SW4) U8004.20(SW5) U8004.21(SW6) U8004.22(SW7) U8004.23(SW8) U8004.24(SW9) U8004.25(SW10) U8004.26(SW11)
PH3_A: JP8054.2 L8002.1 R8055.2 T8052.1 U8003.16(SW1) U8003.17(SW2) U8003.18(SW3) U8003.19(SW4) U8003.20(SW5) U8003.21(SW6) U8003.22(SW7) U8003.23(SW8) U8003.24(SW9) U8003.25(SW10) U8003.26(SW11)
PH_C: C8086.2 JP8056.2 L8005.1 Q8001.5(D) Q8002.1(S_1) Q8002.2(S_2) Q8002.3(S_3) R8070.2 T8053.1 U8005.8(PHASE)
PLTRST#: D2402.1(ANODE) R3137.2 SR2405.1 SR5104.1 U2401.1(A) U2401.2(B) U3002.22(LPCRST#/GPD2) U6200.16(LRESET#/SPI_RST#/SRESET#)
PLTRST#_BUF: D5303.2(CATHODE) D5308.2(CATHODE) Q5002.2(G) R1116.1 R5319.2 R5355.2 SR3304.1 SR7001.1 U1104.2(A) U2401.4(Y)
PLTRST#_BUF_AR: R1116.2 SR1101.2 U1104.4(Y)
PLTRST_CPU#: R2474.1 R4418.2 U0300.BP35(RESET#) U2000.AK2(PLTRST_PROC#)
PM_CLKRUN#: R2251.2 U2000.AW22(GPP_A8/CLKRUN#) U3002.93(CLKRUN#/GPH0/ID0) U6200.15(CLKRUN#/GPIO4/SINT#)
PM_DOWN: R0731.1 U2000.AH2(PM_DOWN)
PM_PWRBTN#: C2400.1 R2447.2 R4415.2 U2000.AT13(GPD3/PWRBTN#) U3002.87(PS2CLK1/DTR0#/GPF2)
PM_RSMRST#: R3066.2 R4406.2 SR2408.1 U3002.112(RING#/PWRFAIL#/CK32KOUT/LPCRST#)
PM_SUSB#: R1117.1 R2491.1 R3062.2 R3074.1 SR0702.1 SR2401.1 U1105.2(A) U2403.2(B) U3002.18(RI1#/GPD0)
PM_SUSC#: R3063.2 R3075.1 SR2402.1 SR3108.1 U3002.21(RI2#/GPD1)
PM_SYNC: R2228.2 U0300.BM34(PM_SYNC)
PM_SYNC_R: R2228.1 U2000.AJ4(PM_SYNC)
PRE_SEL: R1322.2 R1323.1 U1301.16(PRE_SEL)
PROC_AUDIO_CLK: R2311.1 U0300.G27(PROC_AUDIO_CLK)
PROC_AUDIO_SDI: R2307.1 U0300.G25(PROC_AUDIO_SDI)
PROC_AUDIO_SDO: R0302.2 U2000.AN2(DISPA_SDI)
PROC_AUDIO_SDO_R: R0302.1 U0300.G29(PROC_AUDIO_SDO)
PROCHOT#: Q0702.3(DRAIN) R0706.1 R0727.1 R80150.2 SR8009.1 SR8811.2
PROCHOT#_R: R0727.2 U0300.BR30(PROCHOT#)
PROG1: R8028.1 U8000.40(PROG1)
PROG2: R8041.1 U8000.39(PROG2)
PROG3: R8046.1 U8000.38(PROG3)
PROG4: R8087.1 U8000.37(PROG4)
PROG5: R8085.1 U8000.36(PROG5)
PRSNT#: R4611.1 U4601.20(PRSNT#)
PS_NVVDD_PHASE1: C8723.2 JP8701.1 L8701.1 Q8701.5(D) Q8702.1(S_1) Q8702.2(S_2) Q8702.3(S_3) Q8710.1(S_1) Q8710.2(S_2) Q8710.3(S_3) Q8713.5(D) R8751.1 R74104.2 U8702.7(SW)
PS_NVVDD_PHASE2: C8728.2 JP8703.1 L8702.1 Q8703.5(D) Q8704.1(S_1) Q8704.2(S_2) Q8704.3(S_3) Q8712.1(S_1) Q8712.2(S_2) Q8712.3(S_3) Q8714.5(D) R8753.1 U8703.7(SW)
PS_NVVDD_PHASE3: C8733.2 JP8705.1 L8703.1 Q8705.5(D) Q8706.1(S_1) Q8706.2(S_2) Q8706.3(S_3) Q8709.1(S_1) Q8709.2(S_2) Q8709.3(S_3) Q8715.5(D) R8755.1 U8704.7(SW)
PS_NVVDD_PHASE4: C8738.2 JP8707.1 L8704.1 Q8707.5(D) Q8708.1(S_1) Q8708.2(S_2) Q8708.3(S_3) Q8711.1(S_1) Q8711.2(S_2) Q8711.3(S_3) Q8716.5(D) R8757.1 U8705.7(SW)
PS_NVVDD_STBY: R7444.2 R7478.2
PSI: R8902.2 R8903.1 U8900.4(PSI)
PSYS: C8010.2 R8021.2 U8000.1(PSYS)
PV: R9707.1 U9702.10(PV)
PWM1_A: U8000.25(PWM1_A) U8001.1(PWM)
PWM1_B: U8000.12(PWM1_B) U8006.1(PWM)
PWM2_A: U8000.26(PWM2_A) U8002.1(PWM)
PWM2_B: U8000.13(PWM2_B) U8004.1(PWM)
PWM3_A: U8000.27(PWM3_A) U8003.1(PWM)
PWM_C: U8000.35(PWM_C) U8005.3(PWM)
PWR_LED: CON5602.17 U3002.24(PWM0/GPA0)
PWR_LED_LED: CON1.5 LC800.1 LQ800.1(GATE)
PWRBTN#: CON5602.16 JP5601.1 R3024.1 R3028.2 R3053.2
R303_D8: D2801.2(ANODE2) R2811.2
R_DMIC-CLK: R3611.2 U3600.3(GPIO1/DMIC-CLK)
R_DMIC-DATA: R3610.2 U3600.2(GPIO0/DMIC-DATA)
RCIN#: SR2201.1 U3002.4(KBRST#/GPB6)
RESERVED_PIN64: CON5300.64 T5310.1
RL_XTAL1: C3324.1 U3300.7(XTLO) Y3300.1
RL_XTAL2: C3325.1 U3300.8(XTLI) Y3300.3
ROM_CS#: R7400.1 R7483.2 U7401.1(CS#)
ROM_CS#_R: R7483.1 U7000.BJ4(ROM_CS_N)
ROM_SCLK: R7403.2 U7401.6(CLK)
ROM_SCLK_R: R7403.1 R7431.1 R7432.2 U7000.BK3(ROM_SCLK)
ROM_SI: R7402.2 U7401.5(DI(IO0))
ROM_SI_R: R7402.1 R7428.1 R7430.2 U7000.BK2(ROM_SI)
ROM_SO: R7426.1 R7427.2 U7000.BK4(ROM_SO) U7401.2(DO(IO1))
RPD_G1: SR1201.2 U1201.K9(RPD_G1)
RPD_G2: SR1202.2 U1201.K10(RPD_G2)
RST#: R3307.2 SR3304.2 U3300.2(PERSTN)
RST#_DP: C1412.1 R1407.2 U1401.35(RST#)
RSVD19: R1004.1 U0300.BL22(RSVD_20)
RSVD28: R1005.2 U0300.BM22(RSVD_29)
RSVD30: R1010.2 U0300.BN16(RSVD_31)
RSVD34: R1009.1 U0300.BP17(RSVD_35)
RSVD_TP0: T0708.1 U0300.BJ13(RSVD_TP_1)
RSVD_TP1: T0707.1 U0300.BJ14(RSVD_TP_2)
RSVD_TP2: T0717.1 U0300.BJ16(RSVD_TP_3)
RSVD_TP3: T0724.1 U0300.BJ24(RSVD_TP_4)
RSVD_TP4: T0734.1 U0300.BJ33(RSVD_TP_5)
RSVD_TP5: T0732.1 U0300.BJ34(RSVD_TP_6)
RSVD_TP6: T0719.1 U0300.BK16(RSVD_TP_7)
RSVD_TP7: T0722.1 U0300.BK24(RSVD_TP_8)
RSVD_TP8: T0714.1 U0300.BL33(RSVD_TP_9)
RSVD_TP9: T0703.1 U0300.BM33(RSVD_TP_10)
RSVD_TP10: T0709.1 U0300.BR1(RSVD_TP_11)
RSVD_TP11: T0710.1 U0300.BT2(RSVD_TP_12)
RSVD_TP12: T0702.1 U0300.D1(RSVD_TP_13)
RSVD_TP13: T0704.1 U0300.E1(RSVD_TP_14)
RSVD_TP14: T0706.1 U0300.E2(RSVD_TP_15)
RSVD_TP36: T0730.1 U0300.BR17(RSVD_37)
RSVD_TP40: T0729.1 U0300.BT17(RSVD_41)
RTC_IN#: Q2801.3(DRAIN) R2804.1 SR2101.1
RTCRST#: C2828.1 R2801.1 R2812.2 U2000.BC10(RTCRST#)
RTCX1_NO_IO: R2523.1 R2525.2 U2000.BC9(RTCX1)
RTCX2_NO_IO: C2501.1 R2523.2 U2000.BD10(RTCX2) Y2500.4
RTD3_CIO_PWR_EN: R1130.1 U1101.F1(POC_GPIO_6)
RTD3_USB_PWR_EN: R1110.1 R1134.1 U1101.D4(POC_GPIO_2)
RTN_A: SR8013.2 U8000.18(RTN_A)
RTN_B: R8027.2 U8000.6(RTN_B)
S3: C8319.1 D8300.1(ANODE) R8305.2 U8300.7(S3)
S5: C8322.1 D8301.1(ANODE) R8307.2 U8300.8(S5)
SATA_A_DE: R1505.2 R1512.2 U1501.9(A_DE)
SATA_A_EQ1: R1506.2 R1507.2 U1501.18(A_EQ1)
SATA_A_EQ2: R1502.2 R1516.2 U1501.19(A_EQ2)
SATA_B_DE: R1504.2 R1513.2 U1501.8(B_DE)
SATA_B_EQ1: R1501.2 R1517.2 U1501.20(B_EQ1)
SATA_B_EQ2: R1503.2 R1511.2 U1501.17(B_EQ2)
SATA_DEVSLP0: R2157.2 SR5102.1 U2000.AG42(GPP_E4/DEVSLP0)
SATA_LED#: CON5602.24 D5601.3(ANODE) R5603.2
SATA_LED#_LED: CON1.2 LC803.1 LQ803.2(G)
SATA_LED_LED: LQ803.5(G) LQ803.6(D) LR804.2
SATA_RXN1: C5122.1 U2000.D39(PCIE14_RXN/SATA1B_RXN)
SATA_RXN2: C1501.2 C1507.2 U2000.F41(PCIE15_RXN/SATA2_RXN)
SATA_RXN2_C: C1507.1 U1501.4(B_OUTN)
SATA_RXN2_CON: C1510.1 CON5100.16 R1518.1
SATA_RXN2_CON_C: C1510.2 U1501.12(B_INN)
SATA_RXN2_PASS: C1501.1 R1518.2
SATA_RXN3: C5170.1 U2000.D43(PCIE16_RXN/SATA3_RXN)
SATA_RXN3_C: C5170.2 CON5104.43
SATA_RXN4_C: C5122.2 CON5103.43
SATA_RXP1: C5121.1 U2000.E37(PCIE14_RXP/SATA1B_RXP)
SATA_RXP2: C1502.2 C1503.2 U2000.E41(PCIE15_RXP/SATA2_RXP)
SATA_RXP2_C: C1503.1 U1501.5(B_OUTP)
SATA_RXP2_CON: C1511.1 CON5100.15 R1510.1
SATA_RXP2_CON_C: C1511.2 U1501.11(B_INP)
SATA_RXP2_PASS: C1502.1 R1510.2
SATA_RXP3: C5169.1 U2000.E42(PCIE16_RXP/SATA3_RXP)
SATA_RXP3_C: C5169.2 CON5104.41
SATA_RXP4_C: C5121.2 CON5103.41
SATA_SSD_LED#: D5601.2(CATHODE2) SR5105.1
SATA_TXN1: C5123.1 U2000.B38(PCIE14_TXN/SATA1B_TXN)
SATA_TXN2: C1509.2 R1509.2 U2000.B39(PCIE15_TXN/SATA2_TXN)
SATA_TXN2_C: C1509.1 U1501.2(A_INN)
SATA_TXN2_CON: C1506.1 C1515.1 CON5100.18
SATA_TXN2_CON_C: C1506.2 U1501.14(A_OUTN)
SATA_TXN2_PASS: C1515.2 R1509.1
SATA_TXN3: C5172.1 U2000.A41(PCIE16_TXN/SATA3_TXN)
SATA_TXN3_C: C5172.2 CON5104.47
SATA_TXN4_C: C5123.2 CON5103.47
SATA_TXP1: C5124.1 U2000.C38(PCIE14_TXP/SATA1B_TXP)
SATA_TXP2: C1508.2 R1508.2 U2000.A39(PCIE15_TXP/SATA2_TXP)
SATA_TXP2_C: C1508.1 U1501.1(A_INP)
SATA_TXP2_CON: C1505.1 C1514.1 CON5100.19
SATA_TXP2_CON_C: C1505.2 U1501.15(A_OUTP)
SATA_TXP2_PASS: C1514.2 R1508.1
SATA_TXP3: C5171.1 U2000.A40(PCIE16_TXP/SATA3_TXP)
SATA_TXP3_C: C5171.2 CON5104.49
SATA_TXP4_C: C5124.2 CON5103.49
SBU1: CON1201.A8(SBU1) SR1204.2 U1208.2(CH2) U1208.9(N.C.3)
SBU2: CON1201.B8(SBU2) SR1205.2 U1207.2(CH2) U1207.9(N.C.3)
SCLK: R8012.1 U8000.45(SCLK)
SDA: R8014.1 U8000.43(SDA)
SDATA_IN_R: R3613.2 U3600.8(SDATA-IN)
SDO: R5801.1 R5802.1 U5800.1(SDO)
SHUT_DOWN#: D7404.2(CATHODE) U7413.1(S)
SLEW_CTL: R1330.2 R1331.1 U1301.34(SLEW_CTL)
SLP_S5#: Q5301.1(GATE) SR2403.1
SLP_WLAN#: Q5302.1(GATE) SR2404.1
SM_RCOMP0: R0504.2 U0300.G1(DDR_RCOMP[0])
SM_RCOMP1: R0506.2 U0300.H1(DDR_RCOMP[1])
SM_RCOMP2: R0507.1 U0300.J2(DDR_RCOMP[2])
SMB0_CLK: D6002.1(ANODE) D6005.3(ANODE2) R3071.2 SR3010.1 SR6001.2 SR8802.1
SMB0_CLK_BATT: CON6000.6 SR6001.1
SMB0_DAT: D6003.1(ANODE) D6006.3(ANODE2) R3070.2 SR3011.1 SR6002.2 SR8801.1
SMB0_DAT_BATT: CON6000.7 SR6002.1
SMB1_CLK: CON6700.14 Q1202.2(SOURCE) Q7401.3(DRAIN) R1329.2 R1332.1 R3034.1 R5001.2 R5803.1 SR3102.2 U5000.8(SMBCLK)
SMB1_CLK_GPU: Q7401.2(SOURCE) R7409.1 U7000.BJ8(I2CS_SCL)
SMB1_CLK_HDMI: R1332.2 U1301.13(SCL_CTL)
SMB1_CLK_LED: SR3102.1 U3102.26(SCL)
SMB1_DAT: CON6700.13 Q1201.2(SOURCE) Q7402.3(DRAIN) R1328.2 R1333.1 R3035.1 R5002.2 R5804.1 SR3103.2 U5000.7(SMBDATA)
SMB1_DAT_GPU: Q7402.2(SOURCE) R7410.1 U7000.BH8(I2CS_SDA)
SMB1_DAT_HDMI: R1333.2 U1301.14(SDA_CTL)
SMB1_DAT_LED: SR3103.1 U3102.27(SDA)
SMB2_CLK_GPU: R7405.1 SR7407.1 U7000.BG9(I2CC_SCL)
SMB2_DAT_GPU: R7406.1 SR7408.1 U7000.BH9(I2CC_SDA)
SMB3_CLK_GPU: R7407.1 R7498.1 R74107.1 U7000.BG8(I2CB_SCL)
SMB3_DAT_GPU: R7408.1 R7499.1 R74108.1 U7000.BF8(I2CB_SDA)
SMB_CLK_DEBUG: Q3102.4(S) R3111.2 R3115.2 SR4409.1
SMB_CLK_MAIN: CON1600.253(SCL) CON1601.253(SCL) CON1700.253(SCL) CON1701.253(SCL) Q3101.4(S) R3105.2 R3110.2
SMB_CLK_RESUME: C2304.1 Q3101.3(D) Q3102.3(D) R2327.2 R3110.1 R3115.1 U2000.AW44(GPP_C0/SMBCLK)
SMB_DATA_DEBUG: Q3102.1(S) R3109.2 R3113.2 SR4408.1
SMB_DATA_MAIN: CON1600.254(SDA) CON1601.254(SDA) CON1700.254(SDA) CON1701.254(SDA) Q3101.1(S) R3104.2 R3108.2
SMB_DATA_RESUME: C2305.1 Q3101.6(D) Q3102.6(D) R2328.2 R3108.1 R3113.1 U2000.BB43(GPP_C1/SMBDATA)
SMBALERT#_PCHHOT#: R2335.2 R2349.2 U2000.AT27(GPP_B23/SML1ALERT#/PCHHOT#)
SMBALERT#_TLS: R2334.2 R2348.2 U2000.BB41(GPP_C2/SMBALERT#)
SMBCLKCPUXDP: SR4409.2 XDP4400.53
SMBDATACPUXDP: SR4408.2 XDP4400.51
SMCLK0: SR3010.2 U3002.110(SMCLK0/GPB3)
SMDAT0: SR3011.2 U3002.111(SMDAT0/GPB4)
SML0_CLK: C2306.1 R2329.2 U2000.AY44(GPP_C3/SML0CLK)
SML0_DATA: C2307.1 R2330.2 U2000.BB39(GPP_C4/SML0DATA)
SML1_CLK: R3034.2 SR3004.2 U3002.115(SMCLK1/GPC1)
SML1_DATA: R3035.2 SR3003.2 U3002.116(SMDAT1/GPC2)
SPI_CLK: C2204.1 CON4402.7 R3043.1 R3157.2 SR2213.1
SPI_CLK_L500MIL: SR2213.2 U2000.BC31(SPI0_CLK)
SPI_CLK_R: R3157.1 U3101.6(CLK)
SPI_CS0#: CON4402.5 R3041.1 R3117.1 SR2210.1 U3101.1(CS#)
SPI_CS0#_L500MIL: SR2210.2 U2000.BD31(SPI0_CS0#)
SPI_IO2: R3159.1 R4425.2 SR2215.1
SPI_IO2_L500MIL: SR2215.2 U2000.BC29(SPI0_IO2)
SPI_IO2_R: R3116.2 R3159.2 U3101.3(WP#(IO2))
SPI_IO3: CON4402.10 R3158.2 SR2214.1
SPI_IO3_L500MIL: SR2214.2 U2000.BD30(SPI0_IO3)
SPI_IO3_R: R3124.2 R3158.1 U3101.7(HOLD#/RESET#(IO3))
SPI_MISO: CON4402.6 R3099.1 R3160.1 SR2212.1
SPI_MISO_EC: R3099.2 U3002.103(FMISO/GPG5)
SPI_MISO_L500MIL: SR2212.2 U2000.BE30(SPI0_MISO)
SPI_MISO_R: R3160.2 U3101.2(DO(IO1))
SPI_MOSI: CON4402.8 R3004.1 R3044.1 R3156.2 R4414.2 SR2211.1
SPI_MOSI_L500MIL: SR2211.2 U2000.BB29(SPI0_MOSI)
SPI_MOSI_R: R3101.2 R3156.1 U3101.5(DI(IO0))
SRTCRST#: C2827.1 R2802.1 R2810.2 U2000.BB10(SRTCRST#)
SSD_PRESENT: CON5103.1 T5102.1
SSD_PRESENT1: CON5104.1 T5104.1
STRAP0: R7401.1 R7404.2 U7000.BL3(STRAP0)
STRAP1: R7412.1 R7413.2 U7000.BL4(STRAP1)
STRAP2: R7415.1 R7416.2 U7000.BM4(STRAP2)
STRAP3: R7418.1 R7420.2 U7000.BM5(STRAP3)
STRAP4: R7417.2 R7421.1 U7000.BK5(STRAP4)
STRAP5: R7422.1 R7424.2 U7000.BJ5(STRAP5)
SURGE_IN_C: C3400.1 U3401.1(TCT1) U3401.4(TCT2) U3401.7(TCT3) U3401.10(TCT4)
SURGE_OUT_C: C3401.1 R3400.2 R3401.2 R3402.2 R3403.2
SUS_PWRGD: D9200.2(CATHODE) R9202.2 SR9210.2 T9205.1 U3002.67(ADC1/GPI1) U8100.7(PGOOD)
