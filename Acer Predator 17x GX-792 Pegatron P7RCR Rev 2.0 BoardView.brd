# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Nets (continued)
SUSB#_PWR: D9400.2(CATHODE) JP9301.2 Q9102.2(BASE1) R8304.1 R8402.1 R9104.1 R9106.1 R9112.1 R9403.1 SR9101.2 T9108.1 T9301.1
SUSB_EC#: D9201.2(CATHODE) R3029.1 R3074.2 R3079.2 R9204.1 SR9101.1 U2404.2(B)
SUSC#_PWR: D8301.2(CATHODE) D9500.1(ANODE) JP9302.2 Q9103.2(BASE1) R8307.1 R9100.1 R9105.1 R9503.1 SR5702.1 SR9103.2 T9111.1 T9302.1
SUSC_EC#: R3030.1 R3075.2 R3080.2 SR9103.1
SUSC_PWR: Q5706.3(DRAIN) Q5707.1(GATE) Q5710.1(GATE) R5709.2
SUSWARN#: R2263.1 R3011.2 R3098.2 R30101.2 U2000.BD19(GPP_A13/SUSWARN#/SUSPWRDNACK)
SW0: R4624.1 U4601.2(SW0)
SW1: R4626.1 U4601.1(SW1)
SYS_PEX_RST_MON#: R7004.2 R7443.2 U7000.BE2(GPIO16) U7003.1(A)
SYS_PWROK: R2489.1 SR3016.2 U2403.1(A)
SYS_PWROK_R: R3006.2 SR3016.1 U3002.33(GINT/CTS0#/GPD5)
SYS_RESET#: R2451.2 SR4407.2 U2000.AW1(SYS_RESET#)
TBT_BATLOW_N: R1132.1 U1101.F2(POC_GPIO_4)
TBT_CIO_PLUG_EVENT_N: R1146.1 R2247.2 R2257.1 SR1103.2 U2000.R39(GPP_G12/GSXDOUT)
TBT_CIO_PLUG_EVENT_N_R: SR1103.1 U1101.W2(GPIO_5)
TBT_CLKREQ_N: R1109.2 R1111.1 R2482.2 R2483.2 U1102.4(Y)
TBT_CLKREQ_N_R: R2412.2 R2483.1 R2487.2 U2000.BD25(GPP_B8/SRCCLKREQ3#)
TBT_EE_CLK: U1101.AB4(EE_CLK) U1103.6(CLK) U1201.A3(SPI_CLK)
TBT_EE_CS_N: R1105.1 U1101.AC3(EE_CS_N) U1103.1(CS#) U1201.B3(SPI_SSZ)
TBT_EE_DI: U1101.AB3(EE_DI) U1103.5(DI(IO0)) U1201.B4(SPI_MOSI)
TBT_EE_DO: R1104.1 U1101.AC4(EE_DO) U1103.2(DO(IO1)) U1201.A4(SPI_MISO)
TBT_EE_WP_N: R1103.1 U1101.V1(GPIO_2) U1103.3(WP#(IO2))
TBT_FORCE_PWR: R1133.1 R2259.2 SR1102.2 U2000.P43(GPP_G16/GSXCLK)
TBT_FORCE_PWR_R: SR1102.1 U1101.H4(POC_GPIO_3)
TBT_HOLD_N: R1106.1 U1103.7(HOLD#(IO3))
TBT_HWRESET: R1240.2 R3036.1 R3042.2 R3045.1 U3002.98(GPH5/ID5)
TBT_HWRESET_PCH: R1244.2 R2245.2 R2256.1 U2000.L43(GPP_G23)
TBT_HWRESET_R: R1240.1 R1241.1 R1244.1 U1201.D6(HRESET/GND_3)
TBT_I2C_SCL: R1141.1 U1101.U2(GPIO_1) U1201.D2(I2C_SCL1)
TBT_I2C_SDA: R1140.1 U1101.U1(GPIO_0) U1201.D1(I2C_SDA1)
TBT_MRESET: R1222.1 R3092.2 U1201.E11(MRESET)
TBT_MRESET_EC: R3080.1 R3092.1 U3002.82(EGAD/GPE1)
TBT_PCIE_RX0_N: C1102.1 U2000.K19(PCIE5_RXN)
TBT_PCIE_RX0_P: C1101.1 U2000.L19(PCIE5_RXP)
TBT_PCIE_RX1_N: C1104.1 U2000.G22(PCIE6_RXN)
TBT_PCIE_RX1_P: C1103.1 U2000.E22(PCIE6_RXP)
TBT_PCIE_RX2_N: C1106.1 U2000.L22(PCIE7_RXN)
TBT_PCIE_RX2_P: C1105.1 U2000.K22(PCIE7_RXP)
TBT_PCIE_RX3_N: C1108.1 U2000.K24(PCIE8_RXN)
TBT_PCIE_RX3_P: C1107.1 U2000.L24(PCIE8_RXP)
TBT_PCIE_TX0_N: C2001.1 U1101.Y22(PCIE_RX0_N)
TBT_PCIE_TX0_N_C: C2001.2 U2000.D22(PCIE5_TXN)
TBT_PCIE_TX0_P: C2000.1 U1101.Y23(PCIE_RX0_P)
TBT_PCIE_TX0_P_C: C2000.2 U2000.C22(PCIE5_TXP)
TBT_PCIE_TX1_N: C2014.1 U1101.T22(PCIE_RX1_N)
TBT_PCIE_TX1_N_C: C2014.2 U2000.B22(PCIE6_TXN)
TBT_PCIE_TX1_P: C2015.1 U1101.T23(PCIE_RX1_P)
TBT_PCIE_TX1_P_C: C2015.2 U2000.A23(PCIE6_TXP)
TBT_PCIE_TX2_N: C2016.1 U1101.M22(PCIE_RX2_N)
TBT_PCIE_TX2_N_C: C2016.2 U2000.C23(PCIE7_TXN)
TBT_PCIE_TX2_P: C2017.1 U1101.M23(PCIE_RX2_P)
TBT_PCIE_TX2_P_C: C2017.2 U2000.B23(PCIE7_TXP)
TBT_PCIE_TX3_N: C2018.1 U1101.H22(PCIE_RX3_N)
TBT_PCIE_TX3_N_C: C2018.2 U2000.C24(PCIE8_TXN)
TBT_PCIE_TX3_P: C2019.1 U1101.H23(PCIE_RX3_P)
TBT_PCIE_TX3_P_C: C2019.2 U2000.B24(PCIE8_TXP)
TBT_PCIE_WAKE_N: R1138.1 R2305.2 U1101.W1(GPIO_4) U2000.AG44(GPP_D21)
TBT_RBIAS: R1107.2 U1101.H6(RBIAS)
TBT_REFCLK_100_N: SR2520.2 U1101.T19(PCIE_REFCLK_100_IN_N)
TBT_REFCLK_100_N_R: SR2520.1 U2000.E5(CLKOUT_PCIE_N3)
TBT_REFCLK_100_P: SR2519.2 U1101.V19(PCIE_REFCLK_100_IN_P)
TBT_REFCLK_100_P_R: SR2519.1 U2000.G4(CLKOUT_PCIE_P3)
TBT_RESET_N: SR1105.2 U1201.F11(RESETZ)
TBT_RSENSE: R1107.1 U1101.J6(RSENSE)
TBT_SLP_S3_N: R1131.1 SR1104.1 U1101.D2(POC_GPIO_5)
TBT_SLP_S3_N_BUF: R1117.2 SR1104.2 U1105.4(Y)
TBT_SNK1_DDC_CLK: R1143.1 R1169.2 U1101.Y8(DPSNK1_DDC_CLK)
TBT_SNK1_DDC_DATA: R1144.1 R1170.2 U1101.N4(DPSNK1_DDC_DATA)
TBT_TCK: R1114.2 T1103.1 U1101.T4(TCK)
TBT_TDI: R1112.2 T1101.1 U1101.Y4(TDI)
TBT_TDO: R1115.2 T1104.1 U1101.W4(TDO)
TBT_TEST_EN: R1128.1 U1101.E1(TEST_EN)
TBT_TEST_PWG: R1129.1 U1101.AB5(TEST_PWR_GOOD)
TBT_TMS: R1113.2 T1102.1 U1101.V4(TMS)
TBT_TMU_CLK_OUT: R1139.1 U1101.V2(GPIO_3)
TBT_XTAL_25_IN: C1130.1 R1136.2 X1101.1
TBT_XTAL_25_IN_TBT: R1136.1 U1101.D22(XTAL_25_IN)
TBT_XTAL_25_OUT: C1131.1 R1137.2 X1101.3
TBT_XTAL_25_OUT_TBT: R1137.1 U1101.D23(XTAL_25_OUT)
TBTA_AUX_N: C1136.2 U1101.W15(PA_DPSRC_AUX_N)
TBTA_AUX_P: C1137.2 U1101.Y15(PA_DPSRC_AUX_P)
TBTA_CA2HD_0_N_CON: CON1201.B10(SSRXN1) D1204.1 U1101.A21(PA_RX0_N)
TBTA_CA2HD_0_P_CON: CON1201.B11(SSRXP1) D1203.1 U1101.B21(PA_RX0_P)
TBTA_CA2HD_1_N_CON: CON1201.A10(SSRXN2) D1208.1 U1101.B15(PA_RX1_N)
TBTA_CA2HD_1_P_CON: CON1201.A11(SSRXP2) D1207.1 U1101.A15(PA_RX1_P)
TBTA_DPSRC_AUX_N: C1136.1 R1155.1 U1201.J2(AUX_N)
TBTA_DPSRC_AUX_P: C1137.1 R1154.1 U1201.J1(AUX_P)
TBTA_HD2CA_0_N_CON: C1135.2 CON1201.A3(SSTXN1) D1201.1
TBTA_HD2CA_0_P_CON: C1134.2 CON1201.A2(SSTXP1) D1202.1
TBTA_HD2CA_1_N_CON: C1133.2 CON1201.B3(SSTXN2) D1205.1
TBTA_HD2CA_1_P_CON: C1132.2 CON1201.B2(SSTXP2) D1206.1
TBTA_HPD: R1120.1 R1121.1 U1201.C10(GPIO4)
TBTA_I2C_INT: R1145.1 U1101.J4(POC_GPIO_0) U1201.C1(I2C_IRQ1Z)
TBTA_LSRX: R1122.1 U1101.A4(PA_LSRX) U1201.K4(LSX_P2R)
TBTA_LSTX: R1118.1 U1101.A5(PA_LSTX) U1201.L4(LSX_R2P)
TBTA_TX0_N: C1135.1 U1101.B19(PA_TX0_N)
TBTA_TX0_P: C1134.1 U1101.A19(PA_TX0_P)
TBTA_TX1_N: C1133.1 U1101.B17(PA_TX1_N)
TBTA_TX1_P: C1132.1 U1101.A17(PA_TX1_P)
TBTA_USB2_D_N: R1215.1 R1216.1 U1101.D20(PA_USB2_D_N)
TBTA_USB2_D_N_CC: R1215.2 R1221.1 U1201.K5(USB_RP_N)
TBTA_USB2_D_N_CHG: R1216.2 U1202.2(DM_OUT)
TBTA_USB2_D_P: R1213.1 R1214.1 U1101.E20(PA_USB2_D_P)
TBTA_USB2_D_P_CC: R1213.2 R1217.1 U1201.L5(USB_RP_P)
TBTA_USB2_D_P_CHG: R1214.2 U1202.3(DP_OUT)
TBTA_USB2_RBIAS: R1123.2 U1101.H19(PA_USB2_RBIAS)
TBTB_I2C_INT: R1135.1 U1101.E2(POC_GPIO_1)
TC: R9714.1 U9702.13(TC)
THRO_CPU: Q0702.1(GATE) U3002.123(CTX0/TMA0/GPB2)
TP_ATTN#: CON3104.4 Q2301.2(SOURCE) R2310.2 R2363.2 R2382.2
TP_ATTN#_Q: Q2301.3(DRAIN) R2381.2 R2382.1 U2000.AH43(GPP_D22)
TP_BL_EN: Q3107.1(GATE) R2435.2 U2000.AW33(GPP_H7/SRCCLKREQ13#)
TP_BTN#: CON3104.11 R3081.2 U3002.128(GPJ6)
TP_CHA_XMM3_S2: CON1600.162(C0/CS2_N/NC) CON1601.162(C0/CS2_N/NC) T1601.1 T1602.1
TP_CHA_XMM3_S3: CON1600.165(C1/CS3_N/NC) CON1601.165(C1/CS3_N/NC) T1600.1 T1603.1
TP_CHB_XMM1_S2: CON1700.162(C0/CS2_N/NC) CON1701.162(C0/CS2_N/NC) T1702.1 T1703.1
TP_CHB_XMM1_S3: CON1700.165(C1/CS3_N/NC) CON1701.165(C1/CS3_N/NC) T1700.1 T1701.1
TP_CK_48M_USB_SEVR_ONLY: T2204.1 U2000.AR17(GPP_A16/CLKOUT_48)
TP_CLK_I2C: R2313.2 SR3106.2 U2301.3(D)
TP_CLK_I2C_CON: CON3104.5 SR3106.1
TP_CLK_I2C_PCH: R2379.2 U2000.AR38(GPP_C17/I2C0_SCL) U2301.4(S)
TP_DATA_I2C: R2312.2 SR3105.2 U2301.6(D)
TP_DATA_I2C_CON: CON3104.6 SR3105.1
TP_DATA_I2C_PCH: R2380.2 U2000.AT42(GPP_C16/I2C0_SDA) U2301.1(S)
TP_EXIT_HOLDOFF#: R2262.1 T2203.1 U2000.BB17(GPP_A12/BMBUSY#/ISH_GP6/SX_EXIT)
TP_GPD7_RSVD: T2410.1 U2000.BD14(GPD7/RSVD)
TP_GPP_B11: T2400.1 U2000.AN24(GPP_B11)
TP_GPP_G0_TACH0: R2207.2 U2000.U43(GPP_G0/FAN_TACH_0)
TP_GPP_H_18: R2473.2 U2000.BC36(GPP_H18/SML4ALERT#)
TP_LANPHYPC: T2409.1 U2000.AR15(GPD11/LANPHYPC)
TP_LED_BLUE: CON3104.10 R2437.2 U2000.BD33(GPP_H9/SRCCLKREQ15#)
TP_LED_RED: CON3104.9 R2436.2 U2000.BB33(GPP_H8/SRCCLKREQ14#)
TP_PCH_RSVD_BD1: T2500.1 U2000.BD1(RSVD20)
TP_PCH_RSVD_BE2: T2501.1 U2000.BE2(RSVD21)
TP_PS2_CLK: C3103.1 CON3104.8 D3102.1(ANODE) R3073.2 U3002.89(PS2CLK2/GPF4)
TP_PS2_DAT: C3102.1 CON3104.7 D3101.1(ANODE) R3072.2 U3002.90(PS2DAT2/GPF5)
TP_SENSOR: CON3104.3 R2434.2 U2000.BA33(GPP_H6/SRCCLKREQ12#)
TP_SPI0_CS1#: T2202.1 U2000.AW31(SPI0_CS1#)
TP_SPI0_CS2#: T2201.1 U2000.AT31(SPI0_CS2#)
TS1#: CON6000.5 JP9000.2 R6001.2
TS_VREF: T7401.1 U7000.BF12(TS_VREF)
UART0_DEBUG_RXD: CON4402.4 U2000.BA41(GPP_C8/UART0_RXD)
UART0_DEBUG_TXD: CON4402.2 U2000.AV44(GPP_C9/UART0_TXD)
USB2_COMP: R2526.2 U2000.AG3(USB2_COMP)
USB2_ID: SR2001.2 U2000.AG2(USB2_ID)
USB2_VBUSSENSE: R2000.1 U2000.AD10(USB2_VBUSSENSE)
USB3_RX_H_N1: CON5500.5(STDA_SSRX-) L5500.3 RN5500.2(Y) U5500.1(CH1) U5500.10(N.C.4)
USB3_RX_H_N2: CON5501.5(STDA_SSRX-) L5503.3 RN5503.2(Y) U5502.1(CH1) U5502.10(N.C.4)
USB3_RX_H_P1: CON5500.6(STDA_SSRX+) L5500.2 RN5500.4(Y) U5500.2(CH2) U5500.9(N.C.3)
USB3_RX_H_P2: CON5501.6(STDA_SSRX+) L5503.2 RN5503.4(Y) U5502.2(CH2) U5502.9(N.C.3)
USB3_RX_N1: L5500.4 RN5500.1(X) U2000.G13(USB3_5_RXN)
USB3_RX_N2: L5503.4 RN5503.1(X) U2000.C8(USB3_2_RXN/SSIC_1_RXN)
USB3_RX_N3: CON6700.34 U2000.B10(USB3_3_RXN/SSIC_2_RXN)
USB3_RX_N4: CON6700.43 U2000.E11(USB3_4_RXN)
USB3_RX_N6: CON6700.5 U2000.K15(USB3_6_RXN) U6701.5(CH4) U6701.6(N.C.1)
USB3_RX_P1: L5500.1 RN5500.3(X) U2000.H13(USB3_5_RXP)
USB3_RX_P2: L5503.1 RN5503.3(X) U2000.B8(USB3_2_RXP/SSIC_1_RXP)
USB3_RX_P3: CON6700.33 U2000.A9(USB3_3_RXP/SSIC_2_RXP)
USB3_RX_P4: CON6700.42 U2000.G11(USB3_4_RXP)
USB3_RX_P6: CON6700.6 U2000.K13(USB3_6_RXP) U6701.4(CH3) U6701.7(N.C.2)
USB3_TX_H_N1: CON5500.8(STDA_SSTX-) L5502.3 RN5502.2(Y) U5500.4(CH3) U5500.7(N.C.2)
USB3_TX_H_N2: CON5501.8(STDA_SSTX-) L5505.3 RN5505.2(Y) U5502.4(CH3) U5502.7(N.C.2)
USB3_TX_H_P1: CON5500.9(STDA_SSTX+) L5502.2 RN5502.4(Y) U5500.5(CH4) U5500.6(N.C.1)
USB3_TX_H_P2: CON5501.9(STDA_SSTX+) L5505.2 RN5505.4(Y) U5502.5(CH4) U5502.6(N.C.1)
USB3_TX_N1: C5509.1 U2000.B14(USB3_5_TXN)
USB3_TX_N1_C: C5509.2 L5502.4 RN5502.1(X)
USB3_TX_N2: C5511.1 U2000.B12(USB3_2_TXN/SSIC_1_TXN)
USB3_TX_N2_C: C5511.2 L5505.4 RN5505.1(X)
USB3_TX_N3: C6709.1 U2000.C13(USB3_3_TXN/SSIC_2_TXN)
USB3_TX_N3_C: C6709.2 CON6700.31
USB3_TX_N4: C6711.1 U2000.A14(USB3_4_TXN)
USB3_TX_N4_C: C6711.2 CON6700.40
USB3_TX_N6: CON6700.8 U2000.B15(USB3_6_TXN) U6701.2(CH2) U6701.9(N.C.3)
USB3_TX_P1: C5508.1 U2000.C14(USB3_5_TXP)
USB3_TX_P1_C: C5508.2 L5502.1 RN5502.3(X)
USB3_TX_P2: C5510.1 U2000.A12(USB3_2_TXP/SSIC_1_TXP)
USB3_TX_P2_C: C5510.2 L5505.1 RN5505.3(X)
USB3_TX_P3: C6708.1 U2000.D13(USB3_3_TXP/SSIC_2_TXP)
USB3_TX_P3_C: C6708.2 CON6700.30
USB3_TX_P4: C6710.1 U2000.B13(USB3_4_TXP)
USB3_TX_P4_C: C6710.2 CON6700.39
USB3_TX_P6: CON6700.9 U2000.C15(USB3_6_TXP) U6701.1(CH1) U6701.10(N.C.4)
USB_CHG_CTL1: R1209.1 R3017.2 R3019.2 SR5201.1
USB_CHG_CTL2: R5209.2 R5210.1 SR5202.1
USB_CHG_CTL2_EC: R1248.1 R5211.1 U3002.96(GPH3/ID3)
USB_CHG_CTL2_TBT: R1201.2 R1203.1 R1210.1
USB_CHG_CTL3: R1212.1 SR5203.1 U3002.81(DAC5/RIG0#/GPJ5)
USB_CHG_EN: R1238.1 R3012.2 R3021.2 T5201.1 T9713.1 U5200.5(EN)
USB_PWEN: CON6700.25 R5501.2 U3002.80(DAC4/DCD0#/GPJ4) U5501.4(EN)
USBN1: U2000.AF5(USB2N_1) U5200.2(DM_OUT)
USBN1_CHARGE: L5501.4 RN5501.1(X) U5200.11(DM_IN)
USBN2: L5504.4 RN5504.1(X) U2000.AD5(USB2N_2)
USBN3: CON6700.37 U2000.AG8(USB2N_3)
USBN4: CON6700.28 U2000.AE1(USB2N_4)
USBN7: L5301.2 RN5301.4(Y) U2000.AB3(USB2N_7)
USBN7_C: CON5300.5 L5301.1 RN5301.3(X)
USBN9: L4500.1 RN4500.3(X) U2000.AA1(USB2N_9)
USBN10: CON6700.2 D6701.1(ANODE) U2000.AJ8(USB2N_10)
USBP1: U2000.AG7(USB2P_1) U5200.3(DP_OUT)
USBP1_CHARGE: L5501.1 RN5501.3(X) U5200.10(DP_IN)
USBP2: L5504.1 RN5504.3(X) U2000.AD7(USB2P_2)
USBP3: CON6700.36 U2000.AG10(USB2P_3)
USBP4: CON6700.27 U2000.AE2(USB2P_4)
USBP7: L5301.3 RN5301.2(Y) U2000.AB2(USB2P_7)
USBP7_C: CON5300.3 L5301.4 RN5301.1(X)
USBP9: L4500.4 RN4500.1(X) U2000.AA2(USB2P_9)
USBP10: CON6700.3 D6702.1(ANODE) U2000.AJ7(USB2P_10)
V_SA0_DIMM0_CHA: CON1600.256(SA0) R1604.2 R1613.1
V_SA0_DIMM0_CHB: CON1701.256(SA0) R1704.2 R1715.1
V_SA0_DIMM1_CHA: CON1601.256(SA0) R1607.2 R1617.1
V_SA0_DIMM1_CHB: CON1700.256(SA0) R1707.2 R1712.1
V_SA1_DIMM0_CHA: CON1600.260(SA1) R1605.2 R1614.1
V_SA1_DIMM0_CHB: CON1701.260(SA1) R1705.2 R1716.1
V_SA1_DIMM1_CHA: CON1601.260(SA1) R1608.2 R1618.1
V_SA1_DIMM1_CHB: CON1700.260(SA1) R1708.2 R1713.1
V_SA2_DIMM0_CHA: CON1600.166(SA2) R1606.2 R1615.1
V_SA2_DIMM0_CHB: CON1701.166(SA2) R1706.2 R1717.1
V_SA2_DIMM1_CHA: CON1601.166(SA2) R1609.2 R1619.1
V_SA2_DIMM1_CHB: CON1700.166(SA2) R1709.2 R1719.1
VCLK: C8120.2 C8122.1 T8119.1 U8100.19(VCLK)
VCORE_EC: C3015.2 U3002.12(VCORE)
VCORE_VCCSENSE: C8000.1 C8025.1 R80112.2 SR8012.1 U0300.AG37(VCC_SENSE)
VCORE_VSSSENSE: C8002.1 C8025.2 R8000.1 SR8013.1 U0300.AG38(VSS_SENSE)
VGA_DDR_BST1: SR8901.1 U8900.1(BOOT1)
VGA_DDR_BST1_R: C8903.1 SR8901.2
VGA_DDR_BST2: SR8910.1 U8900.15(BOOT2)
VGA_DDR_BST2_R: C8929.1 SR8910.2
VGA_DDR_HG1: SR8909.1 U8900.2(UGATE1)
VGA_DDR_HG1_R: Q8901.4(G) SR8909.2
VGA_DDR_HG2: SR8911.1 U8900.14(UGATE2)
VGA_DDR_HG2_R: Q8904.4(G) SR8911.2
VGA_DDR_LG1: Q8903.4(G) U8900.19(LGATE1)
VGA_DDR_LG2: Q8902.4(G) U8900.17(LGATE2)
VGA_DDR_LX1: C8903.2 L8900.1 Q8901.1(S_1) Q8901.2(S_2) Q8901.3(S_3) Q8903.5(D) R8904.1 T8900.1 U8900.20(PHASE1)
VGA_DDR_LX2: C8929.2 L8901.1 Q8902.5(D) Q8904.1(S_1) Q8904.2(S_2) Q8904.3(S_3) R8917.1 U8900.16(PHASE2)
VGA_DDR_PG: R9208.1 SR8908.1 T9211.1
VGA_DDR_PG_R: SR8908.2 U8900.13(PGOOD)
VGA_DDR_RC1: C8906.1 R8904.2
VGA_DDR_RC2: C8927.1 R8917.2
VGA_DDR_REFIN: C8909.1 R8900.2 R8901.2 U8900.7(REFIN)
VGA_DDR_TON: R8907.1 R8910.1 U8900.9(TON)
VGA_DDR_VCCP: C8910.1 R8905.2 U8900.18(PVCC)
VGA_DDR_VID: SR8904.2 U8900.5(VID)
VGA_DDR_VREF: C8908.1 R8900.1 U8900.8(VREF)
VGA_DDR_VRON: C8904.1 D8900.1(ANODE) SR8903.2 U8900.3(EN)
VID_PLLVDD_GPU_AW27: C7217.1 SR7201.2 U7000.BD12(SP_PLLVDD)
VID_PLLVDD_GPU_AW28: C7210.1 SR7202.2 U7000.BC12(VID_PLLVDD)
VIDALERT#: R0708.1 R0717.2 R80148.2 SR8008.1
VIDSCLK: R0747.2 R8012.2 R80149.2 U0300.BH32(VIDSCK)
VIDSOUT: R0707.2 R8014.2 R80147.2 U0300.BH29(VIDSOUT)
VLDOIN: C8308.1 SR8300.2 U8300.19(VLDOIN)
VR_ENABLE: SR8010.2 SR8011.2 U8000.48(VR_ENABLE)
VR_HOT#: SR8009.2 U8000.46(VR_HOT#)
VRDUTY_PHASE_Q: Q7407.1(GATE) R74104.1 R74105.2
VRDUTY_PU_Q: Q7407.3(DRAIN) R74102.2 R74103.2
VREF_CA_RC: C0501.2 R0510.1
VRM_PWRGD: D2401.1(ANODE) D9202.1(ANODE) R2402.2 R4417.2 R9203.2 SR9206.2 T9207.1 U8000.47(VR_READY) U9201.1(A)
VSADJ: R1321.2 U1301.18(VSADJ)
VSUS_ON: D8200.2(CATHODE) JP9303.2 Q8106.6(D) R3061.2 R3064.2 R8108.1 R8110.1 R8111.2 R8201.1 SR5704.1 T9303.1 U3002.19(L80HLAT/BAO/GPE0)
VSUS_ON_EN: C8118.1 Q8106.3(D) R8109.1 R8110.2 SR8103.1
VSUS_ON_T: Q5711.1(GATE) Q5712.3(DRAIN) Q5713.1(GATE) R5715.2
WAKE#: SR3301.2 U3300.3(WAKEN)
WAKE_PCIE#: D5301.1(ANODE) D5302.1(ANODE) R2446.2 SR3301.1 U2000.BC13(WAKE#)
WAKE_WIGI: CON5300.70 Q5304.2(SOURCE) R5309.1 T5307.1
WAKE_WLAN: CON5300.55 Q5303.2(SOURCE) R5307.1 R5314.1 T5302.1
WARNING: R7445.2 R9712.1 SR9713.2 U7000.BB4(GPIO28) U9702.8(WARNING)
WIGI_RST#: R2211.1 R5356.2
WIGI_RST#_PCH: R2211.2 U2000.BC19(GPP_A17/ISH_GP7)
WLAN/WIGIG_LED: CON5300.6 T5303.1
WLAN_DISABLE#: C5342.1 CON5300.56 R5308.2 U2000.AB44(GPP_F4/SATAXPCIE7/SATAGP7)
WLAN_RST#: R5341.2 SR3002.2
WLAN_RST#_EC: SR3002.1 U3002.97(GPH4/ID4)
WLAN_SUSCLK: R2401.1 SR5301.1
WLAN_SUSCLK_R: CON5300.50 SR5301.2
WLAN_WAKE#: R3036.2 R5314.2
XCLK_BIASREF: R2512.1 U2000.E1(XCLK_BIASREF)
XDP1_JTAG_TCK: SR4403.1 XDP4400.55
XDP1_PIN60: R4425.1 SR4410.1 XDP4400.60
XDP_PCUDEBUG3: R4422.1 R4424.2 XDP4400.1
XTAL24_IN_NO_IO: C2503.1 R2522.2 R2524.2 Y2501.3
XTAL24_IN_R: R2522.1 U2000.A6(XTAL24_IN)
XTAL24_OUT_NO_IO: R2529.1 U2000.A5(XTAL24_OUT)
XTAL24_OUT_R: C2502.1 R2524.1 R2529.2 Y2501.1
XTALIN: C7215.1 U7000.BL6(XTAL_IN) X7200.1
XTALOUT: C7216.1 U7000.BM6(XTAL_OUT) X7200.3
XTALOUTBUFF_R: R7208.1 R7211.2 U7000.BK6(XTAL_OUTBUFF)
XTALSSIN: R7205.2 R7210.2 U7000.BJ6(XTAL_SSIN)
Y5_R: C2500.1 R2525.1 Y2500.1
ZVM_TP: T1000.1 U0300.AT13(ZVM#)
N17740100: R8102.1 U8100.1(CS1)
N17742210: R8103.1 U8100.5(CS2)
N21533547: C8310.1 R8300.2 U8300.9(TON)
N23400012: D9200.1(ANODE) R9200.2 R9206.2 R9207.2 R9208.2 R9215.2 R9216.2 SR9204.2 SR9207.2 SR9208.2 SR9209.2 U9200.1(A) U9200.2(B)
N25316574: Q9200.5(G) R9214.2 SR9206.1 U9201.4(Y)
N59712038: SR8813.2 U8800.7(IADP)
N59900925: D9201.1(ANODE) R9205.2
N60195343: SR8900.1 SR8902.2 SR8903.1
N60195463: C8915.1 R8907.2 R8912.1
N60195527: C8912.1 R8911.2 U8900.12(OCSET/SS)
N60250597: C9118.1 R9105.2 U9102.3(EN1)
N60250604: C9120.1 R9106.2 U9102.5(EN2)
N60250715: C9124.1 U9102.12(CT1)
N60250719: C9123.1 U9102.10(CT2)
N60253878: C9100.1 R9100.2 U9100.3(EN1)
N60253885: C9103.1 R9112.2 U9100.5(EN2)
N60253996: C9109.1 U9100.12(CT1)
N60254000: C9108.1 U9100.10(CT2)
N60314877: C9111.1 R9104.2 U9101.3(ON1) U9101.5(ON2)
N60314934: C9117.1 U9101.12(CT1)
N60315047: C9116.1 U9101.10(CT2)
N65022721: SR8802.2 U8800.12(SCL)
N65022802: C8814.2 D8804.2(CATHODE) D8805.2(CATHODE) U8800.6(ACDET)
N65023456: C8806.1 R8801.1
N65023505: SR8801.2 U8800.11(SDA)
N68998160: Q8805.1(GATE) R8816.1 R8817.2
N68998162: C8827.1 Q8805.3(DRAIN) R8815.2 SR8807.1
N125017610: T0301.1 U0300.A33(EDP_DISP_UTIL)
N125034509: R1000.2 U0300.BJ17(VCCOPC_1) U0300.BJ19(VCCOPC_2) U0300.BJ20(VCCOPC_3) U0300.BK17(VCCOPC_4) U0300.BK19(VCCOPC_5) U0300.BK20(VCCOPC_6) U0300.BL16(VCCOPC_7) U0300.BL17(VCCOPC_8) U0300.BL18(VCCOPC_9) U0300.BL19(VCCOPC_10) U0300.BL20(VCCOPC_11) U0300.BL21(VCCOPC_12) U0300.BM17(VCCOPC_13) U0300.BN17(VCCOPC_14)
N125034565: R1002.2 U0300.BJ23(RSVD_9) U0300.BJ26(RSVD_10) U0300.BJ27(RSVD_11) U0300.BK23(RSVD_16) U0300.BK26(RSVD_17) U0300.BK27(RSVD_18) U0300.BL23(RSVD_21) U0300.BL24(RSVD_22) U0300.BL25(RSVD_23) U0300.BL26(RSVD_24) U0300.BL27(RSVD_25) U0300.BL28(RSVD_26) U0300.BM24(RSVD_30)
N126050588: R2120.2 R2121.1 U2000.AC44(GPP_E12/USB2_OC3#)
N126051220: R2148.1 U2000.W35(GPP_F20/EDP_BKLTEN)
N126053407: R2249.2 R2258.1 U2000.N44(GPP_G17/ADR_COMPLETE)
N126053413: R2208.2 U2000.U42(GPP_G1/FAN_TACH_1)
N126053417: R2209.2 U2000.U41(GPP_G2/FAN_TACH_2)
N126053497: R2243.2 U2000.U35(GPP_G21)
N126053501: R2244.2 R2255.1 U2000.L44(GPP_G22)
N126053667: R2201.1 R2204.2 U2000.M45(GPP_G19/SMI#)
N126061486: R2333.2 R2347.2 U2000.BA40(GPP_C5/SML0ALERT#)
N126061517: C2308.1 R2331.2 U2000.AW42(GPP_C6/SML1CLK)
N126061523: C2309.1 R2332.2 U2000.AW45(GPP_C7/SML1DATA)
N126061775: R2302.2 U2000.AL39(GPP_D0)
N126061781: R2303.2 U2000.AN38(GPP_D2)
N126061784: R2304.2 U2000.AN41(GPP_D3)
N126071044: R2472.2 U2000.AW35(GPP_H11/SML2DATA)
N126071761: R2429.2 U2000.AR31(GPP_H1/SRCCLKREQ7#)
N126071895: C2401.1 R2448.2 U2000.BE11(INTRUDER#)
N126072312: R2406.2 R2426.1 SR2410.1 U2000.AR27(GPP_B0)
N126072357: T2408.1 U2000.BC26(GPP_B12/SLP_S0#)
N126072385: T2404.1 U2000.BC15(GPD6/SLP_A#)
N126072389: T2402.1 U2000.AV15(SLP_LAN#)
N126072391: T2401.1 U2000.BB13(SLP_SUS#)
N126075660: R2616.1 R2619.1 U2000.BE41(VCCSPI1) U2000.BE42(VCCSPI2) U2000.BE43(VCCSPI3)
N126076879: C2602.1 C2603.1 C2604.1 SR2606.1 U2000.AD41(VCCPGPPG) U2000.AJ41(VCCPGPPEF1) U2000.AL41(VCCPGPPEF2) U2000.BC42(VCCPGPPBCH1) U2000.BD40(VCCPGPPBCH2)
N126183850: R0734.2 U0300.BN1(PROC_SELECT#)
N126273757: R1011.2 U0300.BL14(VCC_OPC_1P8_1) U0300.BM14(VCC_OPC_1P8_2)
N126273866: R1013.1 U0300.AY13(RSVD_5)
N126273877: R1013.2 U0300.AU13(RSVD_4)
N126462372: C1000.1 SR1001.1 U0300.Y12(VDDQC)
N126463138: T1003.1 U0300.H14(VCCIO_SENSE)
N126463140: T1002.1 U0300.J14(VSSIO_SENSE)
N126721657: R1003.2 U0300.BL15(VCCOPC_SENSE) U0300.BM16(VSSOPC_SENSE)
N126721746: R1006.2 U0300.BP15(VCCEOPIO_1) U0300.BR15(VCCEOPIO_2) U0300.BT15(VCCEOPIO_3)
N126721910: R1007.2 U0300.BP16(RSVD_34) U0300.BR16(RSVD_36) U0300.BT16(RSVD_40)
N126721980: R1008.2 U0300.BM15(VSSEOPIO_SENSE) U0300.BN15(VCCEOPIO_SENSE)
N126722847: R1012.2 U0300.BJ35(RSVD_13) U0300.BJ36(RSVD_14)
N127662539: C3630.1 C3631.1 C3642.1 SR3602.2 U3600.9(DVDD-IO)
N129948629: R3306.2 U3300.10(RBIAS)
N129953010: SR3303.1 U3300.24(PPS)
N129960916: C3617.1 U3600.12(PCBEEP)
N129960923: C3617.2 C3618.1 R3606.1 R3607.1
N129962294: R3603.1 R3623.1 R3624.1 U3600.13(HP/LINE1_JD(JD1))
N129962530: C3601.1 R3600.1 U3600.27(LDO1-CAP)
N129962745: C3604.1 U3600.34(CPVEE)
N129962763: C3603.2 U3600.37(CBP)
N129963384: C3613.1 L3600.2 U3600.40(AVDD2)
N129963392: C3610.1 C3611.1 C3614.1 C3615.1 L3601.2 U3600.41(PVDD1) U3600.46(PVDD2)
N130075477: C3600.1 U3600.28(VREF)
N130159038: C3709.1 U3700.8(BYPASS)
N130159071: SR3701.2 U3700.7(PD#)
N130819676: R3102.1 R3103.1 R3104.1 R3105.1 R3112.2
N131362545: T3301.1 U3300.39(LED[1])
N131362585: T3302.1 U3300.38(LED[0])
N131439778: R1101.1 U1101.N16(PCIE_RBIAS)
N131441491: R1102.1 U1101.N6(DPSRC_RBIAS)
N131445423: R1108.1 U1101.Y18(DPSNK_RBIAS)
N131647000: R1121.2 U1101.M4(PA_DPSRC_HPD)
N131715858: SR1203.2 U1201.F1(I2C_ADDR)
N131716263: C1208.1 U1201.A2(LDO_1V8D)
N131716280: C1207.1 U1201.K1(LDO_1V8A)
N131716387: C1221.1 U1201.E1(LDO_BMC)
N135532945: R5201.1 U5200.16(ILIM_HI)
N135533052: R5200.1 U5200.15(ILIM_LO)
N135533327: SR5201.2 U5200.6(CTL1)
N135533333: R5211.2 SR5202.2 U5200.7(CTL2)
N135533339: SR5203.2 U5200.8(CTL3)
N135676971: C3603.1 U3600.35(CBN)
N135678655: C3612.1 U3600.39(LDO2-CAP)
N135704866: Q3601.1(S) Q3601.3(D) R3622.1
N135705316: Q3601.6(D) Q3602.1(GATE) R3604.2 R3622.2
N135709581: R3620.2 U3600.19(MIC_CAP)
N135714980: T3602.1 U3600.14(MIC2/LINE2_JD(JD2))
N135717456: C3640.1 U3600.21(LINE1-R(PORT-C-R))
N135717474: C3639.1 U3600.22(LINE1-L(PORT-C-L))
N135719044: R3621.2 U3600.20(VD33_STB)
N136259332: L1101.1 U1101.C1(SVR_IND_1) U1101.C2(SVR_IND_2) U1101.D1(SVR_IND_3)
N136259619: C1184.1 U1101.J16(VCC3P3_ANA_USB2)
N136259621: C1183.1 U1101.L16(VCC3P3_ANA_PCIE)
N136630757: SR2607.1 U2000.AD13(VCCATS)
N137154023: SR1101.1 U1101.L4(PERST_N)
N138223875: R2376.2 U2000.AJ35(GPP_D19/DMIC_CLK0)
N138223878: R2375.1 U2000.AH44(GPP_D20/DMIC_DATA0)
N138274096: R2402.1 R2496.1 R2497.2 U2404.1(A)
N138274106: R2498.2 U2404.4(Y)
N138278798: CON3104.12 SR3107.2
N138336439: CON5102.50 SR5104.2
N138434716: C5005.1 R5015.2 U5001.4(VSET)
N138434827: R5012.2 U5001.1(FSM#)
N138435027: C5006.1 R5016.2 U5002.4(VSET)
N138435047: R5013.2 U5002.1(FSM#)
N138940937: C8065.2 SR8005.2 U8001.3(VCC)
N138947971: C8054.1 R8050.1
N138948723: C8054.2 U8001.5(BOOT)
N138948726: R8050.2 U8001.7(PHASE)
N138949600: JP8050.1 R8056.2 R80125.2
N138949602: JP8051.1 R8057.2
N138949618: C8071.2 R8053.1
N138972993: C8066.2 SR8006.2 U8002.3(VCC)
N138973068: JP8052.1 R8058.2 R80130.2
N138973117: C8055.1 R8051.1
N138973148: C8055.2 U8002.5(BOOT)
N138973150: R8051.2 U8002.7(PHASE)
N138973254: JP8053.1 R8059.2
N138973270: C8072.2 R8054.1
N138993665: C8067.2 SR8007.2 U8003.3(VCC)
N138993706: JP8054.1 R8060.2 R80135.2
N138993779: C8060.1 R8052.1
N138993809: C8060.2 U8003.5(BOOT)
N138993811: R8052.2 U8003.7(PHASE)
N138993926: JP8055.1 R8061.2
N138993942: C8073.2 R8055.1
N139084693: C8086.1 SR8015.2
N139090790: JP8056.1 R8067.2
N139090792: JP8061.1 SR8016.2
N139090834: C80041.2 R8070.1
N139092828: C80066.2 SR8002.1 U8005.6(VCC)
N139235634: R5208.2 U5200.9(STATUS#)
N139244830: CON5102.10 SR5105.2
N139245224: CON5102.38 SR5102.2
N139245248: CON5102.52 SR5103.2
N139703251: CON3104.2 Q3107.3(DRAIN)
N139978690: R1223.2 R1239.2 U1201.F10(BUSPOWERZ)
N139982576: R1225.2 U1201.E4(DEBUG_CTL1)
N139982579: R1224.2 U1201.D5(DEBUG_CTL2)
N139982678: R1226.2 U1201.E2(UART_TX) U1201.F2(UART_RX)
N140129538: SR3104.1 U3102.28(VCC)
N140129583: R3140.2 U3102.1(REXT)
N140177504: CON6003.1 CON6003.2 Q6001.2(SOURCE) R6005.1
N140177624: C6001.2 CON6002.1(T1) CON6002.2(T2) Q6001.1(GATE) R6006.2
N140414267: R5806.1 R5810.1 U5800.11(PS)
N140503834: T3300.1 U3300.23(LED[2])
N141163560: CON6700.21 L6700.2
N141163567: CON6700.20 L6701.2
N141512226: T1209.1 U1201.F4(SWD_DAT)
N141512229: T1210.1 U1201.G4(SWD_CLK)
N143246738: D9500.2(CATHODE) SR9500.1
N143287072: R1161.2 U1101.AA1(GPIO_8)
N143287155: SR1105.1 U1101.F4(RESET_N)
N143634505: SR9703.2 U9700.5(VID)
N143634515: R9700.1 R9728.1 R9729.2 U9700.9(TON)
N143634547: SR9700.2 U9700.13(PGOOD)
N143634634: C9711.1 R9727.1 U9700.12(OCSET/SS)
N143634716: C9725.1 R9706.2
N143634824: C9720.2 R9716.1 R9721.2 R9723.2
N143636053: C9712.1 R9705.2
N143642319: C8717.2 R8744.1
N143642335: C8719.2 R8746.1
N143642423: R8737.1 R8738.2 R8739.2
N143646420: R8750.1 U8702.1(BST)
N143646442: C8723.1 R8750.2
N143646485: Q8702.4(G) Q8710.4(G) U8702.8(DRVH)
N143646495: Q8701.4(G) Q8713.4(G) U8702.5(DRVL)
N143742448: C8726.1 R8751.2
N143746856: Q8703.4(G) Q8714.4(G) U8703.5(DRVL)
N143746974: R8752.1 U8703.1(BST)
N143746980: C8728.1 R8752.2
N143747012: Q8704.4(G) Q8712.4(G) U8703.8(DRVH)
N143747152: C8731.1 R8753.2
N143748104: Q8705.4(G) Q8715.4(G) U8704.5(DRVL)
N143748222: R8754.1 U8704.1(BST)
N143748228: C8733.1 R8754.2
N143748260: Q8706.4(G) Q8709.4(G) U8704.8(DRVH)
N143748400: C8736.1 R8755.2
N143749353: Q8707.4(G) Q8716.4(G) U8705.5(DRVL)
N143749471: R8756.1 U8705.1(BST)
N143749477: C8738.1 R8756.2
N143749509: Q8708.4(G) Q8711.4(G) U8705.8(DRVH)
N143749649: C8741.1 R8757.2
N143830677: R9717.2 U9702.5(A0)
N143896429: C9106.1 Q9107.1(GATE) R9101.1
N143896431: Q9106.2(BASE1) SR9105.2
N143896453: Q9106.4(COLLECTOR2) R9101.2 R9113.1 T9116.1
N143962240: C9134.1 Q9105.1(GATE) R9111.1
N143962242: Q9104.2(BASE1) SR9104.2
N143962269: Q9104.4(COLLECTOR2) R9110.1 R9111.2 T9113.1
N143992242: C8701.2 R8705.2 R8706.2 R8707.1
N143992301: R8708.1 R8709.2
N144139004: SR8814.2 U8800.8(IDCHG)
N144155601: SR8809.2 U8800.15(BATPRES#)
N144155620: T8813.1 U8800.16(TB_STAT#)
N144172051: CON5103.38 SR5101.2
N144184021: C1229.1 U1201.H7(SS)
N144368781: C80064.2 SR8003.2 U8004.3(VCC)
N144368944: C80019.2 SR8004.2 U8006.3(VCC)
N144464229: C80103.1 C80111.1 SR8019.1
N144464251: C80109.1 C80133.1 SR8018.1
N144464349: C8031.2 R8096.1
N144464375: R8081.1 R8084.2
N144464385: C8024.2 R8049.1
N144464387: C8024.1 R80100.1 SR8012.2
N144464409: C8033.2 R8080.1
N144464505: C8007.2 R8099.2 SR8014.1
N144465101: C8012.1 R8093.2
N144466140: C80106.2 R8036.1
N144466150: R8024.1 R8026.2
N144466400: C8018.2 R80102.1
N144466406: C8008.1 R8047.2
N144466450: R8082.2 R80101.1
N144466452: C8007.1 R8079.2
N144538696: R9713.1 R9736.2
N144821715: Q8810.3(DRAIN) SR8812.1 T9607.1
N144850446: C8206.1 SR8200.2 U8200.3(3V3)
N144850458: R8203.1 U8200.11(OTW)
N144850593: SR8201.2 U8200.14(MODE)
N144850939: C8216.2 R8207.1 R8208.2
N144852564: C8605.2 R8605.2 R8606.1
N144852791: C8604.2 R8607.1
N144852865: C8602.1 U8601.11(VCC)
N144854261: C9403.1 SR9400.2 U9400.3(3V3)
N144854287: R9404.1 U9400.11(OTW)
N144854381: SR9401.2 U9400.14(MODE)
N144854559: C9416.2 R9407.1 R9408.2
N144856027: C9612.1 U9600.11(VCC)
N144858298: C9505.1 L9500.2 R9501.2 R9502.2 T9500.1 U9500.8(SW1) U9500.9(SW2) U9500.15(SW3) U9500.16(SW4)
N144858319: C9513.1 JP9501.1 R9505.1
N144858321: C9513.2 R9502.1 R9504.2
N144858349: C9512.1 R9501.1
N144858623: C9505.2 R9500.1
N144858714: C9504.1 U9500.11(VCC)
N144865734: JP8058.1 R8062.2 R80140.2
N144865765: C80052.1 R8071.1
N144865773: C80052.2 U8006.5(BOOT)
N144865775: R8071.2 U8006.7(PHASE)
N144865814: JP8057.1 R8064.2
N144865830: C80046.2 R8073.1
N144865965: JP8059.1 R8063.2 R80145.2
N144865996: C80042.1 R8065.1
N144866034: C80042.2 U8004.5(BOOT)
N144866048: R8065.2 U8004.7(PHASE)
N144866127: JP8060.1 R8066.2
N144866143: C80056.2 R8072.1
N144868520: C8016.2 R8030.1
N144868544: R8088.1 R8094.2
N144868550: R8031.1 R8039.2
N144868676: C8034.2 R8043.2
N144868752: C8021.2 R8037.1
N144868763: C8021.1 R8015.1 R8020.2
N144868949: C8009.2 R8023.1
N144869080: C8036.2 C80110.2 R8040.1
N145218678: C3105.1 SR3109.1 U3103.5(IN)
N145218686: R3167.2 R3168.1 SR3108.2 U3103.3(EN)
N145218718: SR3110.1 U3103.1(OUT)
N145218847: R3169.1 U3103.4(DSG)
N145280710: T1105.1 U1101.W19(DPSRC_AUX_P)
N145280722: T1106.1 U1101.Y19(DPSRC_AUX_N)
N145280742: T1107.1 U1101.AC23(THERMDA_2)
N145280776: T1108.1 U1101.AB23(THERMDA_1)
N145283752: T1109.1 U1101.A23(ATEST_P)
N145283762: T1110.1 U1101.B23(ATEST_N)
N145283804: T1111.1 U1101.E18(USB2_ATEST)
N145283824: T1112.1 U1101.V18(PCIE_ATEST)
N145824487: R5017.2 U5003.1(SET)
N145830127: Q1201.1(GATE) Q1202.1(GATE) R1242.2 R1243.2
N146002641: C4517.1 C4518.1 CON4500.39 CON4500.40 SR4504.2 T4506.1
N148386775: D3601.2(CATHODE) R3632.2 U3600.4(DC_DET)
N148484425: C5008.1 R5020.2 U5004.4(VSET)
N148484463: R5019.2 U5004.1(FSM#)
N148858017: R2165.1 U2000.BD7(GPP_I4/EDP_HPD)
N149219521: CON5300.15 T5304.1
N149219524: CON5300.19 T5305.1
N150816618: CON5104.38 SR5108.2
N150945327: R0752.2 U0300.F30(RSVD_44)
N150945739: R0753.2 U0300.E30(RSVD_43)
N151525704: R1165.1 U1101.G1(DPSRC_HPD)
N151529455: R1166.1 U1101.Y1(GPIO_6)
N151529458: R1167.1 U1101.Y2(GPIO_7)
N151530540: R1168.2 U1101.Y6(DPSNK1_HPD)
N151543889: R1171.2 U1101.Y5(DPSNK0_DDC_CLK)
N151543892: R1172.2 U1101.R4(DPSNK0_DDC_DATA)
N151761859: Q8806.3(DRAIN) Q8807.2(G) Q8807.5(G) R8838.2
N151944858: R1515.1 U1501.10(REXT)
N152086876: CON5100.6 R5131.1
N152092556: C3616.1 U3600.7(LDO3-CAP)
N152509786: C3607.1 R3620.1
N152557460: C6707.1 CON6701.1 R6740.1 SR6701.1
N153744417: R4604.1 U4601.21(ENI2C)
N154168272: CON4500.23 R4595.2
N156034153: R4526.2 R4597.1 SR4506.2 U4502.4(EN/EN#)
N156149773: Q5707.3(DRAIN) R5710.2
N156149860: Q5709.3(DRAIN) R5713.2
N156149939: Q5710.3(DRAIN) R5714.2
N156150699: C6714.1 IU203.4(EN) R6746.2
N156150808: C6713.1 IU202.4(EN) R6745.2
N157253094: T4510.1 U4502.3(OC#)
N157332139: Q5711.3(DRAIN) R5717.2
N157332227: Q5713.3(DRAIN) R5718.2
N157332809: CON6001.9 R6008.1 R6009.1
N158267574: Q5702.3(DRAIN) R5720.1 R5721.1 R5722.1 R5732.1 R5733.1
N158267597: SR5701.2 U5701.2(G)
N158267601: Q5701.1(GATE) R5704.2 U5701.6(D)
N158267609: Q5702.1(GATE) R5707.2 U5701.3(D)
N158267622: Q5701.3(DRAIN) R5701.1 R5702.1 R5703.1 R5705.1 R5731.1
N158267624: Q5703.1(GATE) R5723.2 U5702.6(D)
N158267716: Q5703.3(DRAIN) R5719.2
N158446613: Q2601.1(GATE) Q2602.3(COLLECTOR2) R2602.1
N158446623: Q2602.2(BASE1) Q2602.5(BASE2) Q2602.6(COLLECTOR1) R2610.1
N158452428: D2401.2(CATHODE) D2402.2(CATHODE) R2493.1 U2402.1(A)
N158452468: C2406.2 R2486.2 R2494.1 U2402.2(B)
N159319782: T7501.1 U7000.P45(FB_VREF)
N159319784: R7501.1 U7000.R44(FB_CAL_PD_VDDQ)
N159319786: R7506.1 U7000.P44(FB_CAL_PU_GND)
N159319788: R7500.1 U7000.R45(FB_CAL_TERM_GND)
N159417946: R7401.2 R7412.2 R7415.2 R7418.2 R7421.2 R7422.2 R7463.2 SR7402.2
N159418124: R7426.2 R7428.2 R7431.2 R7462.2 SR7401.2
N159419345: C7400.1 R7400.2 R74100.2 R74101.2 U7401.3(WP#(IO2)) U7401.7(HOLD#(IO3)) U7401.8(VCC)
N159432635: Q7203.2(SOURCE) R7216.2
N159432637: Q7202.2(SOURCE) R7217.2
N159432649: Q7203.3(DRAIN) SR7208.2
N159432653: Q7202.3(DRAIN) SR7207.2
N159618804: C5302.1 Q5300.1(GATE) R5301.2
N159618817: Q5301.3(DRAIN) Q5302.3(DRAIN) R5301.1 R5302.1
N159618827: C5301.1 L5300.1 Q5300.3(DRAIN)
N161419358: R0900.1 U0300.AF29(VCCGTX_1) U0300.AF30(VCCGTX_2) U0300.AF31(VCCGTX_3) U0300.AF32(VCCGTX_4) U0300.AF33(VCCGTX_5) U0300.AF34(VCCGTX_6) U0300.AG13(VCCGTX_7) U0300.AG14(VCCGTX_8) U0300.AG31(VCCGTX_9) U0300.AG32(VCCGTX_10) U0300.AG33(VCCGTX_11) U0300.AG34(VCCGTX_12) U0300.AG35(VCCGTX_13) U0300.AG36(VCCGTX_14) U0300.AH13(VCCGTX_15) U0300.AH14(VCCGTX_16) U0300.AH29(VCCGTX_17) U0300.AH30(VCCGTX_18) U0300.AH31(VCCGTX_19) U0300.AH32(VCCGTX_20) U0300.AJ13(VCCGTX_21) U0300.AJ14(VCCGTX_22)
N161419500: R0901.1 U0300.AH35(VSSGTX_SENSE) U0300.AH36(VCCGTX_SENSE)
N161648505: R1417.1 U1401.10(CAD_SNK)
N161804128: R7467.1 SR7414.1 U7403.5(G)
N161804129: C7406.1 L7402.1 SR7414.2
N161804130: R7468.1 SR7413.1 U7405.2(G)
N161804131: C7404.1 L7403.1 SR7413.2
N161804140: R7435.1 SR7412.1 U7405.5(G)
N161804142: C7402.1 L7404.1 SR7412.2
N161804191: C7408.1 L7401.1 SR7416.2
N161804205: R7455.2 U7408.5(G) U7408.6(D)
N161804217: Q7406.1(GATE) R7453.2 U7407.5(G) U7407.6(D)
N161804239: R7450.2 U7406.5(G) U7406.6(D)
N161804251: R7449.2 U7404.2(G) U7404.3(D)
N162210915: C2627.1 L2602.2 R2611.2 U2000.V28(VCCAPLLEBB_1P0)
N162559558: R7485.2 U7409.5(G) U7409.6(D)
N162559566: C7409.1 R7486.1 R7488.2 U7409.2(G)
N162559590: R7490.2 U7410.5(G) U7410.6(D)
N162559628: D7403.3(CATHODE) R7493.1 U7414.2(B)
N162559639: D7406.3(CATHODE) R7494.1 U7415.2(B)
N162560797: U7412.4(Y) U7413.2(G)
N162560813: R7496.2 R7497.2 U7412.1(A)
N163464731: D5302.2(CATHODE) Q5304.3(DRAIN)
N163464848: D5301.2(CATHODE) Q5303.3(DRAIN)
N165544422: Q3102.2(G) Q3102.5(G) R3106.1 R3107.1
N166665556: R74109.2 R74110.1 U7415.1(A)
N166670701: R2323.2 U2302.2(G) U2302.3(D)
N166730741: SR5706.2 U5702.2(G)
N166730840: SR5705.2 U5701.5(G)
N167209788: R1218.2 U1201.G2(R_OSC)
N168273177: CON5300.32 R5313.1
N169179480: R4629.2 U4602.3(FLG)
N169179550: CON4601.14 R4610.1
N169508413: R1305.1 SR1301.2 U1302.1(EN)
N169508430: D1301.1(ANODE) R1305.2
N169508447: C1321.1 D1301.2(CATHODE) U1302.5(GATE)
N169891946: SR0701.2 U0703.1(A)
N169897673: R5810.2 T5801.1 U5800.10(CSB)
N169898604: R5809.2 R5811.1 T5802.1
N170005185: Q5704.3(DRAIN) R5728.1 R5729.1 R5730.1
N170005191: Q5704.1(GATE) R5727.2 U5702.3(D)
N170005288: SR5707.2 U5702.5(G)
N170416463: CON6001.10 R6002.1 R6007.1
N170576321: Q5002.1(S) R5022.2 SR5001.2
N170953750: C1202.1 R1245.2 R1246.1 U1202.12(OUT)
N170953788: R1209.2 U1202.6(CTL1)
N170953790: R1210.2 R1248.2 U1202.7(CTL2)
N170953816: R1212.2 U1202.8(CTL3)
N170953891: R1208.1 U1202.16(ILIM_HI)
N170953893: R1207.1 U1202.15(ILIM_LO)
N170963974: R1238.2 U1202.5(EN)
N170981753: R5737.2 U5703.2(G)
N170981759: Q5705.3(DRAIN) R5734.1 R5735.1
N170981761: Q5705.1(GATE) R5736.2 U5703.6(D)
N170982263: R5741.2 U5703.5(G)
N170982269: Q5714.3(DRAIN) R5738.1 R5739.1
N170982271: Q5714.1(GATE) R5740.2 U5703.3(D)
N170982673: R5745.2 U5704.2(G)
N170982679: Q5715.3(DRAIN) R5742.1 R5743.1
N170982681: Q5715.1(GATE) R5744.2 U5704.6(D)
N171267611: R1245.1 R1247.1
N172323921: R2324.2 U2000.AJ44(GPP_D23/ISH_I2C2_SCL/ISH_I2C3_S)
N173419281: SR0702.2 U0703.2(B)
N173594018: CON4500.16 SR4505.2
N173598546: Q5712.1(GATE) SR5704.2
N173598592: Q5706.1(GATE) SR5702.2
N173598635: Q5708.1(GATE) SR5703.2
N173602122: SR7001.2 U7002.2(B)
N173612087: R7461.1 SR7416.1 U7403.2(G)
N1361261240: SR3303.2 T3303.1
N1742655301: D8900.2(CATHODE) SR8900.2

Pads without a net: CN7 5 7; CON1600 87 88 91 92 95 97 100 101 104 105; CON1601 87 88 91 92 95 97 100 101 104 105; CON1700 87 88 91 92 95 97 100 101 104 105; CON1701 87 88 91 92 95 97 100 101 104 105; CON4400 6 8; CON4402 12; CON4500 38; CON4800 13 14; CON5100 1 4 5 13; CON5102 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; CON5103 5 6 7 8 10 11 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 59 60 61 62 63 64 65 66 67 68; CON5104 5 6 7 8 10 11 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 59 60 61 62 63 64 65 66 67 68; CON5300 8 9 10 11 12 13 14 17 20 21 22 23 34 36 58 60 62; IU202 3; IU203 3; NOREF#5 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#11 1; NOREF#12 1; NOREF#13 1; NOREF#16 1; NOREF#19 1; NOREF#22 1; NOREF#23 1; NOREF#24 1; NOREF#26 1; NOREF#28 1; NOREF#32 1; NOREF#33 1; NOREF#34 1; NOREF#35 1; Q5002 3 4 5; Q9102 6; Q9103 6; Q9104 6; Q9106 6; U0300 A27 A29 AA14 AE29 AJ8 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B2 B26 B27 B28 B29 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ21 BJ28 BK21 BK28 BL31 BL34 BN33 BN35 BP1 BP13 BR2 BR31 BR33 BR35 C1 C26 C28 C30 C33 C34 C38 D27 D29 D34 E3 E26 E27 E28 E29 E33 E36 E37 F26 F28 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U0701 1; U0702 1; U1101 A7 A9 A11 A13 AB15 AB17 AB19 AB21 AC15 AC17 AC19 AC21 B7 B9 B11 B13 D19 E19 J1 J2 L1 L2 N1 N2 R1 R2 W12 W16 Y12 Y16; U1102 1; U1104 1; U1105 1; U1201 A9 B9 C2 E10 H6 L11; U1202 9; U1401 8 15 21 33 34 37 43 46; U2000 A7 A16 AA45 AB13 AB33 AB35 AB36 AB39 AB42 AB43 AC2 AC3 AD2 AD3 AD31 AD35 AD38 AE17 AF2 AF3 AF17 AG14 AG15 AJ11 AJ13 AJ33 AJ38 AJ39 AJ42 AL7 AL8 AL35 AL36 AL42 AL44 AM43 AN17 AN29 AN42 AN44 AR19 AR22 AR24 AR29 AR39 AR41 AR44 AT43 AU41 AU43 AV4 AV29 AW4 AW27 AY2 B7 B11 B16 B36 BA4 BA5 BA35 BB3 BB22 BB36 BC4 BC8 BC22 BC27 BC35 BD6 BD11 BD18 BD21 BD22 BD27 BE5 BE6 BE21 C11 C36 D3 D5 D7 D8 E6 E35 E45 F2 F45 G15 G35 G37 G44 G45 H15 H40 H42 H43 H44 J45 K37 K44 L37 L39 N29 N31 N38 N39 P1 P24 P27 P29 P31 R2 R3 R4 R7 R8 R11 R13 R24 R27 U2 U3 U5 U7 U13 V1 V2 W2 W3 W7 W13 W39 W42 Y5 Y44; U3102 9 14 18 23; U3300 25 26 28; U3600 15 16 17 18 29; U4501 1 6; U4601 16 17 18 19 22 23; U5000 6; U5704 3 4 5; U6200 1 2 3 6 7 8 9 12 13 14; U7000 A9 A17 A42 AA44 AC7 AC8 AC9 AD3 AD45 AD46 AF49 AG8 AG9 AG52 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AR50 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 B50 BA1 BA2 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD14 BE7 BE12 BE23 BF9 BF21 BF23 BF24 BG1 BG4 BG6 BG11 BG12 BG21 BG23 BG24 BH6 BH11 BH12 BH23 BJ1 BJ2 BJ9 BJ11 BK18 BK20 BK21 BK44 BL18 BL20 BL21 BM20 BM21 C24 C35 D17 D41 E29 F9 F29 F41 G9 G14 G35 G41 H6 H7 H14 H24 H35 J3 J14 J23 J24 J35 J41 J46 J47 M7 M8 M44 M45 P9 U1 V4 V44 V45 Y50; U7001 3 4 5; U7417 3 4 5; U7600 A12 H2 M2 M13; U7601 A12 H2 M2 M13; U7700 A12 H2 M2 M13; U7701 A12 H2 M2 M13; U7800 A12 H2 M2 M13; U7801 A12 H2 M2 M13; U7900 A12 H2 M2 M13; U7901 A12 H2 M2 M13; U8001 4 6 27 30 31 34; U8002 4 6 27 30 31 34; U8003 4 6 27 30 31 34; U8004 4 6 27 30 31 34; U8006 4 6 27 30 31 34; U8200 5 7 8; U8601 3 5 6; U8800 9 13 14; U8900 6; U9400 5 7 8; U9500 3 5 6; U9600 3 5 6

## Via types
v1: diameter 0.559, hole 0.279, TOP to BOTTOM, 1639 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 5742 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 1687 vias
v4: diameter 0.762, hole 0.457, TOP to BOTTOM, 2051 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 2865 vias
v6: diameter 0.66, hole 0.254, TOP to BOTTOM, 23 vias
v7: diameter 0.61, hole 0.305, TOP to BOTTOM, 3 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VSUS_EN: length 41.9
  TOP w0.102: v2(192.64,13.44) v1(193.74,14.55) 192.6,15.69 C8205.1 ; v2(224.34,12.43) 224.51,12.59 U8200.15 ; R8201.2 C8205.1 ; C8205.1 192.6,17.85 192.67,17.92 D8200.1
  IN4 w0.102: v2(192.64,13.44) 195,11.08 222.66,11.08 224.01,12.43 v2(224.34,12.43)
1.0VSUS_FB: length 9
  TOP w0.203: U8200.13 223.51,12.25 223.22,11.97 223.22,11.26 223.37,11.11 R8206.1 222.87,10.27 222.15,10.27 R8205.2 221.11,11.31 v1(219.44,11.31) 218.12,11.31 R8207.2
1.0VSUS_FB_R: length 26.1
  TOP w0.203: R8205.1 218.24,8.24 201.15,8.24 200.26,9.13 v1(200.26,10.86) 200.26,11.16 200.82,11.72 JP8200.1
1.0VSUS_LX: length 1.6
  TOP w0.432: 214.41,12.5 R8208.1
1.0VSUS_RC:
  vias: v1(221.75,18.32)
1.5VS_EN: length 3.4
  TOP w0.102: v1(221.16,31.07) C8402.1 ; C8402.1 221.16,29.37 221.2,29.33 U8400.3 ; C8402.1 R8402.2
1.5VS_FB: length 4.6
  TOP w0.254: v1(218.93,27.11) 218.93,26.6 218.95,26.58 R8401.1 C8400.2 R8403.2 220.43,26.93 221.2,26.15 U8400.4
1.5VS_IN:
  vias: v1(225.46,27.69)
1.8VO_VGA_BST: length 2
  TOP w0.254: v2(118.37,61.7) 118.38,61.71 R8607.2
  BOTTOM w0.254: v1(118.37,62.44) v2(118.37,61.7)
1.8VO_VGA_EN: length 12.4
  TOP w0.102: v1(119.49,58.43) 119.49,59.17 v2(120,59.68) 120.35,60.03 U8601.13
  BOTTOM w0.102: v2(120,59.68) 119.61,59.3 119.61,55.38 120.71,54.29 D8601.1 122.05,55 121.82,55.23 R8602.2 C8607.1
1.8VO_VGA_FB: length 6.2
  TOP w0.203: v2(119.97,60.31) 120.1,60.43 U8601.12
  BOTTOM w0.203: R8604.2 122.66,58.81 122.64,58.83 R8605.1 122.26,59.24 122.21,59.29 R8601.1 121.82,59.7 120.5,61.02 v1(119.97,61.02) v2(119.97,60.31)
1.8VO_VGA_FB_R: length 23.2
  TOP w0.229: 128,71.64 127.63,72 JP8601.1
  TOP w0.254: v2(126.52,55.48) 128.28,57.23 128.28,71.36 128,71.64
  BOTTOM w0.254: R8604.1 C8605.1 123.55,56.83 124.64,55.73 v1(125.89,55.73) 126.14,55.48 v2(126.52,55.48)
1.8VO_VGA_LX:
  vias: v4(123.53,62.14)
1.8VO_VGA_RC:
  vias: v1(126.42,61.58)
1.8VO_VGA_VOUT: length 12.4
  TOP w0.203: U8601.7 124.62,61.23 124.66,61.2 C8611.1
  TOP w0.229: 127.64,70.16 JP8603.1
  TOP w0.254: 127.64,70.16 v1(127.64,67.57) 127.64,64.57 125.41,62.34 C8611.1
1V0_VGA_BST: length 1.1
  BOTTOM w0.254: v1(113.9,146.34) 114.34,146.34 114.36,146.32 R9603.2
1V0_VGA_BST_R: length 2.4
  BOTTOM w0.254: R9603.1 113.82,144.98 113.71,145.09 v1(112.68,145.09)
1V0_VGA_EN: length 21.2
  IN3 w0.102: v2(113.34,144.48) 113.34,144.66 116.11,147.43 v2(116.11,148.59) 116.2,148.5 120.61,148.5 121.16,149.05 121.16,149.45 v2(122.64,150.92)
  BOTTOM w0.102: v2(113.34,144.48) 113.34,144.13 C9603.1 113.6,143.34 113.65,143.29 R9602.2 114.17,142.38 D9600.1 ; U9600.13 v2(116.11,148.59) ; v1(123.93,153.09) D7407.2 123.93,150.81 123.78,150.65 122.9,150.65 v2(122.64,150.92)
1V0_VGA_FB: length 7.3
  BOTTOM w0.102: R9606.2 113.49,149 112.05,149 v1(111.49,149.56)
  BOTTOM w0.203: U9600.12 116.64,148.19 116.54,148.09 115.47,148.09 R9605.1 114.59,148.57 R9604.2
  BOTTOM w0.254: R9606.2 R9604.2
1V0_VGA_FB_R: length 20.9
  IN4 w0.254: v2(112.5,149.46) 112.88,149.46 113.11,149.23 113.11,146.87 115.27,144.71 115.27,136.48 v2(116.95,134.8)
  BOTTOM w0.203: v2(116.95,134.8) 117,134.86 JP9601.1
  BOTTOM w0.254: v1(112.15,151.31) 112.15,149.82 v2(112.5,149.46) R9606.1 C9601.1
1V0_VGA_FB_R1: length 15.3
  TOP w0.254: 123.45,147.5 123.45,148.28 122.8,148.93 122.49,148.93 121.57,149.84 121.57,151.26 121.14,151.7 119.03,151.7 117.68,150.35 v2(114.66,150.35)
  BOTTOM w0.102: v1(113.95,151.39) C9601.2
  BOTTOM w0.254: v2(114.66,150.35) C9601.2 114.66,149.64 R9605.2
1V0_VGA_LX:
  vias: v4(123.45,145.12)
1V0_VGA_RC:
  vias: v1(120.45,145.04)
1V0_VGA_VOUT: length 23.1
  IN4 w0.254: v3(116.72,133.26) 116.92,133.26 117.63,133.97 117.63,135.01 115.86,136.79 115.86,145.14 117.91,147.2 120.48,147.2 v2(121.16,147.89)
  BOTTOM w0.102: v1(121.62,148.34) v2(121.16,147.89)
  BOTTOM w0.203: U9600.7 120.43,147.39 120.57,147.25 C9608.1 v2(121.16,147.89) ; JP9602.1 117,133.53 v3(116.72,133.26)
1V8_AON_EN: length 62.5
  IN3 w0.102: v2(129.17,32.3) 128.76,32.71 126.34,32.71 125.67,33.38 123.04,33.38 v2(122.64,32.98)
  BOTTOM w0.102: R8602.1 123.81,55.73 124.65,54.89 D8601.2 124.65,53.33 124.44,53.11 v1(124.44,52.31) 124.44,49.62 123.02,48.21 123.02,46.63 122.87,46.48 122.87,45.52 122.36,45.01 122.36,43.48 122.63,43.22 122.63,35.98 122.23,35.58 122.23,34.2 122.64,33.79 v2(122.64,32.98) ; v2(129.17,32.3) 129.17,32.93 131.07,34.83 131.07,35.99 135.95,40.87 136.42,40.87 137.78,42.22 137.78,42.5 141.03,45.75 148.6,45.75 149.23,46.39 149.23,47.12 R7484.1 148.24,47.53 148.19,47.48 D7401.3
1V8_MAIN_EN: length 25.9
  TOP w0.102: v2(144.76,57.13) 145.14,57.13 145.81,57.8 D7403.1 ; R74109.1 141.15,58.02 v2(141.15,58.1) 140.77,58.48 v1(140.77,59.39) 140.77,60.38 141.32,60.93 141.69,60.93 142.02,61.26 142.02,61.7 141.71,62.01 141.71,62.57 141.16,63.12 D7406.1
  IN4 w0.102: v2(144.76,57.13) 143.8,58.1 v2(141.15,58.1)
  BOTTOM w0.102: U7416.2 141.08,58.02 v2(141.15,58.1) 141.15,58.4 140.65,58.91 D7404.1 140.41,58.37 140.07,58.03 140.07,56.7 140.95,55.83 140.95,54.99 141.61,54.33 141.61,52.85 D7405.2 142.3,51.11 142.33,51.08 U7411.4
1V8_MAIN_EN_G: length 5.2
  BOTTOM w0.102: U7410.3 145.48,49.72 145.22,49.46 R7491.2 144.39,49.46 142.98,48.05 U7411.2 142.98,47.39 v1(142.3,46.71)
1V8_MAIN_PG: length 26.8
  TOP w0.102: U7414.1 145.15,63.37 145.63,62.89 145.95,62.89 146.64,62.19 146.64,60.21 146.87,59.97 146.87,57.37 146.26,56.75 146.26,55.62 147.31,54.57 148.35,54.57 v1(148.72,54.94) 149.26,55.47 v2(149.88,55.47)
  BOTTOM w0.102: v2(149.88,55.47) 149.97,55.38 149.97,54.85 150.6,54.21 150.98,54.21 151.36,53.83 R7487.2 151.16,53.25 150.24,52.32 U7409.3 150.24,51.05 149.71,50.53 148.37,50.53 148.14,50.3 148.14,49.1 147.16,48.13 D7401.2
2.5VO_BST:
  vias: v1(92.03,10.07)
2.5VO_EN: length 15.6
  TOP w0.102: U9500.13 90.13,8.08 v1(89.08,9.13) 89.08,11.16 90.61,12.68 v2(92.18,12.68)
  BOTTOM w0.102: SR9500.2 99.08,13.19 99.03,13.14 R9503.2 C9511.1 97.36,13.14 97.19,12.96 92.46,12.96 v2(92.18,12.68)
2.5VO_FB: length 6.2
  TOP w0.102: R9504.1 v1(90.05,11.03)
  TOP w0.203: U9500.12 90.53,7.88 90.4,8.01 90.4,8.49 R9506.2 90.56,9.3 90.56,10.6 R9504.1 R9505.2
2.5VO_VOUT: length 29.3
  TOP w0.203: U9500.7 91.33,3.22 C9503.1 92.74,1.81 99.12,1.81 v1(100.64,3.33) 102.39,5.09 103.89,5.09 105.26,6.46 105.82,6.46 107.32,4.96 110.31,4.96 110.6,5.25 110.6,7.98 110.42,8.16 JP9502.1
3V_BST:
  vias: v1(263.12,56.34)
3V_BST_R: length 3
  TOP w0.508: SR8101.1 264.31,54.94 264.78,55.4 264.78,55.39 v1(264.77,55.39)
3V_FB: length 4.4
  TOP w0.229: U8100.4 258.85,59.27 258.21,58.63 R8107.2 258.32,57.49 C8114.1 R8105.2
3V_FB_R: length 40.4
  TOP w0.254: v1(255.96,54.06) 256.14,54.24 v2(256.57,54.24) 257.03,54.24 C8116.2 R8105.1 C8114.2
  IN1 w0.254: v2(262.32,35.38) 262.29,35.41 262.29,37.37 262.57,37.65 265.53,37.65 265.82,37.93 265.82,38.33 265.45,38.7 264.11,38.7 258.77,44.04 258.77,48.14 257.77,49.14 257.77,51.53 258.18,51.94 258.18,53.37 257.32,54.24 v2(256.57,54.24)
  IN4 w0.254: v2(262.32,35.38) 258.68,31.73 v2(255.76,31.73)
  BOTTOM w0.203: v2(255.76,31.73) 255.45,31.43 JP8105.1
3V_HG: length 49.8
  TOP w0.635: 261.7,58.15 v4(262.72,57.13)
  IN1 w0.762: v4(264.01,31.6) 264.01,32.14 265.45,33.57 267.01,33.57 272.12,38.67 272.12,41.59 269.15,44.56 265.62,44.56 262.15,48.03 262.15,51.45 261.93,51.66 261.93,56.72 262.35,57.13 v4(262.72,57.13)
  IN4 w0.762: 271.81,25.31 271.81,26.62 269.45,28.98 265.62,28.98 264.01,30.59 v4(264.01,31.6)
  vias: v2(271.02,25.56) v2(271.02,24.9)
3V_LG: length 59.8
  IN1 w0.762: v4(263.63,57.13) 264.01,56.75 264.01,52.08 263.55,51.61 263.55,48.76 266.33,45.97 269.71,45.97 273.89,41.79 273.89,38.24 274.03,38.11 274.03,36.03 273.38,35.38 272.67,35.38 268.89,31.6 v4(265.03,31.6)
  IN4 w0.762: 273.03,17 272.04,17.99 272.04,19.59 273.26,20.81 273.26,27.17 269.96,30.46 267.21,30.46 266.07,31.6 v4(265.03,31.6)
  vias: v2(272.9,16.01) v2(273.54,16.01)
3V_LX: length 52
  IN1 w0.762: v4(262.62,32.75) 264.84,34.97 265.73,34.97 268.05,37.29 268.05,41.44 266.33,43.16 264.8,43.16 260.75,47.21 260.75,49.32 259.42,50.66 259.42,52.21 260.5,53.29 260.5,56.17 v4(259.75,56.92)
  IN4 w0.762: v4(270.59,19.34) 270.59,22.87 269.75,23.71 269.75,26.65 268.88,27.53 265.09,27.53 262.62,30.01 v4(262.62,32.75)
  BOTTOM w0.508: T8105.1 v4(259.75,56.92)
3V_RC: length 0.7
  TOP w0.102: v1(271.79,20.71) v2(271.79,21.37)
5V_BST: length 0.6
  BOTTOM w0.102: v1(261.32,61.75) v2(261.32,62.39)
5V_BST_R:
  vias: v1(258.93,64.55)
5V_FB: length 5.3
  TOP w0.102: v1(254.95,59.47) 255.3,59.11 255.83,59.11 256.06,59.35 256.06,60.05 R8106.2
  TOP w0.203: U8100.2 258.23,60.07 C8113.2 R8104.2 R8106.2
5V_FB_R: length 42.5
  TOP w0.203: v2(257.82,61.96) C8115.1 257.21,61.5 257.16,61.45 R8104.1 C8113.1
  IN3 w0.254: v2(257.82,61.96) 258.93,63.08 258.93,67.25 259.52,67.83 259.52,69.04 260.94,70.47 278.36,70.47 279.25,71.36 279.25,75.11 281.29,77.15 v2(281.29,80.25)
  BOTTOM w0.102: v1(258.81,62.67) 258.53,62.67 v2(257.82,61.96)
  BOTTOM w0.203: v2(281.29,80.25) 281.41,80.12 JP8103.2
5V_HG: length 16
  TOP w0.508: T8102.1 270.01,68.92 v4(270.92,68.92)
  IN3 w0.762: v4(270.92,68.92) 267.9,65.89 267.9,63.35 265.72,61.17 264.22,61.17 263.2,62.19 v4(262.39,62.19)
5V_LG: length 10
  TOP w0.508: T8106.1 261.47,68.05 v4(261.47,67.72)
  IN3 w0.762: v4(262.66,60.7) 261.88,60.7 260.57,62.01 260.57,62.76 261.6,63.79 261.6,67.6 v4(261.47,67.72)
5V_LX: length 5.9
  BOTTOM w0.762: 259.85,64.35 259.85,65.87 260.17,66.19 260.17,66.85 260.17,68.47 261.32,69.63
  vias: v2(259.82,63.74) v2(260.46,63.74)
5V_RC: length 0.7
  TOP w0.102: v2(266.27,67.8) 265.94,68.13 v1(265.69,68.13)
5V_VO1: length 48.9
  TOP w0.102: v1(263.48,61.4) 263.33,61.25 v2(263.33,59.81)
  TOP w0.216: U8100.14 262.29,60.07 262.46,59.91 263.23,59.91 v2(263.33,59.81)
  IN3 w0.254: v2(281.92,80.25) 281.92,77.07 279.63,74.78 279.63,71.2 277.33,68.89 272.75,68.89 272.47,69.17 272.47,69.73 272.09,70.11 261.09,70.11 259.87,68.9 259.87,67.57 259.34,67.04 259.34,61.62 261.79,59.18 262.96,59.18 263.33,59.54 v2(263.33,59.81)
  BOTTOM w0.203: v2(281.92,80.25) 282.3,79.86 JP8104.2
+1.0V: length 385.6
  TOP w0.254: R0707.1 69.93,125.03 69.63,124.72 v2(69.12,124.72) ; v2(68.89,125.74) 69.02,125.61 69.22,125.61 69.48,125.86 R0708.2 ; R4427.1 R0747.1 v2(69.18,127.11)
  TOP w0.305: v3(109.74,125.01) 109.95,124.8 C1003.2 C1006.2 109.77,123.48 v3(109.24,122.94)
  TOP w0.381: R0738.1 67.27,121.83 67.29,121.85 v2(67.29,121.88)
  TOP w0.508: v2(191.81,32.17) 192.44,32.8 T9100.1
  IN1 w0.254: v2(53.73,116.34) 53.73,117.1 57,120.38 57.84,120.38 58.83,121.37 61.07,121.37 62.06,120.38 63.73,120.38 64.62,121.27 66.68,121.27 v2(67.29,121.88) 67.29,122.89 v2(69.12,124.72) 68.89,124.95 v2(68.89,125.74) 69.18,126.03 v2(69.18,127.11)
  IN2 w0.254: v2(222.92,76.33) 222.58,76.68 214.31,76.68 211.24,73.61 211.24,68.15 210.87,67.78 210.87,65.83 208.65,63.61 205.56,63.61 196.35,54.4 196.35,48.77 193.16,45.57 192.87,45.57 191.66,44.37 v2(191.66,43.76)
  IN2 w0.508: v2(123.58,101.77) 122.34,101.77 121.42,100.84 121.42,96.98 121.61,96.79 121.61,85.16 121.29,84.84 121.29,76.54 123.27,74.56 125.56,74.56 127.77,72.34 127.77,71.19 128.38,70.58 128.38,53.96 127.67,53.24 127.67,46.6 142.67,31.59 146.17,31.59 146.73,32.15 160.55,32.15 161.5,31.2 164.9,31.2 165.71,30.39 167.33,30.39 168.02,31.08 191.2,31.08 191.81,31.68 v2(191.81,32.17)
  IN3 w0.305: v2(53.73,116.34) 53.73,120.25 52.51,121.47 52.51,126.26 53.32,127.07 53.32,129.03 51.39,130.96 51.39,134.44 53.73,136.78 53.73,136.81 54.73,137.81 54.73,148.05 54.51,148.27 54.51,150.97 56.05,152.51 70.18,152.51 73.03,149.66 81.57,149.66 88.55,142.68 88.55,134.71 93.65,129.61 94.1,129.61 94.4,129.31 94.4,126.3 96.59,124.11 107.6,124.11 107.78,123.93 107.78,123.28 108.09,122.97 109.21,122.97 v3(109.24,122.94)
  IN3 w0.508: v3(109.24,122.94) 109.45,122.94 109.82,122.57 109.82,120.85 109.27,120.3 109.19,120.3 108.64,119.76 108.64,116.59 109.07,116.16 109.86,116.16 110.19,115.83 110.19,113.24 111.2,112.24 111.28,112.24 111.29,112.22 113.89,112.22 115.04,111.07 115.04,110.34 115.32,110.07 115.32,107.22 116.01,106.53 116.82,106.53 118.22,105.14 v3(118.22,104.88)
  BOTTOM w0.254: v2(191.66,43.76) 189.72,41.82 189.72,34.88 191.81,32.79 v2(191.81,32.17) ; v2(69.12,124.72) 68.91,124.51 R0739.1 ; v2(222.92,76.33) 223.12,76.54 224.92,76.54 225.23,76.23 R2450.1 ; v2(68.89,125.74) 68.6,126.03 R4428.1
  BOTTOM w0.305: U0300.H30 109.76,124.99 v3(109.74,125.01) ; U0300.H28 U0300.J28 109.28,122.97 109.26,122.97 v3(109.24,122.94)
  BOTTOM w0.432: R0729.2 123.58,101.28 v2(123.58,101.77)
  BOTTOM w0.508: v3(118.22,104.88) 119.46,104.88 119.84,105.26 122.03,105.26 123.27,104.02 123.27,102.17 123.58,101.86 v2(123.58,101.77)
+1.0VO: length 17.6
  TOP w0.254: 223.51,16.82 U8200.6
  TOP w0.432: C8216.1 211.89,12.43
  TOP w0.508: 211.05,17.38 213.01,19.34 222.61,19.34 223.51,18.44 223.51,16.82
+1.0VO_VGA_PWRGD: length 166.1
  TOP w0.102: v2(141.43,61.34) 141.14,61.34 140.66,61.82 D7406.2 ; T9208.1 166.1,38.59 R9207.1 165.69,39.68 v2(165.46,39.45)
  IN3 w0.102: v2(122.64,148.41) 122.23,148 122.23,147.67 121.45,146.89 117.27,146.89 115.42,145.04 115.42,136.62 116.63,135.41 117.24,135.41 117.93,134.72 118.77,134.72 120.41,133.08 120.41,130.17 120.88,129.69 120.88,128.14 124.51,124.52 124.51,112 125.15,111.36 125.15,75.31 127.8,72.66 127.8,70.51 130.08,68.23 130.08,67.39 136.31,61.17 138.47,61.17 138.72,60.92 141.01,60.92 v2(141.43,61.34) 141.52,61.34 144.58,58.27 145.6,58.27 146.79,57.08 151.26,57.08 152.51,55.84 v2(152.51,55.4)
  BOTTOM w0.102: U9600.4 120.78,148.59 121.39,149.21 122.76,149.21 123.02,149.46 123.65,149.46 123.93,149.18 D7407.1 123.93,148.65 123.69,148.41 v2(122.64,148.41) ; R7411.2 151.76,60.88 D7402.2 152.25,59.56 152.25,55.66 v2(152.51,55.4) 152.51,55.1 153.5,54.11 153.5,45.17 154.17,44.5 157.4,44.5 159.03,42.87 160.13,41.76 160.65,41.76 160.92,42.03 160.92,42.34 161.15,42.58 162.86,42.58 163.79,41.65 163.79,39.12 164.06,38.84 164.85,38.84 v2(165.46,39.45)
