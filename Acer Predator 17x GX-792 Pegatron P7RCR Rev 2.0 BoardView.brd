# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TX_P1: length 211.9
  TOP w0.121: v2(195.05,20.38) 195.45,19.98 195.45,19.76 195.26,19.57 194.41,19.57 193.66,20.33 193.66,24.14 191.22,26.58 191.22,28.15 ; 191.22,28.15 191.22,30.06 190.26,31.01 190.26,32.97 189.15,34.08 189.15,39.29 191.14,41.28 195.09,41.28 197.58,43.78 197.58,52.27 203.16,57.84 204.06,57.84 204.39,58.17 204.65,58.17 v2(205.11,58.63) ; 191.22,28.15 v1(191.44,28.15) ; v2(303.27,51.76) 303.36,51.67 C5508.1
  IN1 w0.102: v2(195.05,20.38) 195.46,19.97 195.79,19.97 196.09,19.67 203.64,19.67 205.84,21.86 206.7,21.86 208.96,24.12 210.86,24.12 213.05,26.31 225.57,26.31 226.33,25.55 235.4,25.55 235.78,25.93 243.44,25.93 248.35,30.83 253.79,30.83 255.11,32.15 255.95,32.15 256.16,31.93 260.52,31.93 263.12,29.33 271.71,29.33 273.59,31.22 273.59,32.63 275.05,34.09 275.05,34.51 275.31,34.77 275.31,38.64 275.17,38.77 275.17,39.31 277.01,41.14 278.66,41.14 280.4,39.39 280.4,38.18 284.27,34.31 294.47,34.31 295.7,35.55 298.8,35.55 299.64,36.38 300.48,36.38 300.86,36.76 300.86,41.65 303,43.8 303,51.5 v2(303.27,51.76)
  BOTTOM w0.089: U2000.C14 218.47,63.41 218.29,63.23 218.17,63.23 218.08,63.14 217.67,63.14 217.54,63.04 217.34,63.04 217.3,63.01
  BOTTOM w0.121: 217.3,63.01 216.4,63.01 216.06,63.35 213.62,63.35 213.49,63.48 212.9,63.48 212.51,63.1 210.13,63.1 206.59,59.56 205.78,59.56 205.11,58.89 v2(205.11,58.63)
USB3_TX_P1_C: length 1.4
  TOP w0.121: L5502.1 305.61,51.78 305.4,51.99 305.03,51.99 C5508.2
USB3_TX_P2: length 101.6
  TOP w0.121: v2(300.13,75.19) 300.13,76 300.18,76.05 C5510.1
  IN4 w0.102: v2(300.13,75.19) 299.93,74.99 299.93,74.76 299.71,74.54 296.79,74.54 295.6,73.35 295.6,72.74 294.76,71.9 294.02,71.9 290.41,68.28 288.58,68.28 286.9,66.61 285.68,66.61 284.73,65.65 274.92,65.65 274.67,65.4 270.05,65.4 268.51,66.94 262.7,66.94 262.19,66.43 255.84,66.43 254.59,67.67 252.2,67.67 251.4,68.47 245.31,68.47 244.16,69.62 242.18,69.62 241.69,70.11 241.69,71.1 239.03,73.76 227.45,73.76 226.87,73.17 226.87,72.76 226.09,71.99 226.09,69.95 225.48,69.34 222.88,69.34 222.08,68.54 222.08,66.15 221.5,65.56 220.96,65.56 220.4,65.01 219.59,65.01 219.16,64.57 217.15,64.57 v2(216.67,65.06)
  BOTTOM w0.121: v2(216.67,65.06) 217.17,64.55 U2000.A12
USB3_TX_P2_C: length 1.8
  TOP w0.121: RN5505.3 302.9,76.16 302.6,76.46 301.94,76.46 C5510.2
USB3_TX_P3: length 230.2
  IN1 w0.102: v2(36.3,41.89) 36.43,42.02 36.43,42.35 36.62,42.54 37.74,42.54 38.15,42.13 38.15,41.58 37.4,40.83 37.4,39.83 38.61,38.62 41.28,38.62 45.19,34.7 98.1,34.7 98.29,34.51 106.78,34.51 109.63,37.37 110.6,37.37 113.63,40.39 142.7,40.39 147.17,35.92 161.88,35.92 162.08,36.13 170.87,36.13 171.08,35.92 189.92,35.92 191.65,37.65 192.42,37.65 200.51,45.74 200.51,57.26 203.84,60.59 204.29,60.59 204.48,60.77 v2(204.48,61.04)
  BOTTOM w0.089: 217.5,64.29 217.55,64.33 218.46,64.33 U2000.D13
  BOTTOM w0.121: v2(36.3,41.89) 36.3,43.87 34.96,45.21 34.19,45.21 ; 217.5,64.29 216.95,64.29 216.62,64.62 214.4,64.62 213.84,65.19 212.11,65.19 211.75,64.82 209.44,64.82 207.67,63.06 207.02,63.06 206.38,62.41 205.16,62.41 204.48,61.73 v2(204.48,61.04) ; C6708.1 22.9,46.75 24.99,46.75 26,45.75 29.32,45.75 29.86,45.21 34.19,45.21 ; 34.19,45.21 v1(34.19,44.99)
USB3_TX_P3_C: length 9.7
  BOTTOM w0.121: 19.84,47.86 19.38,47.86 17.78,49.46 14.59,49.46 14.48,49.36 14.48,49.28 14.4,49.2 CON6700.30 ; 19.84,47.86 20.22,47.86 21.22,46.86 21.45,46.86 C6708.2 ; 19.84,47.86 v1(19.84,47.64)
USB3_TX_P4: length 238.9
  IN1 w0.102: v2(206.69,60.79) 206.9,60.57 206.9,60.42 205.95,59.47 203.79,59.47 201.23,56.9 201.23,45.45 195.99,40.22 195.99,39.2 192.02,35.22 170.34,35.22 170.15,35.41 162.36,35.41 162.17,35.22 146.78,35.22 142.31,39.69 113.92,39.69 110.89,36.67 109.92,36.67 105.6,32.35 54.86,32.35 54.54,32.67 50.37,32.67 50.14,32.44 50.14,31.83 v2(50.12,31.81)
  BOTTOM w0.121: 28.28,53.07 31.25,53.07 39.5,44.82 39.5,43.11 42.96,39.65 47.92,39.65 50.27,37.3 50.27,31.95 v2(50.12,31.81) ; 28.28,53.07 v1(28.28,52.85) ; 28.28,53.07 26.93,53.07 26.88,53.01 24.34,53.01 23.96,53.4 19.58,53.4 C6710.1 ; v2(206.69,60.79) 206.69,61.68 207.33,62.32 207.98,62.32 209.74,64.09 212.05,64.09 212.42,64.45 213.64,64.45 214,64.09 216.39,64.09 216.67,63.81 217.69,63.81 U2000.B13
USB3_TX_P4_C: length 5.1
  BOTTOM w0.121: CON6700.39 14.25,53.7 14.38,53.82 16.47,53.82 16.85,53.44 18.06,53.44 C6710.2
USB3_TX_P6: length 238.5
  IN1 w0.102: v2(205.5,57.24) 205.31,57.43 205.31,57.67 205.11,57.87 203.99,57.87 202.75,56.62 202.75,45.78 197.06,40.09 197.06,39.2 192.39,34.53 169.45,34.53 169.26,34.72 162.65,34.72 162.46,34.53 146.46,34.53 143.92,37.07 143.11,37.07 141.84,38.34 139.81,38.34 139.19,38.96 114.17,38.96 111.18,35.97 110.21,35.97 105.89,31.66 51.97,31.66 51.64,31.33 48.9,31.33 47.35,32.87 45.45,32.87 41.82,36.5 39.53,36.5 37.23,38.79 35.97,38.79 35.05,39.72 v2(35.05,42.03)
  BOTTOM w0.121: v2(205.5,57.24) 205.5,57.42 208.58,60.5 ; 208.58,60.5 210.24,62.16 212.81,62.16 213.36,62.71 215.96,62.71 216.13,62.54 217.96,62.54 U2000.C15 ; 208.58,60.5 v1(208.74,60.33) ; CON6700.9 14.35,38.7 14.48,38.56 14.92,38.56 15.2,38.85 15.99,38.85 16.12,38.98 U6701.10 U6701.1 17.29,38.98 17.43,38.84 17.58,38.84 18.14,39.4 18.14,40.26 18.93,41.05 21.8,41.05 22.1,41.05 22.3,40.86 23.25,40.86 25.41,43.02 34.06,43.02 v2(35.05,42.03)
USB_CHG_CTL1: length 183.4
  TOP w0.102: v2(170.11,22.22) 170.11,22.64 169.65,23.1 R3017.2 ; R1209.1 290.35,73.72 290.56,73.51 v2(291.74,73.51) ; v2(293.91,67.62) 294.04,67.49 SR5201.1
  IN2 w0.102: v2(170.11,22.22) 170.44,21.89 176.51,21.89 176.63,22 184.56,22 184.64,22.08 206.58,22.08 208.71,24.21 225.86,24.21 226.37,24.72 236.73,24.72 236.86,24.6 238.2,24.6 238.85,25.25 240.37,25.25 247.51,32.39 252,32.39 258.02,38.41 258.35,38.41 259.1,39.16 260.47,39.16 267.77,46.46 267.77,47.49 273.49,53.21 273.49,55.29 278.85,60.65 278.85,62.45 279.55,63.15 284.76,63.15 288.41,66.81 293.1,66.81 v2(293.91,67.62)
  IN3 w0.102: v2(170.11,22.22) 169.69,22.64 165.08,22.64 164.94,22.77 164.55,22.77 164.17,22.4 153.93,22.4 153.6,22.73 v2(153.6,22.8)
  BOTTOM w0.102: R3019.2 152.33,30.81 151.47,29.95 151.47,25.92 v1(152.66,24.72) 153.02,24.37 153.02,23.39 v2(153.6,22.8) ; v2(291.74,73.51) 291.8,73.51 293.05,72.27 293.05,68.49 v2(293.91,67.62)
USB_CHG_CTL2: length 3.2
  TOP w0.102: R5210.1 R5209.2 SR5202.1 293.39,66.07 293.05,65.72 v1(293.05,65.31)
USB_CHG_CTL2_EC: length 186.9
  TOP w0.102: R5211.1 R1248.1 290.89,69.98 290.48,70.39 289.69,70.39 289.59,70.49 289.59,71 288.93,71.66 287.66,71.66 v2(287.15,72.17) ; U3002.96 160.86,18.83 161.02,18.68 161.47,18.68 161.95,18.2 161.95,17.17 161.24,16.47 v1(161.24,15.02) 160.95,14.73 v2(158.95,14.73)
  IN3 w0.102: v2(287.15,72.17) 287.15,72.33 286.83,72.65 285.13,72.65 283.72,71.25 283.72,69.65 283.42,69.35 283.42,67.37 279.48,63.43 279.48,60.15 279.89,59.75 279.89,57.64 279.41,57.16 279.41,56.66 279.07,56.32 274.62,56.32 271.89,53.59 271.89,53.16 272.56,52.49 275.03,52.49 276.65,50.86 276.65,50.53 276.87,50.32 276.87,47.57 275.51,46.21 271.16,46.21 264.68,39.73 264.68,38.61 263.24,37.17 v2(262.77,37.17)
  IN4 w0.102: v2(158.95,14.73) 159.01,14.66 181.47,14.66 182.82,16.01 186.5,16.01 186.73,16.24 206.3,16.24 210.7,20.64 210.7,21.88 210.95,22.13 213.14,22.13 213.37,22.36 213.37,22.92 213.55,23.1 229.09,23.1 230.5,24.51 240.38,24.51 247.51,31.65 254.02,31.65 256.95,34.58 260.74,34.58 262.77,36.61 v2(262.77,37.17)
USB_CHG_CTL2_TBT: length 3.9
  TOP w0.102: v1(287.59,73.03) 287.99,72.63 288.91,72.63 R1203.1 R1201.2 R1210.1
USB_CHG_CTL3: length 168.8
  TOP w0.102: R1212.1 290.28,71.69 v2(290.07,71.48) ; U3002.81 154.86,20.11 154.36,20.61 v2(154.36,20.86) ; v2(284.46,66.33) 284.47,66.31 SR5203.1 278.54,65.67 278.44,65.56 276.69,65.56 275.39,64.27 v1(274.15,64.27) 274.02,64.14 274.02,62.82 272.65,61.45 272.65,59.47 272.95,59.16 272.95,58.63 272.55,58.22 v2(272.55,56.57)
  IN2 w0.102: v2(272.55,56.57) 272.55,55.21 265.97,48.63 265.97,47.85 252.04,33.92 250.57,33.92 249.65,33 247.26,33 240.12,25.86 235.71,25.86 235.3,25.46 230.06,25.46 228.87,26.65 227.34,26.65 226.63,25.94 219.51,25.94 219.03,26.42 204.67,26.42 202.72,24.48 192.53,24.48 192.44,24.39 190.61,24.39 190.22,24.77 184.74,24.77 184.52,24.55 177.3,24.55 177.17,24.43 166.77,24.43 166,23.65 165.44,23.65 164.97,24.12 163.4,24.12 161.51,22.24 159.05,22.24 157.29,20.48 154.74,20.48 v2(154.36,20.86)
  BOTTOM w0.102: v2(284.46,66.33) 284.94,66.8 284.94,67.27 284.59,67.62 284.59,68.31 285.81,69.53 288.98,69.53 289.64,70.19 289.64,71.05 v2(290.07,71.48)
USB_CHG_EN: length 228.6
  TOP w0.102: v2(295.26,67.6) 295.53,67.6 296.53,66.6 296.53,65.44 296.32,65.23 296.32,64.35 296.42,64.24 297.93,64.24 298.31,64.62 300.95,64.62 301.04,64.53 U5200.5 ; T9713.1 290.35,75.62 R1238.1 290.35,74.94 290.56,74.73 291.51,74.73 v2(291.74,74.51)
  IN2 w0.102: v2(295.26,67.6) 294.27,66.61 288.5,66.61 284.84,62.95 279.64,62.95 279.05,62.36 279.05,60.56 273.74,55.25 273.74,53.17 268.84,48.26 268.84,46.75 265.42,43.34 264.93,43.34 260.55,38.95 259.19,38.95 258.44,38.21 258.1,38.21 252.08,32.19 247.59,32.19 240.46,25.05 238.94,25.05 238.28,24.4 236.68,24.4 236.56,24.52 226.47,24.52 225.96,24.01 208.8,24.01 206.66,21.88 184.75,21.88 184.67,21.8 176.71,21.8 176.6,21.69 162.94,21.69 160.9,19.64 148.16,19.64 v2(147.14,20.65)
  BOTTOM w0.102: v2(147.14,20.65) 147.87,21.38 150.54,21.38 151.01,20.91 151.01,20.78 151.34,20.45 153.61,20.45 153.85,20.69 153.85,21.57 154.21,21.93 154.21,24.92 153.96,25.18 153.96,28.02 154.74,28.81 156.46,28.81 157.87,30.22 157.87,30.72 T5201.1 159.65,32.49 R3021.2 160.46,32.87 160.46,33.03 R3012.2 ; v2(291.74,74.51) 293.25,73 293.25,68.76 293.94,68.08 294.77,68.08 v2(295.26,67.6) 293.17,65.51 286.37,65.51 v1(285.53,66.35)
USB_PWEN: length 387.2
  TOP w0.102: v2(153.88,18.14) 154.47,18.73 U3002.80 ; U5501.4 303.32,68.55 R5501.2 v2(302.24,68.1)
  IN2 w0.102: v2(302.24,68.1) 298.74,68.1 297.03,66.4 288.58,66.4 284.93,62.75 279.72,62.75 279.25,62.28 279.25,60.48 274.01,55.24 274.01,53.15 269.04,48.18 269.04,46.66 265.51,43.13 265.02,43.13 260.63,38.75 259.27,38.75 258.53,38.01 258.19,38.01 252.14,31.95 247.65,31.95 240.54,24.85 239.02,24.85 238.36,24.19 236.5,24.19 236.38,24.31 226.57,24.31 226.02,23.76 217.27,23.76 215,21.5 214.06,21.5 213.67,21.11 213.01,21.11 212.58,21.55 209.79,21.55 208.85,20.61 208.85,19.23 207.5,17.89 197.09,17.89 195.38,19.59 193.64,19.59 192.32,20.91 188.65,20.91 187.97,20.23 175.04,20.23 174.84,20.43 173.16,20.43 172.47,19.74 163.68,19.74 162.77,18.83 154.36,18.83 153.88,18.35 v2(153.88,18.14) 153.64,17.9 146.55,17.9 145.01,16.36 137.8,16.36 137.52,16.64 111.97,16.64 110.85,17.76 97.11,17.76 91.04,23.83 63.04,23.83 61.28,22.07 40.61,22.07 36.46,17.91 33.4,17.91 32.65,18.67 25.88,18.67 25.43,18.22 24.53,18.22 23.78,18.97 23.78,20.31 24.36,20.9 24.36,24.62 23.78,25.2 23.78,30.67 24.9,31.79 24.9,36.23 24.34,36.79 24.34,38.21 23.51,39.03 23.51,41.22 22.79,41.94 22.79,43.06 22.33,43.52 22.23,43.52 22,43.75 22,46.46 18.37,50.09 18.37,56.98 v2(18.78,57.39)
  BOTTOM w0.102: CON6700.25 10.01,46.7 10.01,46.71 9.91,46.71 8.71,47.9 8.64,47.97 8.64,55.51 9.99,56.85 9.99,59.29 10.1,59.4 12.28,59.4 13.69,58 18.17,58 v2(18.78,57.39) ; v1(153.22,18.14) v2(153.88,18.14)
USBN1: length 86.3
  TOP w0.121: v2(296.6,67.85) 297.47,66.99 298.36,66.99 298.81,66.54 299.68,66.54 ; v1(299.68,66.76) 299.68,66.54 ; 299.68,66.54 300.55,66.54 301,66.99 301.89,66.99 302.17,66.71 302.7,66.71 303,66.41 U5200.2
  IN4 w0.102: v2(230.48,68.2) 232.07,69.79 237.94,69.79 240.34,67.39 240.34,66.17 243.14,63.38 245.01,63.38 245.92,62.48 252.14,62.48 252.85,63.19 254.22,63.19 257.71,59.71 259.79,59.71 261.09,58.41 265.33,58.41 266.58,59.66 271.59,59.66 273.12,61.18 276.67,61.18 278.55,63.06 286.3,63.06 288.12,64.88 289.87,64.88 292.09,67.1 295.73,67.1 296.23,67.61 296.36,67.61 v2(296.6,67.85)
  BOTTOM w0.121: U2000.AF5 230.12,67.84 v2(230.48,68.2)
USBN1_CHARGE: length 14.7
  TOP w0.121: U5200.11 303,61.89 303.46,61.42 303.72,61.42 305.11,60.03 305.31,60.03 305.82,59.52 305.82,59.06 306,58.88 306,58.48 305.57,58.04 v2(305.55,58.04)
  BOTTOM w0.121: L5501.4 307.81,51.14 308.1,51.44 308.1,52.89 307.7,53.3 307.7,56.5 306.03,58.17 305.68,58.17 v2(305.55,58.04)
USBN2: length 99.3
  IN4 w0.102: v2(229.35,67.61) 229.55,67.81 229.55,68.9 231.15,70.49 238.23,70.49 239.03,69.7 239.84,69.7 241.51,68.03 241.51,67.34 243.72,65.13 249.03,65.13 249.92,64.24 254.67,64.24 255.59,63.32 258.49,63.32 262.4,59.41 265.17,59.41 266.24,60.47 271.32,60.47 272.76,61.92 275.74,61.92 277.63,63.81 286.06,63.81 287.83,65.58 289.58,65.58 291.88,67.88 293.07,67.88 294.85,69.65 297.77,69.65 298.38,70.26 298.38,72.37 299.1,73.1 300.98,73.1 302.91,75.03 302.91,79.18 304.16,80.42 304.16,81.17 v6(303.87,81.46)
  BOTTOM w0.121: v2(229.35,67.61) 229.15,67.61 U2000.AD5 ; v6(303.87,81.46) 303.87,80.88 303.38,80.4 303.38,79.61 303.66,79.34 304.29,79.34 304.55,79.08 L5504.4
USBN3: length 253.3
  IN1 w0.102: v2(48.55,37.95) 48.37,37.78 48.37,37.24 48.83,36.79 60.81,36.79 61.4,37.38 97.29,37.38 98.81,38.89 109.97,38.89 113.21,42.13 134.92,42.13 135.31,42.53 144.41,42.53 147.28,39.66 147.28,39.1 148.51,37.87 148.59,37.87 148.8,37.65 189.11,37.65 192.97,41.51 194.11,41.51 196.08,43.48 196.08,44.23 198.56,46.71 198.56,57.78 204.21,63.43 208.03,63.43 209.57,64.97 210.73,64.97 212.26,66.5 212.26,67.17 213.34,68.25 221.24,68.25 221.8,68.82 228.15,68.82 228.78,68.18 228.78,66.12 229.17,65.74 230.23,65.74 v2(230.43,65.94)
  BOTTOM w0.121: CON6700.37 14.42,52.7 14.56,52.56 18.62,52.56 18.88,52.31 25.33,52.31 ; v2(230.43,65.94) 230.4,65.94 U2000.AG8 ; v2(48.55,37.95) 48.34,38.16 48.34,38.34 47.68,39 42.72,39 38.87,42.85 38.87,44.28 33.82,49.33 30.03,49.33 27.06,52.31 25.33,52.31 ; 25.33,52.31 v1(25.33,52.52)
USBN4: length 249.1
  IN1 w0.102: v2(228.07,71.48) 227.87,71.28 227.72,71.28 227.58,71.41 227.58,71.87 227.26,72.19 225.28,72.19 224.43,71.34 216.05,71.34 215.56,70.86 210.55,70.86 209.87,70.17 206.82,70.17 205.94,69.3 205.94,68.62 205.03,67.7 205.03,66.23 197.12,58.32 197.12,47.25 194.58,44.71 194.58,43.99 193.67,43.07 192.56,43.07 188.53,39.05 151.04,39.05 145.59,44.5 132.71,44.5 132.21,44 112.86,44 109.44,40.58 97.99,40.58 97.07,39.67 43.2,39.67 39.39,43.48 36.39,43.48 35.57,42.65 35.26,42.65 35.15,42.77 35.15,42.84 v2(35.41,43.11)
  BOTTOM w0.121: CON6700.28 15.37,48.2 17.26,46.31 20,46.31 21.26,45.05 22.99,45.05 23.55,44.49 28.2,44.49 28.68,44.01 31.12,44.01 ; v2(35.41,43.11) 35.24,43.28 35.24,43.92 34.91,44.25 33.97,44.25 33.72,44.01 31.12,44.01 ; 31.12,44.01 v1(31.12,44.23) ; U2000.AE1 228.75,70.27 228.75,70.55 228.5,70.8 228.5,71.05 v2(228.07,71.48)
USBN7: length 116
  IN4 w0.102: v2(226.96,70.87) 227.14,71.05 227.43,71.05 227.67,71.29 227.67,71.69 228.33,72.35 238.13,72.35 239.2,71.28 240.19,71.28 240.84,70.63 240.84,69.64 244.16,66.31 251.48,66.31 252.6,65.2 259.53,65.2 259.86,64.87 261.8,64.87 262.98,66.05 266.35,66.05 270.34,62.06 272.04,62.06 273.3,63.32 274.8,63.32 275.53,64.05 277.08,64.05 277.82,64.79 285.08,64.79 285.16,64.87 286.35,64.87 288.91,67.42 290.71,67.42 294.06,70.77 296.65,70.77 297.9,72.02 297.9,72.96 298.66,73.72 300.64,73.72 302.41,75.48 302.41,81.48 301.19,82.7 301.19,89.82 300.95,90.06 300.51,90.06 v2(300.41,90.16)
  BOTTOM w0.121: v2(226.96,70.87) 227.32,70.51 227.32,69.12 U2000.AB3 ; L5301.2 291.6,88.75 292.38,88.75 292.89,89.26 298.51,89.26 299.22,89.97 300.22,89.97 v2(300.41,90.16)
USBN7_C: length 3.8
  BOTTOM w0.121: L5301.1 289.5,88.75 289.3,88.75 288.63,89.42 288.63,90.56 288.75,90.68 CON5300.5
USBN9: length 267.3
  IN1 w0.102: v2(223.53,74.05) 223.13,73.65 222.42,73.65 220.81,72.04 215.76,72.04 215.27,71.55 206.3,71.55 205.5,70.76 205.5,70.44 204.28,69.22 204.28,66.51 196.31,58.54 196.31,47.43 192.65,43.77 192.27,43.77 188.57,40.08 151.36,40.08 151.29,40.15 151.29,40.15 150.49,40.95 150.49,40.96 128.66,62.79 128.66,69.48 127.84,70.29 127.84,84.41 128.34,84.91 128.34,89.73 127.69,90.38 127.69,122.55 126.78,123.46 126.78,124.83 125.78,125.83 125.78,131.95 125.4,132.33 125.4,133.52 126.68,134.8 126.68,149.31 127.27,149.9 127.27,152.19 125.4,154.07 125.4,163.03 123.54,164.89 122.06,164.89 120.5,166.44 120.5,167.65 115.45,172.7 112.2,172.7 105.89,179.01 105.89,179.7 106.03,179.84 106.2,179.84 v2(106.46,179.59)
  BOTTOM w0.121: v2(106.46,179.59) 106.03,180.01 105.24,180.01 104.77,180.48 104.77,181.03 L4500.1 ; v2(223.53,74.05) 224.18,73.39 224.18,72.76 226.33,70.62 226.33,70.16 226.71,69.77 U2000.AA1
USBN10: length 254.2
  IN1 w0.102: v2(231.66,66.53) 231.03,67.16 231.03,68.32 230.04,69.31 219.29,69.31 218.73,68.74 212.48,68.74 210.9,67.16 210.9,65.83 210.52,65.45 209.32,65.45 208.71,64.84 204.93,64.84 198.04,57.95 198.04,46.87 195.56,44.39 195.56,43.67 194.02,42.13 192.91,42.13 188.91,38.13 149,38.13 147.81,39.33 147.81,39.81 144.54,43.08 113.44,43.08 109.78,39.42 98.22,39.42 97.48,38.68 42.64,38.68 41.56,39.76 38.44,39.76 v2(38.26,39.58)
  BOTTOM w0.121: v2(231.66,66.53) 231.41,66.53 U2000.AJ8 ; v2(38.26,39.58) 38.13,39.71 38.13,39.71 38.09,39.75 37.92,39.75 36.76,38.59 35.46,38.59 33.23,40.82 30.3,40.82 29.68,40.2 29.68,38.03 27.71,36.07 26.04,36.07 24.77,34.8 19.68,34.8 17.89,33 17.33,33 D6701.1 16.18,33 15.96,33 15.65,33.31 15.65,34.96 15.28,35.33 14.59,35.33 14.46,35.2 CON6700.2
USBP1: length 86.2
  TOP w0.121: 297.92,66.75 298.26,66.75 298.71,66.3 300.64,66.3 301.09,66.75 301.79,66.75 302.07,66.47 302.6,66.47 302.76,66.31 302.76,65.71 302.72,65.67 302.57,65.67 302.5,65.59 U5200.3 ; 297.92,66.75 297.37,66.75 296.9,67.22 v2(296.58,67.22) ; 297.92,66.75 v1(297.92,66.53)
  IN4 w0.102: v2(230.48,67.56) 230.89,67.96 230.89,68.31 232.16,69.58 237.85,69.58 240.13,67.3 240.13,66.08 243.05,63.16 244.92,63.16 245.83,62.26 252.23,62.26 252.94,62.97 254.13,62.97 257.62,59.49 259.7,59.49 261,58.2 265.42,58.2 266.67,59.44 271.68,59.44 273.21,60.97 276.76,60.97 278.64,62.85 286.39,62.85 288.21,64.66 289.96,64.66 292.18,66.89 295.82,66.89 296.32,67.39 296.4,67.39 v2(296.58,67.22)
  BOTTOM w0.121: v2(230.48,67.56) 230.39,67.56 U2000.AG7
USBP1_CHARGE: length 15
  TOP w0.121: v2(305.59,58.65) 305.59,59.42 305.21,59.8 305.01,59.8 303.62,61.19 303.36,61.19 302.85,61.7 302.42,61.7 302.32,61.81 302.32,62.01 302.5,62.19 U5200.10
  BOTTOM w0.121: 308.34,52.53 308.34,51.42 308.61,51.14 L5501.1 ; 308.34,52.53 v1(308.56,52.53) ; 308.34,52.53 308.34,52.99 307.93,53.39 307.93,56.6 306.13,58.4 305.84,58.4 v2(305.59,58.65)
USBP2: length 99.9
  IN4 w0.102: v2(229.37,66.96) 229.77,67.36 229.77,68.81 231.24,70.28 238.14,70.28 238.94,69.48 239.75,69.48 241.29,67.94 241.29,67.25 243.63,64.92 248.94,64.92 249.83,64.03 254.58,64.03 255.5,63.1 258.4,63.1 262.31,59.19 265.26,59.19 266.33,60.26 271.41,60.26 272.85,61.7 275.83,61.7 277.72,63.6 286.15,63.6 287.92,65.36 289.67,65.36 291.97,67.66 293.16,67.66 294.94,69.44 297.86,69.44 298.6,70.17 298.6,72.28 299.19,72.88 301.07,72.88 303.13,74.94 303.13,79.09 304.37,80.33 304.37,81.26 v2(304.58,81.46)
  BOTTOM w0.121: v2(229.37,66.96) 229.19,67.13 U2000.AD7 ; v2(304.58,81.46) 304.58,81 304.46,80.88 304.2,80.88 303.62,80.3 303.62,79.71 303.76,79.58 304.24,79.58 304.55,79.88 L5504.1
USBP3: length 253.3
  IN1 w0.102: v2(230.43,65.25) 230.16,65.52 229.08,65.52 228.57,66.03 228.57,68.09 228.06,68.6 221.89,68.6 221.33,68.04 213.43,68.04 212.47,67.08 212.47,66.41 210.81,64.75 209.66,64.75 208.12,63.22 204.3,63.22 198.77,57.69 198.77,46.62 196.3,44.14 196.3,43.39 194.2,41.29 193.06,41.29 189.2,37.43 148.71,37.43 148.5,37.65 148.42,37.65 147.06,39.01 147.06,39.57 144.32,42.31 135.4,42.31 135.01,41.92 113.3,41.92 110.06,38.68 98.9,38.68 97.38,37.16 61.49,37.16 60.9,36.57 48.74,36.57 48.16,37.15 48.16,37.73 v2(47.94,37.95)
  BOTTOM w0.121: v1(23.4,51.85) 23.4,52.07 ; 23.4,52.07 18.78,52.07 18.53,52.32 14.58,52.32 14.46,52.2 CON6700.36 ; 23.4,52.07 26.96,52.07 29.93,49.1 33.72,49.1 38.63,44.18 38.63,42.76 42.62,38.77 47.58,38.77 48.11,38.24 48.11,38.13 v2(47.94,37.95) ; v2(230.43,65.25) 230.33,65.25 U2000.AG10
USBP4: length 249.1
  IN1 w0.102: v2(228.07,70.87) 227.88,71.06 227.63,71.06 227.37,71.32 227.37,71.78 227.17,71.98 225.37,71.98 224.52,71.13 216.14,71.13 215.65,70.64 210.64,70.64 209.96,69.96 206.91,69.96 206.16,69.21 206.16,68.53 205.24,67.61 205.24,66.14 197.34,58.23 197.34,47.16 194.8,44.62 194.8,43.9 193.76,42.86 192.65,42.86 188.62,38.83 150.95,38.83 145.5,44.28 132.8,44.28 132.3,43.78 112.95,43.78 109.53,40.37 98.08,40.37 97.16,39.45 43.11,39.45 39.3,43.26 36.48,43.26 35.66,42.44 35.17,42.44 34.93,42.68 34.93,42.96 v2(34.78,43.11)
  BOTTOM w0.121: CON6700.27 14.45,47.7 14.54,47.78 14.54,47.86 14.64,47.96 15.27,47.96 17.16,46.08 19.9,46.08 21.16,44.81 22.89,44.81 23.45,44.25 28.1,44.25 28.58,43.77 29.44,43.77 ; 29.44,43.77 v1(29.44,43.55) ; 29.44,43.77 33.82,43.77 34.06,44.02 34.81,44.02 35.01,43.82 35.01,43.34 v2(34.78,43.11) ; v2(228.07,70.87) 228.52,70.43 228.52,70.17 228.99,69.7 228.99,69.52 U2000.AE2
USBP7: length 115.5
  IN4 w0.102: v2(300.4,89.54) 300.7,89.85 300.86,89.85 300.97,89.73 300.97,82.61 302.19,81.39 302.19,75.57 300.55,73.93 298.57,73.93 297.68,73.04 297.68,72.11 296.56,70.99 293.97,70.99 290.62,67.63 288.82,67.63 286.26,65.08 285.07,65.08 284.99,65.01 277.73,65.01 276.99,64.26 275.44,64.26 274.71,63.53 273.21,63.53 271.95,62.28 270.43,62.28 266.44,66.26 262.89,66.26 261.71,65.08 259.95,65.08 259.62,65.41 252.69,65.41 251.57,66.53 244.25,66.53 241.05,69.73 241.05,70.72 240.28,71.5 239.29,71.5 238.22,72.56 228.24,72.56 227.45,71.78 227.45,71.38 227.34,71.27 227.17,71.27 226.96,71.48 v2(226.96,71.48)
  BOTTOM w0.121: v2(300.4,89.54) 300.2,89.74 299.31,89.74 298.6,89.03 292.99,89.03 292.48,88.52 291.62,88.52 L5301.3 ; v2(226.96,71.48) 227.46,70.98 227.46,70.85 227.56,70.76 227.56,69.39 U2000.AB2
USBP7_C: length 4.2
  BOTTOM w0.121: L5301.4 289.5,88.51 289.2,88.51 288.39,89.32 288.39,90.58 288.25,90.72 CON5300.3
USBP9: length 267.3
  IN1 w0.102: v2(106.51,180.25) 106.32,180.06 105.94,180.06 105.67,179.79 105.67,178.92 112.11,172.49 115.36,172.49 120.29,167.56 120.29,166.35 121.97,164.68 123.45,164.68 125.18,162.95 125.18,153.98 127.06,152.1 127.06,149.99 126.46,149.4 126.46,134.89 125.18,133.61 125.18,132.24 125.56,131.86 125.56,125.74 126.56,124.74 126.56,123.37 127.48,122.46 127.48,90.29 128.12,89.64 128.12,85 127.63,84.5 127.63,70.2 128.44,69.39 128.44,62.7 150.27,40.87 151.2,39.94 151.2,39.94 151.27,39.86 188.48,39.86 188.49,39.86 188.66,39.86 192.36,43.56 192.74,43.56 196.53,47.34 196.53,58.45 204.5,66.42 204.5,69.13 205.72,70.35 205.72,70.67 206.39,71.34 215.36,71.34 215.85,71.83 220.9,71.83 222.51,73.44 v2(223.53,73.44)
  BOTTOM w0.121: U2000.AA2 226.7,69.54 226.61,69.54 226.09,70.06 226.09,70.52 223.95,72.66 223.95,73.3 223.8,73.44 v2(223.53,73.44) ; L4500.4 105.01,181.05 105.01,180.58 105.34,180.25 v2(106.51,180.25)
USBP10: length 254.1
  IN1 w0.102: v2(38.23,40.19) 38.45,39.97 41.65,39.97 42.73,38.89 97.39,38.89 98.13,39.64 109.69,39.64 113.35,43.3 144.63,43.3 148.02,39.9 148.02,39.42 149.09,38.35 188.82,38.35 192.82,42.35 193.93,42.35 195.35,43.76 195.35,44.48 197.82,46.96 197.82,58.03 204.84,65.05 208.62,65.05 209.23,65.67 210.44,65.67 210.69,65.92 210.69,67.25 212.39,68.96 218.64,68.96 219.2,69.52 230.13,69.52 231.25,68.41 231.25,67.25 231.36,67.14 v2(231.68,67.14)
  BOTTOM w0.121: v2(38.23,40.19) 38.03,39.99 37.82,39.99 36.66,38.82 35.56,38.82 33.33,41.05 30.2,41.05 29.44,40.29 29.44,38.13 27.62,36.3 25.94,36.3 24.67,35.03 19.59,35.03 17.79,33.24 17.29,33.24 D6702.1 16.2,33.23 16.06,33.23 15.88,33.41 15.88,35.06 15.38,35.57 14.59,35.57 14.45,35.7 CON6700.3 ; v2(231.68,67.14) 231.43,66.89 231.3,66.89 U2000.AJ7
V_SA0_DIMM0_CHA: length 31.8
  TOP w0.305: v2(104.91,73.87) 106.13,73.87 106.76,73.24 106.76,70.34 107.12,69.98 109.73,69.98 111.11,68.61 111.11,64.21 109.98,63.09 108.92,63.09 108.37,63.63 CON1600.256
  BOTTOM w0.102: R1604.2 105.8,76.97 112.48,76.97 v1(114.3,75.14)
  BOTTOM w0.305: v2(104.91,73.87) 105.19,74.15 R1613.1 R1604.2
V_SA0_DIMM0_CHB: length 6.3
  BOTTOM w0.305: R1704.2 102.67,42.15 R1715.1 102.67,42.55 102.94,42.82 104.39,42.82 105.02,43.44 106.14,43.44 106.38,43.68 CON1701.256
V_SA0_DIMM1_CHA: length 43.4
  TOP w0.102: v1(116.47,76.26) 114.92,77.81 104.55,77.81 101.54,74.79 v2(101.54,73.19)
  IN2 w0.305: v2(107.85,58.91) 107.21,59.56 107.21,66.53 103.22,70.52 102.62,70.52 102.32,70.82 102.32,72.41 v2(101.54,73.19)
  BOTTOM w0.254: CON1601.256 106.38,57.7 107.59,58.91 v2(107.85,58.91)
  BOTTOM w0.305: v2(101.54,73.19) 101.54,73.19 101.54,69.82 R1607.2 R1617.1
V_SA0_DIMM1_CHB: length 14.3
  TOP w0.305: v2(108.37,51.29) CON1700.256 ; R1712.1 R1707.2 117.81,51.64 v2(117.84,51.67)
  IN3 w0.305: v2(117.84,51.67) 117.1,50.93 114.66,50.93 113.75,50.02 111.65,50.02 110.81,50.86 108.81,50.86 v2(108.37,51.29)
  BOTTOM w0.102: v1(118.45,52.08) 118.24,52.08 v2(117.84,51.67)
V_SA1_DIMM0_CHA: length 33.4
  TOP w0.102: v2(103.54,74.18) 103.54,74.74 105.21,76.41 113.01,76.41 v1(116.08,73.34)
  TOP w0.305: CON1600.260 109.37,65.46 110.57,66.66 110.57,68.57 109.57,69.58 106.95,69.58 106.36,70.17 106.36,73.07 105.96,73.46 105.26,73.46 105.09,73.29 104.65,73.29 103.77,74.18 v2(103.54,74.18)
  BOTTOM w0.305: v2(103.54,74.18) 103,74.18 102.65,74.53 R1614.1 R1605.2
V_SA1_DIMM0_CHB: length 10
  BOTTOM w0.102: v1(113.98,44.53) R1705.2
  BOTTOM w0.305: CON1701.260 107.38,43.79 108.49,42.68 R1716.1 112.58,42.15 R1705.2
V_SA1_DIMM1_CHA: length 43.7
  TOP w0.102: v1(116.52,78.01) 104.47,78.01 101.03,74.58 v2(101.03,72.67)
  IN2 w0.305: v2(109.09,58.85) 108.64,58.4 107.64,58.4 106.8,59.24 106.8,66.37 103.05,70.12 102.45,70.12 101.91,70.65 101.91,72.24 101.49,72.67 v2(101.03,72.67)
  BOTTOM w0.254: CON1601.260 107.38,57.95 107.8,58.38 108.62,58.38 v2(109.09,58.85)
  BOTTOM w0.305: v2(101.03,72.67) 101,72.63 R1618.1 R1608.2
V_SA1_DIMM1_CHB: length 10.5
  TOP w0.305: R1713.1 R1708.2 v2(115.68,51.64) ; v2(110.34,51.42) 109.68,51.42 109.37,51.72 CON1700.260
  IN3 w0.305: v2(110.34,51.42) 110.82,51.42 111.82,50.43 113.58,50.43 114.79,51.64 v2(115.68,51.64)
  BOTTOM w0.102: v1(116.01,52.2) 116.01,51.97 v2(115.68,51.64)
V_SA2_DIMM0_CHA: length 71.6
  TOP w0.254: CON1600.166 85.87,65.89 86.8,66.81 v2(87.84,66.81)
  IN3 w0.102: v2(87.84,66.81) 96.27,75.24 112.09,75.24 116.75,70.59 116.75,63.32 117.57,62.49 118.47,62.49 118.72,62.24 119.94,62.24 123.18,58.99 123.18,50.67 124.67,49.18 v2(124.67,47.53)
  BOTTOM w0.102: v1(124.95,46.92) 124.67,47.2 v2(124.67,47.53)
  BOTTOM w0.305: v2(87.84,66.81) 87.94,66.81 88.4,67.27 88.4,68.08 89.18,68.87 90.86,68.87 91.04,69.05 R1615.1 R1606.2
V_SA2_DIMM0_CHB: length 5
  BOTTOM w0.305: CON1701.166 83.88,43.67 84.1,43.45 85.4,43.45 86.26,42.58 R1717.1 R1706.2
V_SA2_DIMM1_CHA: length 52.2
  TOP w0.102: v2(91.04,71.99) 98.84,79.79 v1(116.82,79.79)
  IN3 w0.254: v2(91.04,71.99) 90.56,71.99 86.32,67.75 86.32,60.31 86.8,59.82 v2(86.82,59.82)
  BOTTOM w0.254: v2(86.82,59.82) 86.82,59.77 86.34,59.29 85.6,59.29 83.88,57.56 CON1601.166 ; v2(91.04,71.99) 89.41,71.99 88.91,71.49 R1609.2 R1619.1
V_SA2_DIMM1_CHB: length 44.1
  TOP w0.102: v2(88.02,47.84) 86.32,49.54 86.32,50.5 85.87,50.94 CON1700.166
  IN3 w0.102: v2(88.02,47.84) 88.45,48.26 88.45,51.81 88.92,52.28 106.52,52.28 108.45,50.35 110.6,50.35 111.44,49.51 114.26,49.51 115.33,48.44 v2(116.03,48.44)
  BOTTOM w0.102: v2(116.03,48.44) 116.11,48.37 v1(116.11,45.75) 115.96,45.6 115.25,45.6 R1719.1 115.22,45.19 R1709.2
VCLK: length 13.9
  TOP w0.102: C8122.1 C8120.2 258.14,70.69 258.41,70.96 v2(258.55,70.96)
  TOP w0.216: U8100.19 260.14,61.59 259.59,62.14 259.37,62.14 T8119.1
  TOP w0.254: T8119.1 258.31,63.19 258.31,63.49 v2(257.69,64.12)
  IN3 w0.254: v2(258.55,70.96) 258.04,70.46 258.04,65.89 258.3,65.64 258.3,64.37 258.04,64.12 v2(257.69,64.12)
VCORE_EC: length 3.2
  TOP w0.178: 156.44,36.61 156.47,36.59 U3002.12
  TOP w0.254: C3015.2 v1(156.44,37.06) 156.44,36.61
VCORE_VCCSENSE: length 116.5
  TOP w0.254: v3(93.4,131.63) 93.68,131.91 v1(93.68,132.7) ; C8025.1 55.65,183.67 56.7,184.72 C8000.1 R80112.2 ; C8025.1 55.28,182.86 55.18,182.76 SR8012.1 ; C8025.1 55.28,184.46 54.84,184.89 54.21,184.89 53.57,185.53 v2(53.57,186.34)
  IN3 w0.254: v3(93.4,131.63) 92.17,131.63 88.96,134.84 88.96,143.19 81.85,150.3 73.23,150.3 70.54,152.99 49.26,152.99 45.93,156.32 45.93,170.32 44.32,171.93 44.32,185.11 46.42,187.21 52.76,187.21 53.57,186.39 v2(53.57,186.34)
  BOTTOM w0.203: U0300.AG37 95.49,129.74 95.49,130.27 95.52,130.3 95.52,130.88 94.77,131.63 v3(93.4,131.63)
VCORE_VSSSENSE: length 111
  TOP w0.254: v3(93,132.19) 92.21,132.19 v1(92.06,132.04) ; v2(52.94,186.34) 52.94,185.53 53.47,185 C8002.1 R8000.1 C8025.2 54.41,183.01 54.2,182.8 SR8013.1
  IN3 w0.254: v2(52.94,186.34) 52.43,186.85 46.64,186.85 44.73,184.94 44.73,172.1 46.34,170.49 46.34,156.41 49.35,153.4 70.71,153.4 73.4,150.71 82.02,150.71 85.32,147.4 89.31,143.42 89.31,134.99 92.11,132.19 v3(93,132.19)
  BOTTOM w0.203: v3(93,132.19) 93.05,132.14 94.72,132.14 95.87,130.99 U0300.AG38
VGA_DDR_BST1:
  vias: v1(247.2,79.43)
VGA_DDR_BST1_R:
  vias: v1(244.41,81.01)
VGA_DDR_BST2: length 2.7
  BOTTOM w0.102: v2(247.53,84.74) 247.53,84.36 247.68,84.21 v1(249.74,84.21)
VGA_DDR_BST2_R:
  vias: v1(245.24,86.52)
VGA_DDR_HG1: length 0.7
  BOTTOM w0.102: v1(248.27,80.04) v2(248.27,80.75)
VGA_DDR_HG1_R: length 31.1
  TOP w0.635: v4(242.68,82.79) 240.99,82.79 239.6,81.4 236.83,81.4 236.38,81.85 228.5,81.85 225.02,85.32 225.02,89.01
  IN3 w0.635: v4(242.68,82.79) 244.07,81.39 245.34,81.39 248.13,78.61 v4(248.52,78.61)
  vias: v1(224.42,88.5)
VGA_DDR_HG2:
  vias: v1(247.88,88.04)
VGA_DDR_HG2_R: length 5.6
  TOP w0.635: 246.34,87.46 245.95,87.84 245.09,87.84 242.09,90.84
  vias: v1(241,91.4)
VGA_DDR_LG1: length 38.6
  IN3 w0.635: v4(246.39,82.23) 246.69,82.53 246.69,86.27 240.72,92.23 240.09,92.23 239.76,92.56 238.69,92.56 238.3,92.95 231.12,92.95 227.31,96.76 226.69,96.76 224.66,98.79 224.26,98.79 223.5,99.55 v4(217.79,99.55)
  vias: v1(216.99,99.5)
VGA_DDR_LG2: length 2.1
  BOTTOM w0.508: v1(248.22,85.02) 247.88,85.35 246.67,85.35 246.39,85.07
  vias: v2(245.34,83.67) v2(245.98,83.67)
VGA_DDR_LX1: length 30.9
  TOP w0.635: 244.51,81.85 243.74,81.85 243.31,81.41 241.41,81.41 240.13,80.13 236.31,80.13 235.87,80.56 227.98,80.56 223.02,85.53 223.02,92.01
  vias: v4(219.17,94.7) v4(219.2,93.83) v4(219.2,92.95) v4(219.2,92.06) v4(219.26,91.17) v4(220.12,91.02) v4(220.22,95.18) v4(220.99,91.02) v4(221.06,95.41) v4(221.88,91.02) v4(221.98,95.38) v4(222.89,95.36) v4(222.87,91.02) v4(223.81,95.36) v4(223.86,90.96) v4(224.75,95.03) v4(225.74,95.03)
VGA_DDR_LX2:
  vias: v1(241.81,84.97) v2(236.07,85.96) v2(236.2,85.33) v2(236.33,84.44) v2(236.33,83.8) v2(236.33,83.17) v2(237.5,82.71) v2(239.12,82.66) v2(239.38,84.79) v2(240.52,89.67) v2(241.15,89.67) v2(241.79,89.67) v4(236.86,85.96) v4(236.94,85.1) v4(237.09,84.21) v4(237.06,83.34) v4(237.75,85.96) v4(237.8,85.07) v4(237.93,83.34) v4(237.95,84.21) v4(238.39,82.61) v4(238.69,85.99) v4(238.67,85.1) v4(238.84,84.23) v4(238.83,83.37)
VGA_DDR_PG: length 142.7
  TOP w0.102: T9211.1 R9208.1 164.42,39.68 v2(164.19,39.45)
  IN2 w0.102: v2(169.45,43.06) 170.34,43.95 185.21,43.95 186.22,42.95 192.08,42.95 192.36,43.23 196.69,43.23 197.16,43.7 197.16,44.85 198.52,46.21 205.16,46.21 206.15,45.22 239.69,45.22 240.88,46.41 240.88,52.45 240.64,52.69 240.64,53.59 242.45,55.4 250.32,55.4 250.91,55.99 251.96,55.99 252.28,56.3 252.28,56.76 248.34,60.69 248.34,62.52 248.42,62.59 248.42,67.52 247.37,68.56 245.54,68.56 245.3,68.8 245.3,70.96 245.98,71.64 246.33,71.64 247.55,72.86 247.55,83.62 248.83,84.9 v2(248.83,85.72)
  BOTTOM w0.102: v2(248.83,85.72) 249.52,86.41 SR8908.1 ; v2(164.19,39.45) 164.19,42.42 165.22,43.44 165.79,43.44 166.63,42.6 168.99,42.6 v2(169.45,43.06)
VGA_DDR_PG_R: length 4.5
  TOP w0.102: v2(249.46,85.63) 249.46,85.48 248.77,84.79 U8900.13
  BOTTOM w0.102: v2(249.46,85.63) 249.52,85.57 SR8908.2 250.84,85.57 251.01,85.73 v1(251.01,86.9)
VGA_DDR_RC1:
  vias: v1(221.72,99.27)
VGA_DDR_REFIN: length 6.6
  TOP w0.102: R8901.2 251.31,81.03 v1(250.91,81.44)
  TOP w0.203: U8900.7 250.75,82.43
  TOP w0.229: 250.75,82.43 251.16,82.02 C8909.1
  TOP w0.254: v2(253.5,81.77) 253.24,81.52 252.38,81.52 R8901.2 C8909.1
  BOTTOM w0.254: R8900.2 v2(253.5,81.77)
VGA_DDR_TON: length 3.2
  TOP w0.203: U8900.9 250.58,83.23 250.67,83.33 v1(251.01,83.33)
  TOP w0.254: v1(251.01,83.33) 251.38,83.33 251.75,82.96 R8910.1 252.63,82.96 252.71,83.04 R8907.1
VGA_DDR_VCCP: length 2.5
  BOTTOM w0.381: v2(244.35,83.04) 243.79,82.47 C8910.1 243.79,81.12 R8905.2
  vias: v1(244.94,82.76)
VGA_DDR_VID: length 3
  TOP w0.102: v1(251.87,79.97) 251.5,79.97 251.31,80.16 SR8904.2 250.51,80.58 250.22,80.58 249.57,81.22 U8900.5
VGA_DDR_VREF: length 3.5
  TOP w0.203: U8900.8 251.06,82.83
  TOP w0.229: 251.06,82.83 v2(251.26,82.63)
  BOTTOM w0.102: v1(250.81,82.18) v2(251.26,82.63)
  BOTTOM w0.254: v2(251.26,82.63) 251.29,82.66 C8908.1 R8900.1
VGA_DDR_VRON: length 8.8
  TOP w0.114: U8900.3 248.77,80.98 v2(249,80.75)
  BOTTOM w0.102: v2(249,80.75) 249.36,80.4 D8900.1 250.37,80.4 250.86,80.88 253.15,80.88 254,80.03 SR8903.2 C8904.1 254.87,81.39 v1(255.3,81.39)
VID_PLLVDD_GPU_AW27: length 0.5
  BOTTOM w0.254: U7000.BD12 149.35,83.77 v3(149.69,84.11)
  vias: v1(148.62,83.42)
VID_PLLVDD_GPU_AW28: length 0.5
  BOTTOM w0.254: U7000.BC12 150.05,83.76 v3(150.39,84.1)
  vias: v1(148.98,81.39)
VIDALERT#: length 118.2
  TOP w0.076: R0717.2 72.96,125.74 72.62,126.07 R80148.2 72.22,125.94 71.53,125.94 71.46,125.86 R0708.1
  TOP w0.121: v2(54.97,116.34) 55.25,116.34 56.63,117.71 v1(58.61,117.71) 58.89,117.71 61.12,119.94 61.12,122.19 61.69,122.76 63.5,122.76 64.04,123.3 67.7,123.3 68.08,123.68 68.08,125.66 68.57,126.16 69.72,126.16 69.87,126.31 70.55,126.31 R0708.1
  IN4 w0.083: v2(54.97,116.34) 50.88,120.43 50.88,133.46 54.37,136.95 54.37,147.33 53.66,148.04 53.66,154.84 53.06,155.44 47.39,155.44 46.24,156.59 46.24,175.38 48.56,177.7 52.59,177.7 53.68,178.79 53.68,179.49 55.43,181.24 55.43,186.42 55.89,186.88 55.89,188.34 56.72,189.16 v2(56.72,189.94)
  BOTTOM w0.121: v2(56.72,189.94) 56.72,189.51 56.86,189.37 SR8008.1
VIDSCLK: length 124.8
  TOP w0.076: R0747.2 71.24,127.11 71.41,127.27 71.41,127.85 71.49,127.93 72.33,127.93 72.62,127.64 R80149.2 72.62,127.26 73.76,126.13 74.88,126.13 75.09,125.91 75.09,125.58 75.98,124.7 78.27,124.7 78.55,124.97 78.55,126.03 v3(78.95,126.43)
  TOP w0.121: R0747.2 70.38,126.66 68.29,126.66 67.58,125.95 67.58,124.07 67.32,123.81 63.74,123.81 63.23,123.3 61.52,123.3 60.61,122.4 60.61,120.15 58.68,118.22 v1(56.87,118.22) 56.42,118.22 55.25,117.05 v2(54.97,117.05)
  IN4 w0.083: v2(54.97,117.05) 51.37,120.66 51.37,133.29 54.83,136.76 54.83,147.52 54.13,148.23 54.13,155.03 53.26,155.91 47.58,155.91 46.7,156.78 46.7,175.19 48.75,177.24 52.78,177.24 54.15,178.6 54.15,179.3 55.89,181.05 55.89,186.23 56.36,186.69 56.36,188.14 57.33,189.12 v2(57.33,189.9)
  BOTTOM w0.102: v3(78.95,126.43) 79.02,126.43 U0300.BH32
  BOTTOM w0.121: v2(57.33,189.9) 57.33,189.88 R8012.2
VIDSOUT: length 125.2
  TOP w0.076: v3(79.33,122.84) 78.81,123.36 78.15,123.36 77.5,124.01 75.57,124.01 75.07,124.51 74.05,124.51 73.77,124.8 73.03,124.8 73,124.82 R80147.2 72.19,125.61 71.49,125.61 71.35,125.47 71.35,125.38 R0707.2
  TOP w0.121: R0707.2 70.58,125.44 69.85,125.44 69.6,125.19 68.98,125.19 68.62,124.84 68.62,123.52 67.9,122.79 64.24,122.79 63.71,122.26 61.9,122.26 61.62,121.98 61.62,119.73 v1(60.73,118.84) 59.1,117.21 56.84,117.21 55.28,115.65 v2(54.97,115.65)
  IN4 w0.083: v2(56.11,189.79) 56.11,189.22 55.43,188.53 55.43,187.07 54.92,186.57 54.92,181.39 53.22,179.69 53.22,178.99 52.4,178.16 48.37,178.16 45.78,175.57 45.78,156.34 47.14,154.98 52.87,154.98 53.2,154.65 53.2,147.84 53.91,147.14 53.91,137.14 50.4,133.64 50.4,120.25 54.97,115.68 v2(54.97,115.65)
  BOTTOM w0.089: U0300.BH29 79.33,123.97 v3(79.33,122.84)
  BOTTOM w0.121: v2(56.11,189.79) 56.01,189.69 R8014.2
VLDOIN: length 2.6
  TOP w0.102: SR8300.2 26.79,54.81 v1(26.14,55.46)
  TOP w0.203: 27.31,51.85 U8300.19
VR_ENABLE: length 6.3
  TOP w0.102: SR8011.2 59,187.26 v2(59.19,187.26) 59.47,186.98 59.47,186 59.93,185.53 v1(60.59,185.53)
  BOTTOM w0.102: U8000.48 58.57,186.73 59.1,187.26 v2(59.19,187.26) 59.52,187.59 SR8010.2
VR_HOT#: length 2.5
  BOTTOM w0.121: SR8009.2 57.82,187.65 v1(57.82,187.59) 57.82,186.87 57.77,186.83 U8000.46
VRDUTY_PHASE_Q: length 4.5
  TOP w0.432: R74104.1 R74105.2 187.23,171.61 v1(188.02,170.82) 188.69,170.15 Q7407.1
VRDUTY_PU_Q: length 6
  TOP w0.102: Q7407.3 186.57,166.81 v1(185.55,167.82)
  TOP w0.432: Q7407.3 187.74,165.77 187.46,165.49 R74102.2 R74103.2
VREF_CA_RC: length 2.1
  TOP w0.305: v1(66.76,102.17) 67.09,101.84 C0501.2 67.88,102.27 67.8,102.34 R0510.1
VRM_PWRGD: length 467.5
  TOP w0.102: v2(179.14,39.45) 178.86,39.45 SR9206.2 R9203.2 178.88,40.64 179.11,40.41 U9201.1 ; D2401.1 254.49,66.78 253.85,66.15 v2(253.85,66.02) ; D9202.1 185.91,33.51 T9207.1 186.08,32.87 v2(186.44,32.51)
  IN1 w0.102: v2(253.85,66.02) 253.85,65.6 253.93,65.53 253.93,60.65 253.52,60.24 253.52,45.45 v2(254.13,44.84) ; v2(78.59,185.02) 77.3,186.32 62.96,186.32 61.61,187.66 58.88,187.66 v2(58.32,187.1)
  IN2 w0.102: v2(174.63,27.58) 174.21,27.58 173.03,28.76 161.93,28.76 161.64,28.47 157.98,28.47 157.64,28.13 157.64,27.79 157.4,27.55 155.3,27.55 154.48,28.37 135.32,28.37 130.69,33.01 130.69,33.98 128.79,35.87 122.52,35.87 121.47,34.83 114.27,34.83 113.21,33.76 109.22,33.76 108.7,33.24 103.38,33.24 101.28,31.15 55.32,31.15 52.36,34.1 44.58,34.1 41.21,37.47 41.21,40.54 35.9,45.85 35.9,70.82 43.44,78.37 43.44,88.42 42.81,89.05 42.81,101.12 45.69,104 46.28,104 51.17,108.88 54.73,108.88 59.3,113.45 59.3,117.04 61.63,119.37 61.63,123.91 v2(61.68,123.96) 62.06,124.34 62.06,133.81 61.91,133.97 61.91,145.3 63.1,146.49 64.99,146.49 68.69,150.19 68.69,153.65 70.18,155.14 70.18,169.37 71.43,170.62 71.43,176.08 71.94,176.59 71.94,177.41 78.59,184.06 v2(78.59,185.02)
  IN3 w0.102: v2(178.16,32.51) 178.57,32.91 186.04,32.91 v2(186.44,32.51) 186.91,32.04 187.98,32.04 188.52,31.49 194.78,31.49 196.8,33.51 196.8,34.65 197.99,35.84 199.71,35.84 205.08,41.2 209.9,41.2 210.01,41.09 211.18,41.09 211.5,40.77 240.57,40.77 241.18,41.38 248.47,41.38 250.27,43.19 250.77,43.19 252.42,44.84 v2(254.13,44.84)
  BOTTOM w0.102: R4417.2 61.85,124.13 v2(61.68,123.96) ; U8000.47 58.17,186.95 v2(58.32,187.1) ; R2402.2 254.92,43.92 254.13,44.71 v2(254.13,44.84) ; v2(174.63,27.58) 174.83,27.78 174.83,31 176.34,32.51 v2(178.16,32.51) 179.14,33.48 v2(179.14,39.45)
VSADJ: length 2.4
  TOP w0.102: R1321.2 297.67,80.12 v1(298.02,80.47) 298.02,80.93 298,80.96 U1301.18
VSUS_ON: length 230.7
  TOP w0.102: v2(149.79,20.97) 149.79,21.39 152.08,23.68 152.08,24.31 151.44,24.95 151.44,29.98 151.62,30.16 151.62,31.58 153.66,33.63 U3002.19 153.66,35.91 153.18,36.4 153.18,36.85 152.32,37.71 R3064.2 151.98,38.02 151.9,38.09 151.9,39.81 151.29,40.42 R3061.2 ; v2(270.52,54.54) 269.73,55.33 T9303.1 269.51,62.78 269.51,63.44 263.66,69.3 261.08,69.3 259.96,68.18 v2(258.55,68.18) 258.17,68.18 JP9303.2 257.28,66.78 257.16,66.66 R8111.2 R8108.1 258.57,65.75 Q8106.6 259.56,65.75 260.2,65.11 261.87,65.11 262.36,65.6 262.36,66.07 R8110.1 ; v2(191.22,24.8) 192.43,23.59 192.49,23.59 192.56,23.52 192.56,19.96 191.24,18.65 D8200.2 190.07,17.73 190.05,17.71 R8201.1
  IN2 w0.102: v2(149.79,20.97) 150.13,21.32 157.84,21.32 158.96,22.44 161.43,22.44 163.46,24.47 166.52,24.47 166.69,24.63 177.09,24.63 177.21,24.76 184.43,24.76 184.65,24.98 191.04,24.98 v2(191.22,24.8) 191.33,24.68 202.64,24.68 204.58,26.63 219.21,26.63 219.69,26.14 226.55,26.14 227.26,26.85 228.95,26.85 230.15,25.66 235.22,25.66 235.62,26.07 240.04,26.07 247.17,33.2 249.5,33.2 250.42,34.12 251.95,34.12 265.77,47.94 265.77,48.72 270.52,53.46 v2(270.52,54.54) ; v2(273.74,69.98) 273.74,70.11 273.39,70.47 268.48,70.47 266.81,68.79 259.16,68.79 v2(258.55,68.18)
  BOTTOM w0.102: SR5704.1 274.1,69.63 v2(273.74,69.98)
VSUS_ON_EN: length 5.8
  TOP w0.102: R8110.2 v1(263.68,67.47) ; R8110.2 263.16,67.05 Q8106.3 ; R8110.2 C8118.1 R8109.1 264.46,66.11 264.47,66.12 SR8103.1
VSUS_ON_T: length 77.1
  IN1 w0.102: v2(273.13,69.98) 273.13,69.99 270.22,69.99 269.27,69.04 263.28,69.04 259.54,72.78 259.54,76.19 258.06,77.68 257.52,77.68 256.95,78.25 256.95,80.8 257.69,81.53 257.69,82.57 261.97,86.85 266.17,86.85 267.9,88.58 273.22,88.58 276.24,91.6 v2(276.56,91.6)
  BOTTOM w0.102: Q5711.1 273.35,96.14 v1(275.65,93.83) 276.56,92.92 v2(276.56,91.6) ; Q5712.3 278.06,69.1 280.19,66.96 282.74,66.96 283.15,66.56 Q5713.1 282.56,65.74 281.72,66.58 280.27,66.58 R5715.2 278.42,68.13 277.07,68.13 276.59,67.65 273.87,67.65 273.37,68.14 273.37,69.74 v2(273.13,69.98)
WAKE#: length 7.2
  TOP w0.102: SR3301.2 287.91,97.07 287.91,97.25 287.29,97.87 285.69,97.87 285.18,98.38 284.54,98.38 283.96,98.96 283.58,98.96 v1(283.53,99.01) 283.18,99.36 U3300.3
WAKE_PCIE#: length 86.5
  TOP w0.102: SR3301.1 287.75,95.88 v2(287.64,95.99)
  IN2 w0.102: v2(259.91,92.67) 261.17,93.93 271.34,93.93 272.56,95.15 281.21,95.15 282.06,95.99 v2(287.64,95.99)
  BOTTOM w0.102: U2000.BC13 238.42,64.45 239.23,64.45 239.3,64.53 241.19,64.53 241.23,64.56 241.29,64.62 241.78,64.62 242.58,65.41 244.16,65.41 244.39,65.64 245.01,65.64 245.92,66.55 247.07,66.55 247.11,66.6 248.32,66.6 248.65,66.28 248.7,66.28 R2446.2 249.5,66.31 252.89,66.31 255.96,69.38 255.96,70.61 257.18,71.83 257.18,74.35 256.47,75.06 256.47,80.42 255.79,81.11 255.79,81.61 254.43,82.96 254.43,87.97 256.58,90.13 257.37,90.13 v2(259.91,92.67) ; D5302.1 281.16,94.98 281.41,94.72 282.89,94.72 283.06,94.9 D5301.1 284.36,95.77 284.58,95.99 v2(287.64,95.99)
WAKE_WIGI: length 41.6
  IN2 w0.102: v2(305.11,95.31) 305.06,95.26 300.37,95.26 299.4,96.23 291.38,96.23 v2(291.09,95.94)
  BOTTOM w0.102: v2(291.09,95.94) 290.71,96.32 288.57,96.32 287.73,95.49 285.48,95.49 284.28,94.29 R5309.1 283.39,89.64 283.14,89.9 280.47,89.9 280.12,89.54 278.62,89.54 278.05,88.97 Q5304.2 ; v2(305.11,95.31) 305.59,95.79 305.59,96.96 304.86,97.7 304.86,98.36 305,98.5 CON5300.70 305,99.93 304.8,100.13 304.8,101.22 T5307.1
WAKE_WLAN: length 39.2
  IN2 w0.102: v2(300.18,94.72) 298.89,96.02 291.98,96.02 291.46,95.5 v2(290.65,95.5)
  BOTTOM w0.102: T5302.1 303.94,88.42 303.41,87.89 R5314.1 302.75,88.78 301.25,90.28 CON5300.55 301.25,92.29 301.15,92.39 301.15,93.76 v2(300.18,94.72) ; v2(290.65,95.5) 290.02,96.12 288.65,96.12 287.81,95.28 285.65,95.28 284.54,94.16 284.54,91.09 285.6,90.02 285.6,88.5 285.43,88.32 284.71,88.32 R5307.1 283.95,88.42 283.95,88.02 283.65,87.71 281.95,87.71 281.35,88.31 Q5303.2
WARNING: length 189.4
  TOP w0.102: v1(87.74,184) 88.04,183.7 R9712.1 89.41,183.7 v2(90.02,183.09) 90.02,183.47 90.28,183.73 91.39,183.73 91.58,183.53 SR9713.2 91.87,183.27 92.1,183.04 U9702.8
  IN3 w0.102: v2(148.69,69.1) 148.24,69.55 142.09,69.55 141.41,70.24 141.41,73.1 140.74,73.77 140.22,73.77 138.26,75.72 136.57,75.72 135.2,77.1 133.75,77.1 130.59,80.25 130.59,82.08 129.88,82.8 129.88,87.56 126.8,90.64 126.8,116.49 127.11,116.81 127.11,123.09 127.62,123.59 127.62,123.95 127.31,124.25 127.07,124.25 122.51,128.81 122.51,130.37 122.04,130.84 122.04,133.75 120.06,135.73 118.36,135.73 117.66,136.43 117.05,136.43 116.44,137.04 116.44,144.62 117.62,145.8 122.77,145.8 123.05,146.08 123.24,146.08 125.96,148.8 v2(125.96,150.86)
  IN4 w0.102: v2(125.96,150.86) 125.91,150.86 125.1,151.67 123.64,151.67 123.31,151.34 121.47,151.34 120.68,152.13 119.72,152.13 112.86,158.99 106.91,158.99 105.77,160.13 101.71,160.13 100.23,161.61 99.13,161.61 98.76,161.25 96.42,161.25 95.64,162.03 95.64,165.18 94.9,165.92 94.9,176.69 93.58,178.01 93.58,180.07 92.49,181.16 92.49,182.43 91.83,183.09 v2(90.02,183.09)
  BOTTOM w0.102: R7445.2 148.11,69.68 v2(148.69,69.1) 149.05,69.1 149.91,69.96 150.15,69.96 150.48,70.28 150.48,73.73 151.05,74.3 151.05,76.18 150.85,76.38 150.68,76.38 150.44,76.62 150.44,76.88 150.66,77.1 150.83,77.1 151.05,77.32 151.05,77.84 U7000.BB4
WIGI_RST#: length 72.7
  TOP w0.102: v2(279.25,87.87) 280.63,87.87 280.7,87.94 280.7,89.42 280.9,89.62 286.31,89.62 288.49,91.8 291.9,91.8 R5356.2
  IN2 w0.102: v2(255.26,84.59) 256.44,85.78 257.71,85.78 261.51,89.57 269.36,89.57 270.83,88.09 279.03,88.09 v2(279.25,87.87)
  BOTTOM w0.102: R2211.1 250.03,60.18 250.37,60.53 250.37,61.03 250.12,61.29 249.98,61.29 249.75,61.51 249.75,62.15 250.07,62.47 251.32,62.47 252.86,64.01 252.86,66 256.17,69.3 256.17,70.53 257.38,71.75 257.38,74.44 256.67,75.15 256.67,80.51 255.99,81.19 255.99,81.69 255.2,82.48 255.2,84.15 255.26,84.21 v2(255.26,84.59)
WIGI_RST#_PCH: length 11.4
  BOTTOM w0.102: R2211.2 247.92,60.93 245.89,60.93 v1(245.7,60.74) 245.34,60.38 244.77,60.38 244.56,60.58 240.84,60.58 240.67,60.41 239.33,60.41 239.17,60.56 238.49,60.56 238.3,60.75 U2000.BC19
WLAN/WIGIG_LED: length 2.9
  BOTTOM w0.102: T5303.1 289,101.74 CON5300.6
WLAN_DISABLE#: length 140.1
  TOP w0.102: v1(225.38,41.05) 225.38,41.54 v2(225.23,41.69) ; R5308.2 302.06,100.29 v2(302.49,100.72)
  IN3 w0.102: v2(287.64,94.77) 287.64,94.29 287.18,93.83 283.45,93.83 276.44,86.82 271.28,86.82 269.62,85.16 261.67,85.16 261.55,85.04 260.15,83.65 260.15,82.53 259.29,81.67 259.29,79.14 258.01,77.86 257.09,77.86 252.76,73.53 252.76,71.72 254.13,70.35 254.13,68.62 253.39,67.88 251.26,67.88 249.15,65.77 249.15,62.59 250.47,61.28 250.47,61.03 251.04,60.46 252.22,60.46 252.93,59.75 252.93,47.29 252.03,46.39 250.86,46.39 248.68,44.2 240.5,44.2 239.79,43.49 226.78,43.49 225.69,42.4 225.69,42.15 v2(225.23,41.69)
  IN4 w0.102: v2(302.49,100.72) 299.57,97.79 297.01,97.79 295.56,96.35 290.18,96.35 289.74,95.91 289.74,95.03 289.03,94.32 288.09,94.32 v2(287.64,94.77)
  BOTTOM w0.102: U2000.AB44 227.41,48.12 227.41,48.01 227.08,47.69 227.08,46.08 225.63,44.64 225.63,41.51 C5342.1 225.13,41.59 v2(225.23,41.69) ; CON5300.56 301.5,100.08 301.78,100.36 302.14,100.36 v2(302.49,100.72)
WLAN_RST#: length 202.4
  TOP w0.102: R5341.2 295.13,91.6 288.58,91.6 286.39,89.42 283.57,89.42 283.22,89.06 283.22,88.06 282.53,87.37 282.53,86.88 282.38,86.72 v2(281.9,86.72) ; v2(171.13,20.59) 169.45,18.92 169.45,18.35 167.98,16.87 SR3002.2 166.64,16.28 v1(166.27,15.91)
  IN1 w0.102: v2(171.13,20.59) 171.53,21 176.35,21 178.39,23.04 183.88,23.04 184.49,22.44 201.73,22.44 209.52,30.22 231.56,30.22 232.48,29.29 243.5,29.29 247.36,33.15 250.31,33.15 250.78,33.63 252.93,33.63 255.3,36 255.3,40.97 254.2,42.07 252.42,42.07 251.89,42.6 251.89,44.4 252.23,44.74 252.23,45.42 251.5,46.15 251.5,49.65 251.65,49.8 251.65,52.48 251.39,52.74 251.39,57.5 250.37,58.52 250.37,59.67 251.11,60.41 251.33,60.41 251.62,60.69 251.62,63.2 249.23,65.59 v2(249.23,67.8)
  IN2 w0.102: v2(249.23,67.8) 249.41,67.98 252.75,67.98 254.72,69.94 254.72,78.99 256.99,81.25 256.99,82.35 262.74,88.1 265.85,88.1 266.5,88.75 268.2,88.75 270.72,86.24 275.82,86.24 276.66,85.4 280.57,85.4 v2(281.9,86.72)
WLAN_RST#_EC: length 6.8
  TOP w0.102: SR3002.1 v1(164.75,16.87) 164.33,16.87 163.4,17.8 163.4,19.58 163.23,19.76 163.23,21.01 163.13,21.11 U3002.97
WLAN_SUSCLK: length 1.8
  TOP w0.102: v1(308.82,100.57) R2401.1 SR5301.1
WLAN_SUSCLK_R: length 12.5
  TOP w0.102: v1(305.42,101.2) v2(306.05,101.2) 306.3,101.45 SR5301.2
  BOTTOM w0.102: v2(306.05,101.2) 306.05,102.34 305.86,102.53 300.07,102.53 299.75,102.21 299.75,100.22 300,99.97 CON5300.50
WLAN_WAKE#: length 220.9
  IN2 w0.102: v2(306.13,95.69) 306.13,94.74 303.7,92.31 302.27,92.31 302.17,92.21 284.82,92.21 283.66,91.05 283.66,86.05 282.84,85.22 282.84,80.04 278.67,75.88 278.67,70.89 278.14,70.37 275.09,70.37 271.88,67.15 271.44,67.15 264.8,60.51 264.37,60.51 264.13,60.27 264.13,60.04 262.75,58.66 254.92,58.66 251.97,55.71 250.93,55.71 250.42,55.2 242.54,55.2 240.84,53.5 240.84,52.78 241.08,52.53 241.08,46.66 241.08,46.33 239.77,45.02 206.07,45.02 205.28,45.8 v2(198.69,45.8)
  BOTTOM w0.102: R3036.2 163.68,20.71 163.91,20.48 163.91,20.45 164.9,19.46 167.8,19.46 168.42,20.08 168.42,21.03 168.96,21.57 170.63,21.57 171.02,21.97 171.02,22.47 172.35,23.79 172.35,36.35 172.52,36.53 172.52,37.2 171.82,37.9 v1(170.44,37.9) 170.01,37.9 168.66,39.25 168.66,39.62 169.79,40.75 187.42,40.75 191.74,45.07 197.95,45.07 v2(198.69,45.8) ; R5314.2 303.64,87.03 305.24,88.63 306.2,88.63 306.62,89.05 306.62,89.78 307.6,90.76 308.1,90.76 308.54,91.2 308.54,93.08 308.97,93.51 308.97,94.32 308.13,95.16 306.66,95.16 v2(306.13,95.69)
XCLK_BIASREF: length 6.9
  BOTTOM w0.121: U2000.E1 218.72,70.29 218.31,70.29 218.07,70.53 218.07,70.84 217.77,71.14 215.87,71.14 214.95,70.21 R2512.1
XDP1_JTAG_TCK: length 5.4
  BOTTOM w0.102: XDP4400.55 62.41,132.95 62.55,132.82 62.55,131.62 62.74,131.43 SR4403.1 63.44,130.25 v1(63.76,129.93)
XDP1_PIN60: length 8.9
  BOTTOM w0.121: R4425.1 53.24,130.84 54.35,131.95 XDP4400.60 ; R4425.1 52.5,127.92 v1(52.23,127.92) ; R4425.1 53.67,126.75 53.67,126.38 53.74,126.32 SR4410.1
XDP_PCUDEBUG3: length 7.8
  BOTTOM w0.102: XDP4400.1 62.25,146.45 62.74,146.95 62.74,147.87 R4422.1 63.19,147.92 63.35,147.76 63.9,147.76 64.06,147.92 R4424.2 63.74,148.32 63.63,148.42 63.63,150.38 v1(63.71,150.45)
XTAL24_IN_NO_IO: length 5.6
  BOTTOM w0.121: R2522.2 R2524.2 211.44,67.8 211.26,67.62 C2503.1 210.26,67.62 209.85,68.03 208.48,68.03 Y2501.3
XTAL24_IN_R: length 4.3
  BOTTOM w0.121: R2522.1 213.7,68.03 216.77,68.03 U2000.A6
XTAL24_OUT_NO_IO: length 4.2
  BOTTOM w0.121: U2000.A5 216.64,68.66 R2529.1
XTAL24_OUT_R: length 3.9
  BOTTOM w0.121: R2529.2 R2524.1 211.52,68.66 211.27,68.41 C2502.1 210.7,68.61 210.5,68.61 209.78,69.33 Y2501.1
XTALIN: length 12.7
  BOTTOM w0.108: X7200.1 137.33,73.84 139.29,73.84 C7215.1 139.81,73.84 140.51,73.84 142.07,75.39 142.07,78.39 142.88,79.2 144.1,79.2 U7000.BL6
XTALOUT: length 12.7
  BOTTOM w0.108: X7200.3 137.29,74.31 137.29,74.15 137.36,74.08 139.27,74.08 C7216.1 139.85,74.07 140.42,74.07 141.83,75.49 141.83,78.49 142.79,79.44 143.14,79.44 143.21,79.51 143.21,79.81 143.27,79.87 143.68,79.87 143.75,79.81 U7000.BM6
XTALOUTBUFF_R: length 12.8
  BOTTOM w0.102: 142.07,79.15 143,80.08 144.19,80.08 144.32,79.94 144.49,79.94 144.88,79.55 U7000.BK6
  BOTTOM w0.121: 142.07,79.15 140.7,79.15 v1(140.42,78.87) 140.83,78.46 140.83,76.55 140.52,76.24 139.32,76.24 139.01,76.55 R7211.2 138.25,76.13 137.05,76.13 136.63,76.55
XTALSSIN: length 13.9
  TOP w0.121: R7205.2 143.64,70.39 143.62,70.42 R7210.2 143.23,70.92 142.9,71.25 142.9,72.5 v1(142.68,72.71) 142.68,74.87 v3(143.18,75.38)
  IN1 w0.083: v3(143.18,75.38) 143.69,75.89 145.07,75.89 145.19,76 146.33,76 146.58,76.25 146.58,78.11 v3(145.49,79.19)
  BOTTOM w0.102: U7000.BJ6 v3(145.49,79.19)
