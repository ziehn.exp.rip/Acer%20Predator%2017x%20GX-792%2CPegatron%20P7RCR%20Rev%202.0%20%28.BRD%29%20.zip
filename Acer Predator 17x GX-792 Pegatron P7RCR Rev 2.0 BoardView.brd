# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 84.49,72 84.49,68.42 84.62,68.29 86.29,68.29 86.92,67.66 86.92,66.78 87.34,66.36 88.27,66.36 88.7,66.8 88.7,67.97 89.26,68.54 91.83,68.54 92.32,68.05 93.89,68.05 94.42,67.52 97.5,67.52 98.13,66.89 98.6,66.89 99,67.29 99,67.92 99.13,68.05 102.8,68.05 103,67.84 103,67.59 103.6,66.99 104.52,66.99 105.48,66.02 105.5,65.91 105.41,65.85 101.43,65.85 101.35,65.93 92.42,65.93 92.41,65.94 92.41,66.5 92.24,66.67 91.84,66.67 91.46,67.06 91.46,67.72 91.27,67.9 89.45,67.9 89.28,67.74 89.28,66.75 89.56,66.47 90.82,66.47 91.07,66.22 91.07,65.93 84.15,65.93 83.76,66.31 83.76,69.86 83.49,70.13 83.49,71.98 83.61,72.1 84.39,72.1
GND on BOTTOM (solid shape): 205.62,122.69 205.62,121.95 205.62,121.95 205.62,121.77 205.76,121.64 205.88,121.64 205.97,121.55 205.97,120.78 206.02,120.73 206.28,120.73 206.37,120.64 206.37,120.42 206.28,120.2 206.38,119.99 206.38,119.84 206.07,119.52 206.01,119.48 205.96,119.43 205.83,119.43 205.76,119.5 205.76,119.61 205.91,119.93 205.69,120.2 205.68,120.2 205.42,120.47 205.42,120.76 205.14,121.04 204.1,121.04 203.68,120.63 203.68,120.39 203.48,120.18 203.41,120.14 203.36,120.08 203.24,120.08 203.16,120.17 203.16,120.74 204.52,122.11 204.52,122.77 204.55,122.8 205.51,122.8
GND on BOTTOM (solid shape): 207.24,112.58 207.34,112.47 207.48,112.41 207.49,112.41 207.6,112.3 207.6,112.29 207.65,112.22 207.71,112.17 207.71,112 207.62,111.91 207.58,111.79 207.58,111.73 207.6,111.63 207.64,111.59 207.66,111.57 207.7,111.53 207.71,111.5 207.73,111.47 207.73,111.26 208.78,110.2 208.78,109.04 208.7,108.96 208.33,108.96 208.19,109.1 208.19,110.21 207.35,111.04 207.35,111.36 207.16,111.56 207.16,111.59 207.07,111.68 207.07,111.81 207.21,112.09 207.06,112.37 207.06,112.53 207.13,112.6 207.23,112.6
GND on BOTTOM (solid shape): 73.97,112.95 73.97,112.83 74.12,112.68 75.76,112.68 75.78,112.69 75.79,112.7 75.87,112.74 75.93,112.8 76.01,112.84 76.09,112.8 76.13,112.76 76.19,112.72 76.3,112.6 76.3,112.58 76.35,112.41 76.48,112.29 76.53,112.2 76.48,112.11 76.35,111.98 76.3,111.81 74.98,111.81 74.74,112.05 74.03,112.05 74,112.06 74,112.07 73.82,112.23 73.59,112.25 73.41,112.43 73.41,113.04 73.48,113.11 73.81,113.11
GND on BOTTOM (solid shape): 107.42,128.47 107.42,128.22 107.38,128.06 107.42,127.91 107.42,127.57 107.38,127.41 107.42,127.26 107.46,127.21 107.5,127.17 107.51,127.16 107.51,127.01 107.45,126.96 107.4,126.89 107.38,126.76 107.41,126.63 107.41,126.63 107.45,126.57 107.5,126.52 107.51,126.5 107.51,126.39 107.32,126.2 107.19,126.2 107.18,126.23 107.1,126.35 106.97,126.41 106.96,126.41 106.76,126.61 106.76,127.36 107.17,127.77 107.17,127.92 107.2,128.06 107.17,128.2 107.17,128.47 107.21,128.51 107.39,128.51
GND on BOTTOM (solid shape): 169.68,138.3 169.68,138.24 169.82,138.11 169.84,138.1 169.85,138.09 169.92,138.02 170,137.97 170.02,137.96 170.12,137.95 170.24,137.96 170.26,137.98 170.34,138.03 170.4,138.1 170.46,138.11 170.51,138.09 170.54,138.08 170.69,138.08 170.76,138.11 170.81,138.15 171.03,138.15 171.09,138.11 171.42,138.11 171.5,138.03 171.57,138.03 172.56,138.03 172.61,137.98 172.61,137.62 172.6,137.6 171.8,137.6 171.73,137.54 171.53,137.54 171.42,137.65 171.39,137.7 171.37,137.7 171.32,137.75 170.49,137.75 170.21,137.47 170.11,137.47 169.55,138.02 169.49,138.02 169.33,138.18 169.33,138.35 169.37,138.39 169.58,138.39
GND on BOTTOM (solid shape): 160.68,140.42 160.68,139.77 160.79,139.66 161.86,139.66 161.87,139.66 162.06,139.63 162.22,139.74 162.23,139.74 162.42,139.74 162.48,139.68 162.56,139.64 162.57,139.63 162.64,139.56 162.65,139.54 162.7,139.4 162.8,139.3 162.8,139.2 162.71,139.12 162.6,139.12 162.32,139.26 162.04,139.11 161.95,139.11 161.75,139.25 161.51,139.22 161.5,139.21 161.45,139.21 161.43,139.19 159.6,139.19 159.34,139.45 159.03,139.45 159,139.48 159,140.1 159.41,140.52 160.58,140.52
GND on BOTTOM (solid shape): 188.29,138.55 188.34,138.51 188.34,138.13 188.28,138.07 187.08,138.07 187.07,138.08 186.07,138.08 185.87,137.88 185.73,137.88 185.69,137.93 185.63,137.97 185.54,138.05 185.41,138.05 185.34,137.98 185.33,137.98 185.26,137.93 185.2,137.86 185.13,137.85 185.01,137.96 185.01,138.06 185.1,138.14 185.14,138.25 185.15,138.26 185.31,138.43 185.35,138.45 185.38,138.49 185.57,138.49 185.61,138.44 185.67,138.4 185.85,138.33 186.02,138.41 186.16,138.5 186.31,138.45 186.35,138.42 187,138.42 187.13,138.55 188.04,138.55
GND on BOTTOM (solid shape): 217.13,67.41 217.14,67.35 217.15,67.32 217.19,67.25 217.25,67.2 217.28,67.18 217.28,67.07 217.25,67.05 217.21,67.02 217.1,66.91 216.82,66.91 216.71,67.02 216.71,67.04 216.52,67.46 216.07,67.39 216.03,67.38 216,67.39 215.55,67.46 215.35,67.06 215.36,67.03 215.04,66.71 214.22,66.71 214.1,66.84 214.1,67.54 214.36,67.8 216.74,67.8
GND on BOTTOM (solid shape): 141.2,140.31 141.25,140.25 141.32,140.21 141.7,139.83 142.37,139.83 142.56,139.63 142.69,139.62 142.79,139.64 142.86,139.68 142.96,139.77 143.08,139.77 143.35,139.51 143.35,139.49 143.43,139.35 143.58,139.26 143.6,139.26 143.87,138.98 143.87,138.87 143.83,138.83 143.8,138.8 143.77,138.77 143.73,138.73 143.65,138.73 143.33,139.04 143.33,139.05 143.06,139.26 142.75,139.13 142.6,139.13 142.33,139.4 141.33,139.4 141,139.73 140.03,139.73 139.97,139.79 139.97,140.29 139.99,140.31
GND on BOTTOM (solid shape): 67.47,68.27 67.47,66.07 67.25,65.85 59.85,65.85 59.77,65.77 59.77,62.56 59.23,62.02 58.27,62.02 58.1,62.19 58.1,62.84 58.47,63.22 58.47,65.83 58.38,65.92 56.86,65.92 56.86,65.91 56.77,65.82 56.77,63.84 56.92,63.69 56.92,63.23 57.11,63.04 57.11,62.47 57.05,62.41 56.57,62.41 56.48,62.5 56.48,65.79 56.36,65.9 56.36,65.92 48.9,65.92 48.9,67.17 49.08,67.34 49.85,67.34 49.96,67.23 50,67.24 50.53,67.24 50.69,67.4 51.41,67.4 51.97,67.96 55.1,67.96 55.51,67.54 56.1,67.54 56.54,67.11 57,67.11 57.42,67.53 57.93,67.53 58.27,67.18 58.55,67.18 58.55,67.19 58.73,67.19 58.85,67.07 58.85,65.92 58.85,65.83 58.77,65.75 58.77,63.76 58.87,63.67 59.37,63.67 59.48,63.78 59.48,65.73 59.4,65.81 59.4,66.9 59.72,67.22 59.72,67.7 59.97,67.96 64.02,67.96 64.43,67.55 65.17,67.55 65.59,67.13 65.98,67.13 66.19,67.34 66.19,68.12 66.42,68.35 67.39,68.35
GND on BOTTOM (solid shape): 188.49,140.52 188.45,140.49 188.03,140.49 187.37,139.83 187.36,139.83 186.96,139.42 186.49,139.42 186.43,139.38 186.2,139.38 186.08,139.41 185.95,139.28 185.92,139.21 185.89,139.18 185.87,139.17 185.74,139.17 185.71,139.21 185.65,139.25 185.64,139.28 185.55,139.37 185.4,139.37 185.3,139.28 185.29,139.26 185.24,139.21 185.18,139.15 185.03,139 185.02,138.92 184.89,138.79 184.8,138.79 184.67,138.92 184.67,139.04 184.95,139.32 184.96,139.33 185.06,139.39 185.12,139.49 185.13,139.5 185.39,139.76 185.59,139.76 185.74,139.68 185.91,139.69 185.92,139.7 186.11,139.7 186.17,139.74 186.2,139.77 186.57,139.77 187.53,140.72 187.53,141.01 187.58,141.06 188.49,141.06
GND on BOTTOM (solid shape): 157.99,48.59 157.99,48.49 157.91,48.41 157.86,48.31 157.86,48.29 157.61,48.05 157.44,48.05 157.36,48.13 157.25,48.17 157.14,48.17 157.04,48.12 157.01,48.09 156.98,48.06 156.94,48.04 156.9,48.02 156.84,48.01 156.61,47.78 156.6,47.74 156.58,47.69 156.55,47.65 156.42,47.52 154.92,47.52 154.9,47.54 154.9,47.94 154.9,47.95 156.23,47.95 156.3,47.99 156.4,47.99 156.43,48.02 156.46,48.02 156.65,48.21 156.65,48.24 156.83,48.42 156.91,48.43 157.05,48.57 157.06,48.6 157.08,48.63 157.1,48.66 157.27,48.66 157.41,48.56 157.59,48.54 157.67,48.55 157.79,48.67 157.91,48.67
GND on BOTTOM (solid shape): 165.05,48.69 165.1,48.63 165.2,48.55 165.33,48.54 165.46,48.55 165.56,48.63 165.6,48.68 165.75,48.68 165.75,48.68 166.01,48.43 166.71,48.43 166.76,48.48 166.78,48.48 166.8,48.52 166.9,48.61 166.92,48.63 166.95,48.64 167.1,48.64 167.15,48.61 167.2,48.58 167.49,48.29 168.33,48.29 168.38,48.23 168.38,47.78 168.34,47.73 167.35,47.73 167.26,47.83 167.22,47.86 167.04,48.05 165.89,48.05 165.73,48.17 165.53,48.15 165.46,48.09 165.42,48.05 165.27,48.05 164.99,48.33 164.99,48.34 164.94,48.43 164.86,48.5 164.86,48.59 164.96,48.69
GND on BOTTOM (solid shape): 168.43,51.13 168.9,51.13 169.02,51.01 169.04,50.98 169.07,50.95 169.07,50.72 169.06,50.7 168.97,50.62 168.94,50.6 168.75,50.6 168.71,50.61 168.66,50.63 168.43,50.63 168.4,50.6 167.5,50.6 167.41,50.6 167.22,50.41 167.22,49.98 167.12,49.88 165.88,49.88 165.38,49.39 165.25,49.39 164.98,49.66 164.93,49.74 164.87,49.79 164.87,49.92 164.95,49.99 165.05,49.99 165.09,49.94 165.18,49.86 165.23,49.86 165.33,49.84 165.43,49.86 165.46,49.86 165.48,49.88 165.56,49.94 165.62,50.02 165.63,50.02 165.78,50.17 165.83,50.2 165.99,50.2 166.07,50.27 166.72,50.27 166.78,50.32 166.78,50.92 166.99,51.13 167.34,51.13 167.37,51.16 168.4,51.16
GND on BOTTOM (solid shape): 177.69,49.06 177.74,49 177.8,48.95 177.8,48.86 177.46,48.52 177.46,48.51 177.38,48.45 177.32,48.37 177.31,48.37 177.02,48.07 176.85,48.07 176.64,48.18 176.42,48.07 176.17,48.07 176.15,48.08 175.69,48.08 175.44,47.83 175.42,47.78 175.4,47.72 175.36,47.67 174.88,47.19 174.88,47.17 174.85,47.14 174.03,47.14 173.99,47.18 173.99,47.63 174.02,47.66 174.8,47.66 175.14,48 175.24,48.03 175.58,48.36 176.15,48.36 176.17,48.37 176.25,48.37 176.31,48.43 176.34,48.43 176.48,48.57 176.52,48.64 176.54,48.67 176.7,48.67 176.74,48.63 176.78,48.59 176.89,48.49 176.98,48.49 177.05,48.55 177.06,48.56 177.19,48.64 177.28,48.77 177.28,48.79 177.56,49.06
GND on BOTTOM (solid shape): 206.13,77.75 206.13,77.61 206,77.48 205.95,77.47 205.81,77.34 205.8,77.31 205.74,77.27 205.7,77.21 205.64,77.18 205.64,76.88 205.7,76.85 205.75,76.79 205.8,76.75 205.81,76.7 205.79,76.65 205.78,76.61 205.78,76.38 205.82,76.34 205.84,76.32 205.86,76.29 205.86,76.09 205.8,76.02 205.8,75.77 206,75.57 206,74.26 205.97,74.22 205.65,74.22 205.58,74.29 205.58,75.38 205.53,75.44 205.49,75.49 205.47,75.54 205.47,75.65 205.49,75.7 205.52,75.74 205.55,75.78 205.55,76.02 205.52,76.06 205.48,76.18 205.51,76.3 205.53,76.33 205.53,76.61 205.5,76.69 205.36,76.82 205.3,76.83 205.17,76.96 205.17,77.1 205.44,77.37 205.45,77.37 205.56,77.45 205.64,77.56 205.64,77.57 205.9,77.82 206.06,77.82
GND on BOTTOM (solid shape): 207.92,87.73 207.92,86.83 207.9,86.8 207.9,86.55 207.41,86.07 207.37,86.03 207.33,85.94 207.33,85.72 207.36,85.69 207.38,85.66 207.4,85.62 207.4,85.49 207.37,85.44 207.33,85.39 207.32,85.36 207.31,85.34 207.27,85.17 207.36,85.02 207.39,84.97 207.44,84.93 207.44,84.75 207.2,84.5 207.18,84.5 207.08,84.45 207,84.36 206.91,84.36 206.81,84.46 206.81,84.55 206.96,84.83 206.82,85.1 206.82,85.31 207.01,85.51 207.01,85.62 207.03,85.66 207.05,85.69 207.08,85.72 207.08,86.04 207.03,86.1 207.01,86.12 207.01,86.37 207.03,86.4 207.05,86.42 207.37,86.73 207.37,87.79 207.87,87.79
GND on BOTTOM (solid shape): 94.43,106.14 94.55,106.01 94.72,105.95 94.81,105.88 94.79,105.78 94.6,105.6 94.6,105.34 94.48,105.23 94.42,105.07 94.43,104.9 94.52,104.77 94.52,103.04 94.57,102.99 94.57,102.31 94.57,102.3 94.57,102.05 94.49,101.97 94.47,101.96 94.23,101.96 94.11,102.07 94.11,102.78 94.16,102.83 94.16,103.62 93.94,103.85 93.91,103.93 93.95,104 94.27,104.29 94.07,104.68 94.04,104.69 94.04,105.97 94.02,106.08 94.11,106.14
GND on BOTTOM (solid shape): 157.62,50.34 157.79,50.22 158,50.25 158.05,50.3 158.08,50.34 158.28,50.34 158.31,50.29 158.36,50.26 158.36,50.12 158.08,49.84 158.07,49.83 157.99,49.79 157.93,49.73 157.78,49.73 157.75,49.77 157.71,49.79 157.6,49.91 157.48,49.91 157.39,49.82 157.31,49.77 157.25,49.7 157.2,49.69 157.14,49.71 157.11,49.72 156.9,49.72 156.84,49.67 156.81,49.65 156.63,49.65 156.58,49.69 156.55,49.74 156.51,49.8 156.16,49.8 155.01,49.8 154.97,49.84 154.97,50.23 154.98,50.24 155.89,50.24 155.95,50.27 156.11,50.27 156.14,50.26 156.17,50.24 156.2,50.21 156.55,50.21 156.62,50.13 156.68,50.13 156.74,50.07 157.18,50.07 157.45,50.34
GND on BOTTOM (solid shape): 141.34,137.48 141.45,137.52 141.57,137.5 142.24,136.82 142.38,136.82 142.43,136.78 142.6,136.78 142.67,136.81 142.81,136.95 142.82,137.02 142.83,137.05 142.85,137.07 142.89,137.11 142.94,137.16 143.1,137.16 143.17,137.09 143.25,137.04 143.26,137.04 143.34,136.96 143.34,136.94 143.44,136.74 143.63,136.65 143.65,136.65 143.73,136.57 143.73,136.56 143.78,136.48 143.85,136.41 143.85,136.27 143.76,136.17 143.6,136.17 143.33,136.45 143.32,136.46 143.06,136.66 142.75,136.52 142.07,136.52 141.9,136.69 141.9,136.72 141.6,137.02 140.55,137.02 140.29,137.02 140.29,137.45 140.55,137.45 141.31,137.45
GND on BOTTOM (solid shape): 186.45,50.67 186.48,50.66 187.45,50.66 187.52,50.59 187.52,49.48 187.47,49.43 186.95,49.43 186.89,49.47 186.82,49.49 185.01,49.49 184.98,49.45 184.92,49.42 184.88,49.39 184.64,49.39 184.61,49.41 184.58,49.44 184.44,49.58 184.43,49.59 184.34,49.75 184.18,49.84 184.17,49.85 184.03,49.99 183.99,50.03 183.95,50.07 183.95,50.25 184.04,50.33 184.19,50.33 184.31,50.22 184.32,50.14 184.46,50 184.48,49.99 184.49,49.98 184.57,49.9 184.66,49.86 184.68,49.84 184.76,49.84 184.85,49.84 184.88,49.86 184.96,49.91 185.03,49.98 185.95,49.98 186.1,50.14 186.1,50.34 186.12,50.36 186.1,50.44 186.1,50.55 186.12,50.59 186.14,50.63 186.18,50.67 186.2,50.68 186.43,50.68
GND on BOTTOM (solid shape): 162.4,138.47 162.44,138.42 162.48,138.38 162.65,138.21 162.65,138.2 162.7,138.09 162.79,138 162.79,137.89 162.73,137.83 162.59,137.83 162.54,137.88 162.47,137.93 162.44,137.96 162.32,137.96 162.2,137.96 162.16,137.92 162.11,137.88 162.06,137.83 161.92,137.83 161.86,137.89 161.84,137.92 161.81,137.93 161.8,137.95 161.78,137.95 161.71,138 161.61,137.95 161.58,137.95 161.57,137.94 161.54,137.93 161.27,137.67 160.51,137.67 160.48,137.64 160.42,137.61 160.35,137.6 159.48,137.6 159.47,137.61 159.47,138.03 160.35,138.03 160.42,138.02 160.48,137.99 160.51,137.97 161.15,137.97 161.32,138.14 161.34,138.19 161.36,138.24 161.39,138.28 161.42,138.31 161.44,138.32 161.62,138.32 161.7,138.26 161.87,138.26 161.97,138.16 162.12,138.31 162.14,138.36 162.15,138.37 162.2,138.41 162.24,138.47
GND on BOTTOM (solid shape): 111.18,117.31 111.23,117.26 111.31,117.21 111.48,117.05 111.48,117.04 111.64,116.87 111.87,116.87 111.88,116.87 112.14,116.87 112.22,116.79 112.22,116.6 112.19,116.57 112.11,116.32 112.26,116.1 112.29,116.09 112.29,115.86 112.26,115.84 112.2,115.79 112.15,115.73 112.03,115.73 111.99,115.78 111.95,115.82 111.76,115.88 111.23,115.47 111.18,115.44 111.14,115.39 109.08,115.39 109,115.47 109,115.74 109.05,115.8 111.01,115.8 111.4,116.18 111.4,116.25 111.4,116.26 111.42,116.37 111.4,116.47 111.4,116.48 111.4,116.67 110.96,117.1 110.96,117.23 111.01,117.27 111.06,117.31 111.07,117.32 111.16,117.32
GND on BOTTOM (solid shape): 207.04,77.45 207.08,77.42 207.42,77.07 207.42,76.93 207.31,76.82 207.31,76.79 207.3,76.78 207.27,76.63 207.34,76.5 207.38,76.46 207.45,76.39 207.48,76.31 207.49,76.25 207.85,75.89 207.9,75.87 207.98,75.84 208.06,75.78 208.59,75.25 208.68,75.16 208.68,74.11 208.55,73.98 207.92,73.98 207.83,74.07 207.83,75.24 207.75,75.32 207.75,75.37 207.6,75.52 207.6,75.66 207.6,75.67 207.6,75.76 207.55,75.83 207.31,76.07 207.27,76.08 207.08,76.27 207.08,76.31 207.07,76.39 207.03,76.46 206.93,76.55 206.9,76.57 206.85,76.6 206.82,76.64 206.82,76.76 206.88,76.81 206.95,76.91 206.96,77.03 206.95,77.12 206.95,77.19 206.81,77.33 206.81,77.4 206.92,77.52 206.98,77.52
GND on BOTTOM (solid shape): 153.87,140.72 153.87,139.85 153.74,139.71 152.52,139.71 152.48,139.67 152.42,139.67 152.08,139.33 151.45,139.33 151.42,139.3 151.4,139.3 151.27,139.16 151.25,139.14 151.22,139.12 151.09,139.12 150.9,139.25 150.67,139.23 150.59,139.17 150.53,139.1 150.38,138.95 150.35,138.85 150.29,138.8 150.25,138.73 150.13,138.73 150,138.86 150,139.02 150.05,139.06 150.08,139.11 150.23,139.25 150.24,139.25 150.4,139.34 150.49,139.5 150.49,139.52 150.64,139.66 150.69,139.71 150.74,139.76 150.9,139.76 151.06,139.64 151.26,139.65 151.34,139.7 151.38,139.75 152.05,139.75 152.23,139.93 152.23,140.13 152.87,140.78 153.82,140.78
GND on BOTTOM (solid shape): outline of 99 points within 97.57,41.95 104.78,47.07
GND on BOTTOM (solid shape): 162.01,95.1 162.07,95.04 162.14,94.99 162.26,94.87 162.26,94.35 162.09,94.18 161.98,94.07 161.94,93.93 161.94,93.91 161.87,93.84 161.83,93.84 161.79,93.78 161.75,93.74 161.71,93.7 161.67,93.67 161.67,93.43 161.71,93.4 161.76,93.35 161.8,93.31 161.83,93.2 161.8,93.09 161.75,93.05 161.71,93 161.67,92.98 161.63,92.97 161.57,92.97 161.39,92.78 161.31,92.71 161.24,92.69 161.17,92.73 161.14,92.76 161.1,92.79 161.1,93.62 161.2,93.73 161.25,93.87 161.25,93.89 161.33,93.97 161.37,93.97 161.4,94.01 161.45,94.05 161.48,94.09 161.51,94.1 161.54,94.11 161.59,94.13 161.96,94.5 161.96,94.77 161.87,94.82 161.83,94.85 161.81,94.9 161.81,95 161.82,95.02 161.85,95.05 161.91,95.1
GND on BOTTOM (solid shape): 176.3,139.96 176.86,139.96 176.86,139.96 176.91,139.96 176.96,139.95 177.01,139.92 177.07,139.86 177.09,139.81 177.21,139.69 177.24,139.69 177.26,139.67 177.46,139.67 177.58,139.79 177.77,139.79 177.84,139.72 177.92,139.68 177.94,139.68 177.99,139.62 177.99,139.61 178.09,139.39 178.3,139.3 178.32,139.3 178.37,139.24 178.38,139.23 178.43,139.13 178.51,139.06 178.53,139.05 178.53,138.93 178.47,138.87 178.4,138.8 178.23,138.8 178.2,138.85 178.16,138.88 178.16,138.93 178.12,138.97 178.11,139.01 177.98,139.15 177.95,139.16 177.9,139.22 177.83,139.28 177.8,139.28 177.67,139.31 177.54,139.28 177.51,139.28 177.46,139.23 177.42,139.2 177.24,139.2 177.21,139.23 177.18,139.3 177.12,139.3 177.08,139.34 175.94,139.34 175.76,139.16 174.82,139.16 174.76,139.22 174.76,139.96 174.86,140.06 176.2,140.06
GND on BOTTOM (solid shape): 205.76,106.86 205.76,105.9 205.77,105.89 205.77,105.87 205.92,105.72 205.94,105.72 206.05,105.61 206.05,104.69 205.96,104.6 205.96,104.28 206.04,104.2 206.04,104.19 206.09,104.1 206.17,104.04 206.17,103.88 206.09,103.82 206.04,103.73 206.04,103.72 205.95,103.64 205.93,103.63 205.75,103.54 205.65,103.35 205.65,103.33 205.56,103.25 205.55,103.24 205.47,103.19 205.41,103.12 205.25,103.12 205.2,103.18 205.14,103.23 205.11,103.24 205.11,103.37 205.14,103.39 205.2,103.43 205.25,103.49 205.27,103.5 205.3,103.51 205.36,103.52 205.5,103.65 205.51,103.68 205.57,103.73 205.63,103.8 205.63,103.83 205.66,103.96 205.63,104.09 205.63,104.12 205.56,104.19 205.51,104.24 205.5,104.27 205.5,104.31 205.5,104.75 205.59,104.84 205.59,105.22 205.55,105.26 204.93,105.26 204.81,105.38 204.81,105.64 204.89,105.73 205.1,105.73 205.2,105.83 205.2,106.88 205.25,106.92 205.7,106.92
GND on BOTTOM (solid shape): 75.36,118.35 75.44,118.31 75.52,118.24 75.62,118.2 75.66,118.15 75.66,118.15 75.69,117.95 75.83,117.8 75.88,117.71 75.83,117.62 75.69,117.48 75.66,117.28 75.66,117.27 75.62,117.22 75.52,117.18 75.44,117.11 75.36,117.07 75.28,117.11 75.16,117.2 75.01,117.23 74.99,117.23 74.78,117.43 73.59,117.43 73.41,117.61 73.41,118.02 73.6,118.21 74.2,118.21 74.24,118.2 74.28,118.19 74.39,118.19 74.52,118.22 74.63,118.31 74.71,118.35 75.04,118.19
GND on BOTTOM (solid shape): 112.99,114.15 113.04,114.18 113.1,114.17 114.06,113.21 114.14,113 114.34,112.91 114.44,112.92 114.52,112.95 114.81,112.66 115.75,112.66 115.91,112.51 115.91,112.4 115.78,112.28 115.45,112.28 115.45,112.28 114.77,112.28 114.67,112.38 114.67,112.41 114.65,112.54 114.57,112.65 114.41,112.73 114.24,112.71 114.19,112.68 114.14,112.63 113.94,112.63 113.87,112.69 113.8,112.72 113.78,112.73 113.74,112.77 113.74,112.8 113.7,113 113.55,113.14 113.55,113.2 113.37,113.38 113.32,113.38 113.25,113.46 113.16,113.51 113.13,113.51 113.09,113.56 113.09,113.58 113.07,113.75 112.97,113.89 112.94,113.91 112.91,113.92 112.91,114.02 112.88,114.05 112.9,114.07 112.92,114.09
GND on BOTTOM (solid shape): 176.78,52.46 176.78,52.4 176.76,52.39 176.69,52.31 176.64,52.2 176.64,52.19 176.46,52.01 176.44,51.99 176.41,51.96 175.6,51.96 175.4,51.77 175.4,51.53 175.48,51.46 175.54,51.38 175.62,51.32 175.91,51.02 176.28,51.02 176.55,51.29 176.68,51.29 176.76,51.21 176.85,51.16 176.87,51.15 176.92,51.1 177.02,51.1 177.09,51.17 177.1,51.17 177.19,51.24 177.26,51.33 177.26,51.34 177.57,51.65 177.68,51.65 177.82,51.51 177.82,51.42 177.72,51.33 177.54,51.14 177.53,51.14 177.38,51.06 177.29,50.91 177.29,50.89 177.05,50.66 176.87,50.66 176.83,50.7 176.77,50.74 176.76,50.78 176.6,50.94 176.42,50.75 176.37,50.69 176.33,50.66 176.14,50.66 176.1,50.68 175.82,50.68 175.48,51.02 175.42,51.02 175.07,51.37 173.91,51.37 173.82,51.45 173.82,51.9 173.85,51.92 175.06,51.92 175.4,52.27 176.24,52.27 176.46,52.48 176.51,52.51 176.54,52.55 176.69,52.55
GND on BOTTOM (solid shape): outline of 101 points within 278.11,79.48 287.59,84.82
GND on BOTTOM (solid shape): 113.06,115.75 113.13,115.72 113.18,115.68 113.24,115.65 113.3,115.63 113.36,115.62 113.39,115.6 113.41,115.57 113.46,115.4 113.6,115.29 113.68,115.27 113.76,115.28 114.1,114.94 114.08,114.9 114.07,114.86 114.18,114.54 114.52,114.53 114.56,114.55 114.86,114.25 115.68,114.25 115.89,114.03 115.89,113.85 114.76,113.85 114.67,113.95 114.67,113.97 114.57,114.23 114.29,114.3 114.2,114.26 114.12,114.19 113.96,114.19 113.88,114.26 113.78,114.3 113.75,114.32 113.74,114.36 113.71,114.56 113.56,114.71 113.56,114.99 113.45,115.1 113.43,115.12 113.4,115.13 113.31,115.22 113.14,115.22 112.91,115.46 112.91,115.66 112.95,115.69 112.99,115.72
GND on BOTTOM (solid shape): 159.96,87.34 160.02,87.29 160.3,87.01 160.3,86.68 160.3,86.67 160.28,86.47 160.4,86.31 160.4,86.09 160.27,85.85 160.4,85.61 160.4,85.39 160.35,85.34 160.3,85.28 160.02,85 159.78,85 159.7,85.08 159.7,85.19 159.72,85.23 159.77,85.28 159.85,85.32 159.85,85.5 159.85,85.68 159.78,85.71 159.74,85.76 159.71,85.78 159.7,85.83 159.7,85.87 159.71,85.91 159.75,85.94 159.79,85.99 159.85,86.02 159.85,86.19 159.85,86.38 159.73,86.45 159.71,86.49 159.7,86.53 159.7,86.57 159.71,86.61 159.73,86.64 159.76,86.68 159.76,87.12 159.73,87.16 159.71,87.19 159.7,87.23 159.7,87.27 159.71,87.31 159.73,87.34 159.76,87.37 159.81,87.4 159.9,87.4
GND on BOTTOM (solid shape): outline of 102 points within 113.61,47.89 117.6,56.78
GND on BOTTOM (solid shape): 207.53,106.79 207.53,106.02 207.31,105.8 207.28,105.8 207.19,105.71 207.11,105.65 207.06,105.58 207.01,105.53 207.01,105.49 206.98,105.47 206.98,105.21 207.01,105.18 207.01,105.14 207.31,104.84 207.37,104.83 207.45,104.74 207.45,104.52 207.41,104.48 207.38,104.45 207.34,104.41 207.32,104.28 207.35,104.16 207.4,104.09 207.46,104.04 207.46,103.88 207.41,103.83 207.37,103.78 207.22,103.63 207.2,103.63 207.05,103.54 206.96,103.38 206.95,103.37 206.8,103.22 206.76,103.18 206.71,103.13 206.56,103.13 206.43,103.26 206.43,103.38 206.51,103.44 206.56,103.52 206.56,103.53 206.66,103.63 206.68,103.63 206.96,103.9 206.79,104.25 206.79,104.41 206.8,104.43 206.9,104.53 206.9,104.77 206.86,104.81 206.85,104.82 206.78,104.93 206.67,105 206.66,105.01 206.34,105.33 206.34,105.62 206.64,105.93 206.64,106.82 206.67,106.85 207.47,106.85
GND on BOTTOM (solid shape): 242.4,93.68 243.45,93.51 244.5,93.37 244.53,93.35 244.61,93.1 244.61,93.09 244.62,92.96 244.68,92.84 244.69,92.84 244.79,92.52 244.79,92.51 244.8,92.38 244.86,92.26 244.87,92.25 244.97,91.93 244.98,91.77 245.05,91.63 245.06,91.63 245.11,91.46 245.15,91.33 245.2,91.21 245.23,91.14 245.27,91.07 245.43,90.82 245.63,90.59 245.7,90.51 245.78,90.45 246.1,90.23 246.45,90.07 246.56,90.01 246.68,90 246.84,89.97 247.01,89.95 247.22,89.94 247.43,89.92 247.46,89.91 247.57,89.89 247.69,89.91 247.91,89.9 248.13,89.89 248.17,89.88 248.21,89.87 248.27,89.87 248.33,89.88 248.5,89.88 248.5,88.16 248.42,87.92 248.5,87.67 248.5,86.65 247.89,86.04 245.04,86.04 244.42,86.66 244.42,89.48 242.96,90.94 242.96,91.83 242.27,92.51 242.27,93.58 242.37,93.68
GND on BOTTOM (solid shape): 161.65,73.24 161.69,73.24 161.71,73.22 161.86,73.13 162.03,73.13 162.12,73.11 162.16,73.03 162.16,72.87 162.04,72.75 162,72.73 161.64,72.3 162.19,72.18 162.3,72.21 162.37,72.11 162.37,72.01 161.97,71.61 161.95,71.61 161.72,71.05 162.28,71.28 162.28,71.3 162.39,71.41 162.5,71.43 162.57,71.34 162.57,70.49 161.85,69.77 159.04,69.77 158.78,70.03 158.78,70.62 159.01,70.84 159.04,70.83 159.19,70.82 159.34,70.87 159.57,70.87 160.58,71.88 160.58,72.37 160.57,72.43 160.57,74.01 160.65,74.09 160.8,74.09
GND on BOTTOM (solid shape): 113.06,109.45 113.14,109.42 113.24,109.35 113.36,109.32 113.38,109.31 113.41,109.29 113.41,109.27 113.5,109.06 113.71,108.97 113.73,108.97 114.07,108.64 115.21,108.64 115.29,108.55 115.29,108.4 115.26,108.36 114.67,108.36 114.66,108.36 114.56,108.36 114.23,108.03 114.23,107.98 114.11,107.87 114.06,107.72 114.06,107.7 113.09,106.74 113.06,106.73 113.03,106.73 112.98,106.78 112.88,106.87 112.91,106.9 112.91,106.99 113.06,107.13 113.11,107.34 113.11,107.36 113.14,107.41 113.16,107.41 113.25,107.46 113.32,107.54 113.42,107.54 113.56,107.68 113.56,107.78 113.68,108.31 113.14,108.35 113.07,108.32 112.99,108.35 112.96,108.38 112.92,108.41 112.87,108.49 112.92,108.58 113.03,108.68 113.08,108.81 113.06,109.03 112.92,109.19 112.92,109.37 112.96,109.39 112.99,109.42
GND on BOTTOM (solid shape): 113.06,111.03 113.14,111 113.24,110.93 113.36,110.89 113.39,110.88 113.41,110.84 113.45,110.7 113.55,110.6 113.55,110.55 113.93,110.17 113.96,110.17 114.03,110.14 114.06,110.07 114.11,109.9 114.25,109.78 114.26,109.78 114.3,109.73 114.33,109.64 114.26,109.57 114.18,109.53 114.12,109.46 114.04,109.42 113.96,109.46 113.89,109.53 113.8,109.57 113.78,109.58 113.75,109.62 113.75,109.64 113.7,109.84 113.56,109.99 113.56,110.02 113.35,110.23 113.32,110.23 113.31,110.25 113.06,110.37 112.74,110.21 112.66,110.25 112.58,110.32 112.48,110.36 112.45,110.38 112.44,110.42 112.44,110.45 112.44,110.51 112.48,110.55 112.5,110.56 112.65,110.67 112.72,110.84 112.73,110.88 112.77,110.89 112.89,110.93 112.99,111
GND on BOTTOM (solid shape): 76.36,127.37 76.41,127.3 76.48,127.25 76.53,127.16 76.48,127.07 76.34,126.92 76.31,126.73 76.3,126.69 76.27,126.67 76.03,126.37 76.27,126.07 76.29,126.05 76.3,126.02 76.34,125.82 76.48,125.67 76.53,125.58 76.48,125.5 76.31,125.18 76.51,124.87 76.51,124.73 76.09,124.73 76.02,124.75 75.99,124.82 75.92,124.99 75.77,125.09 75.77,125.29 75.99,125.64 75.66,125.89 75.64,125.89 75.37,126.16 75.3,126.16 75.3,126.22 75.31,126.23 75.29,126.55 75,126.68 74.87,126.81 74.87,127.21 74.98,127.32 75.48,127.32 75.57,127.41 76.31,127.41
GND on BOTTOM (solid shape): 172.62,84.44 172.62,84.35 172.47,84.01 172.69,83.71 172.87,83.6 172.93,83.53 173.11,83.45 173.29,83.48 173.4,83.48 173.76,83.84 173.96,83.84 174.06,83.75 174.17,83.7 174.25,83.68 174.26,83.66 174.31,83.56 174.4,83.49 174.45,83.4 174.4,83.31 174.32,83.24 174.26,83.15 174.26,83.13 174.15,83.09 173.97,82.96 173.9,82.75 173.9,82.71 173.87,82.63 173.79,82.6 173.67,82.6 173.11,82.04 173.04,82.01 172.97,82.04 172.72,82.13 172.47,82.02 172.39,82.02 172.05,82.36 172.03,82.47 171.96,82.56 171.9,82.63 171.7,82.93 171.57,83.01 171.45,83.03 171.33,83.01 171.19,82.93 171.1,82.8 171.1,82.79 171.05,82.75 171,82.79 170.98,82.84 170.98,83.25 172.22,84.49 172.26,84.52 172.53,84.52
GND on BOTTOM (solid shape): 112.11,114.75 112.18,114.59 112.33,114.5 112.35,114.49 112.38,114.44 112.38,114.35 112.35,114.3 112.33,114.3 112.24,114.26 112.17,114.19 112.09,114.15 112.01,114.19 111.51,114.18 111.68,113.71 111.7,113.7 111.73,113.66 111.73,113.64 111.77,113.44 111.91,113.3 111.96,113.22 111.91,113.13 111.87,113.1 111.84,113.07 111.76,113.04 111.69,113.07 111.6,113.14 111.48,113.17 111.46,113.18 111.42,113.22 111.41,113.28 111.4,113.33 111.4,113.37 111.36,113.39 111.3,113.45 111.24,113.49 111.2,113.63 111.13,113.7 111.13,113.71 111.06,113.84 110.95,113.93 110.93,114.01 110.95,114.08 111.01,114.12 111.06,114.17 111.1,114.18 111.14,114.18 111.32,114.23 111.4,114.41 111.4,114.68 111.41,114.72 111.42,114.79 112.1,114.79
GND on BOTTOM (solid shape): 97.17,120.89 97.17,110.56 96.99,110.46 96.9,110.27 96.89,110.25 96.84,110.2 96.82,110.2 96.52,110 96.63,109.65 96.67,109.57 96.62,109.49 96.57,109.44 96.53,109.37 96.52,109.36 96.47,109.32 96.45,109.33 96.16,109.29 96,109.04 96,109.02 95.94,108.97 95.85,108.95 95.78,109.02 95.74,109.1 95.69,109.18 95.66,109.25 95.79,109.57 95.66,109.9 95.69,109.97 95.75,110.06 95.79,110.16 95.82,110.22 95.89,110.24 95.97,110.25 96.05,110.29 96.06,110.29 96.09,110.29 96.33,110.54 96.4,110.54 96.6,110.64 96.7,110.82 96.69,111.07 96.51,111.25 96.34,111.42 96.34,121.01 96.49,121.16 96.9,121.16
GND on BOTTOM (solid shape): 169.01,89.51 169.05,89.46 169.1,89.42 169.1,87.9 169.05,87.85 169.02,87.82 168.96,87.78 168.96,87.7 168.95,87.6 168.96,87.5 168.96,87.42 169.02,87.38 169.05,87.35 169.09,87.32 169.1,87.29 169.1,87.2 169.09,87.18 169.05,87.12 169.05,86.67 169.07,86.64 169.09,86.62 169.1,86.6 169.1,86.5 169.09,86.48 169.05,86.45 169.02,86.42 168.96,86.38 168.96,86.3 168.95,86.2 168.96,86.1 168.96,86.02 169.02,85.98 169.05,85.95 169.09,85.92 169.1,85.9 169.1,85.8 169.09,85.78 169.05,85.75 169.02,85.72 168.96,85.68 168.96,85.6 168.95,85.5 168.96,85.4 168.96,85.32 169.02,85.28 169.05,85.25 169.09,85.22 169.1,85.19 169.1,85.12 168.98,85 168.59,85 168.52,85.08 168.53,85.1 168.51,85.26 168.41,85.38 168.41,85.62 168.53,85.85 168.41,86.08 168.41,86.32 168.52,86.46 168.51,86.64 168.51,87.16 168.52,87.34 168.41,87.48 168.41,87.72 168.52,87.88 168.5,88.07 168.5,88.53 168.53,88.64 168.51,88.75 168.51,89.25 168.52,89.3 168.53,89.35 168.56,89.34 168.6,89.34 168.78,89.38 168.91,89.51
GND on BOTTOM (solid shape): outline of 160 points within 86.11,41.77 97.02,46.65
GND on BOTTOM (solid shape): 154.2,111.21 154.31,111.23 154.37,111.14 154.37,110.84 154.69,110.52 154.68,110.48 154.66,110.44 154.65,110.38 154.6,110.34 154.58,110.34 154.27,110.06 154.43,109.68 154.47,109.64 154.48,109.58 154.36,109.47 154.32,109.31 154.36,109.06 154.56,108.9 154.66,108.86 154.67,108.84 154.72,108.75 154.8,108.69 154.85,108.6 154.8,108.51 154.72,108.45 154.67,108.37 154.66,108.35 154.57,108.32 154.43,108.25 154.34,108.13 154.26,108.08 154.17,108.12 154.07,108.22 153.94,108.28 153.85,108.3 153.84,108.33 153.79,108.43 153.7,108.51 153.65,108.6 153.7,108.69 153.79,108.76 153.84,108.86 153.85,108.87 154.05,108.99 154.13,109.1 154.16,109.43 153.9,109.62 153.87,109.63 153.85,109.67 153.81,109.81 153.7,109.91 153.65,110 153.7,110.09 153.81,110.2 153.85,110.34 153.85,110.37 154.1,110.62 154.1,111.12
GND on BOTTOM (solid shape): outline of 95 points within 160.69,84.97 162.48,92.31
GND on BOTTOM (solid shape): outline of 90 points within 160.81,95.45 162.5,102.11
GND on BOTTOM (solid shape): 315.24,94.42 315.14,94.35 315.05,94.28 314.77,93.79 314.79,93.23 315.16,92.73 315.75,92.54 322.14,92.54 322.14,87.36 321.9,87.36 321.4,86.86 321.01,86.86 320.99,86.86 320.96,86.87 321.2,87.69 320.5,88.19 318.5,88.19 317.8,87.69 318.04,86.87 318.01,86.86 317.99,86.86 315.62,86.86 315.25,87.22 314.75,87.36 314.75,87.36 314.04,87.06 313.74,86.35 313.74,82.98 313.67,82.91 313.3,82.91 313.24,82.98 313.24,85.71 312.21,85.71 312.08,85.84 312.08,86.21 312.21,86.34 313.24,86.34 313.24,86.48 313.26,86.6 313.14,86.72 311.13,86.72 310.8,87.05 310.8,90.42 311.42,91.04 321.64,91.04 321.64,91.68 320.66,91.68 320.66,92.04 316.46,92.04 316.46,91.68 315.32,91.68 315.32,92.1 314.27,93.21 314.74,94.67 314.74,95.61 315.24,95.61
GND on BOTTOM (solid shape): 186.57,99.12 186.57,98 186.35,97.78 186.24,97.76 186.18,97.86 186.18,98.18 186.08,98.74 185.63,98.41 185.59,98.32 185.5,98.3 185.17,98.24 185.06,97.92 185.05,97.87 185.03,97.82 184.93,97.73 184.83,97.7 184.76,97.78 184.37,98.03 184.12,97.63 184.1,97.57 184.07,97.5 183.9,97.34 183.74,97.34 183.66,97.38 183.65,97.48 183.38,97.93 183.01,97.55 182.99,97.5 182.83,97.34 182.7,97.34 182.62,97.39 182.61,97.48 182.35,97.94 181.98,97.57 181.96,97.52 181.78,97.34 181.57,97.34 181.46,97.44 181.46,97.47 181.52,97.61 181.51,97.77 181.49,97.8 181.61,97.91 181.86,97.91 181.94,98 182.05,98 182.48,98.43 182.48,98.5 182.48,98.51 182.51,98.63 182.48,98.76 182.48,98.77 182.48,99.02 182.63,99.17 186.52,99.17
GND on BOTTOM (solid shape): 313.74,72.85 314.49,71.88 315.62,72.34 318.35,72.34 317.89,71.67 318.5,71.14 320.5,71.14 321.11,71.67 320.65,72.34 321.39,72.34 321.39,59.46 320.94,59.46 321.2,60.28 320.5,60.79 318.5,60.79 317.8,60.28 318.06,59.46 315.62,59.46 315.25,59.82 314.75,59.96 314.75,59.96 314.04,59.66 313.74,58.95 313.74,55.48 313.24,55.48 313.24,58.4 312.32,58.4 312.27,58.45 312.27,58.73 312.32,58.78 313.24,58.78 313.24,58.95 313.25,59.12 313.28,59.29 311.13,59.29 310.88,59.54 310.88,61.69 310.86,61.69 310.86,70.2 310.88,70.2 310.88,71.86 311.38,72.37 313.16,72.37 313.28,72.49 313.25,72.67 313.24,72.85 313.24,72.88 312.43,72.88 312.35,72.96 312.35,73.44 312.43,73.51 313.74,73.51
GND on BOTTOM (solid shape): outline of 228 points within 43.67,111.11 56.52,117.58
GND on BOTTOM (solid shape): 153.03,114.71 155.67,114.71 155.92,114.46 155.92,113.87 155.88,113.79 155.79,113.78 155.58,113.79 155.4,113.69 155.33,113.66 155.26,113.69 155.07,113.87 155.03,114.04 154.65,114.33 154.32,113.98 154.26,113.89 154.15,113.91 153.69,114.38 153.68,114.38 153.67,114.39 153.26,114.46 153.07,114.1 153.04,114.02 152.97,113.99 152.44,113.99 152.39,114.16 152.06,114.45 151.7,114.2 151.63,114.13 151.53,114.17 150.92,114.07 151.33,113.6 151.33,113.6 151.43,113.6 151.47,113.56 151.49,113.45 151.41,113.39 151.15,113.21 151.14,112.89 151.13,112.8 151.05,112.75 150.93,112.75 150.39,113.3 150.39,113.34 150.39,113.35 149.9,113.79 149.96,113.14 149.97,113.13 150.04,113.06 150.76,112.35 151.25,112.35 151.31,112.29 151.31,112.09 151.25,112.05 151.21,112 150.99,112 150.97,112.02 150.84,112.12 150.67,112.12 150.63,112.16 150.18,112.16 150.06,112.18 150.06,112.18 149.87,112.22 149.69,112.17 149.35,112.17 148.91,112.6 147.69,113.82 147.69,114.71 148.03,115.05 152.69,115.05
GND on BOTTOM (solid shape): outline of 94 points within 144.3,100.39 149.87,105.83
GND on BOTTOM (solid shape): outline of 95 points within 64.93,110.58 77.53,118.35
GND on BOTTOM (solid shape): outline of 91 points within 176.52,72.92 181.89,80.39
GND on BOTTOM (solid shape): outline of 137 points within 152.53,84.99 153.39,102.83
GND on BOTTOM (solid shape): outline of 100 points within 151.28,105.57 154.92,111.24
GND on BOTTOM (solid shape): outline of 335 points within 59.4,19.55 105.74,39.06
GND on BOTTOM (solid shape): outline of 173 points within 169.8,85 170.5,102.81
GND on BOTTOM (solid shape): outline of 174 points within 168.41,89.88 169.1,102.81
GND on BOTTOM (solid shape): outline of 462 points within 130.08,177.59 184.38,192.39
GND on BOTTOM (solid shape): outline of 200 points within 166.98,84.98 167.69,102.8
GND on BOTTOM (solid shape): outline of 183 points within 164.2,85 164.9,102.8
GND on BOTTOM (solid shape): outline of 197 points within 165.6,85 166.28,102.81
GND on BOTTOM (solid shape): outline of 182 points within 155.51,84.99 156.23,102.83
GND on BOTTOM (solid shape): outline of 217 points within 72.94,119.08 79.14,125.63
GND on BOTTOM (solid shape): outline of 514 points within 39.17,50.36 67.73,58.58
GND on BOTTOM (solid shape): outline of 231 points within 159.7,87.81 160.4,102.81
GND on BOTTOM (solid shape): outline of 156 points within 170.9,103.34 176.98,107.9
GND on BOTTOM (solid shape): outline of 224 points within 158.31,85 159.02,102.81
GND on BOTTOM (solid shape): outline of 141 points within 169.63,112.22 178.49,119.39
GND on BOTTOM (solid shape): outline of 231 points within 156.89,85 157.59,102.83
GND on BOTTOM (solid shape): outline of 219 points within 154.08,84.96 154.82,102.85
GND on BOTTOM (solid shape): outline of 638 points within 83.71,50.32 106.47,59.01
GND on BOTTOM (solid shape): outline of 321 points within 162.78,84.99 163.5,101.4
GND on BOTTOM (solid shape): outline of 870 points within 89.3,102.54 96.67,112.05
GND on BOTTOM (solid shape): outline of 1149 points within 183.23,179.34 211.4,193.15
GND on BOTTOM (solid shape): outline of 956 points within 108.68,103.07 117.18,112.81
GND on BOTTOM (solid shape): outline of 1672 points within 109.87,121.45 120.71,131.05
GND on BOTTOM (solid shape): outline of 1920 points within 96.09,93.15 118.89,112.02
GND on BOTTOM (solid shape): outline of 2915 points within 70.12,95.11 90.06,118.76
GND on BOTTOM (solid shape): outline of 6966 points within 0.51,0.51 323.99,193.19
GND on BOTTOM (solid shape): outline of 6971 points within 216.37,48.54 237.72,70.64
GND on GND1 (solid shape): outline of 5802 points within 0.51,0.51 323.99,193.19
GND on IN1 (solid shape): 37.82,99 37.82,93.54 31.54,87.25 31.54,85.43 30.92,84.81 24.93,84.81 24.41,85.32 24.41,89.61 34.48,99.68 37.14,99.68
GND on IN1 (solid shape): 103,192.92 103.59,192.92 103.65,192.85 103.67,192.82 103.65,192.78 102.57,191.7 101.78,191.7 100.26,190.18 96.96,190.18 96.88,190.25 96.88,190.43 96.9,190.47 96.93,190.48 97.46,190.48 97.5,190.44 99.66,190.44 100.08,190.87 100.08,191.45 99.83,191.7 98.27,191.7 98.2,191.63 97.48,191.63 97.34,191.5 96.93,191.5 96.9,191.51 96.88,191.55 96.88,192.01 96.96,192.08 98.58,192.08 99.09,192.59 99.09,192.82 99.35,193.07 103,193.07
GND on IN1 (solid shape): outline of 89 points within 284.05,38.87 287.31,46.69
GND on IN1 (solid shape): outline of 324 points within 214.04,30.86 233.22,36.15
GND on IN1 (solid shape): outline of 742 points within 18.31,46.62 34.02,69.89
GND on IN1 (solid shape): outline of 858 points within 68.67,3.63 115.7,15.12
GND on IN1 (solid shape): outline of 12478 points within 0.51,0.51 323.99,193.19
GND on GND2 (solid shape): outline of 5632 points within 0.51,0.51 323.99,193.19
GND on IN2 (solid shape): 36.85,99.45 36.85,88.58 33.02,84.76 24.76,84.76 24.43,85.1 24.43,90.14 34.34,100.05 36.25,100.05
GND on IN2 (solid shape): 46.74,185.92 46.85,185.94 46.91,185.85 46.91,185.39 47.77,184.53 47.77,181.36 47.18,180.77 47.18,176.95 46.22,175.99 46.11,175.97 46.05,176.06 46.05,185.23
GND on IN2 (solid shape): outline of 313 points within 0.54,46.37 13.29,59.62
GND on IN2 (solid shape): outline of 307 points within 4.93,17.05 10.78,31.62
GND on IN2 (solid shape): outline of 688 points within 77.86,3.51 156.3,21.75
GND on IN2 (solid shape): outline of 722 points within 3.51,51.24 18.46,78.63
GND on IN2 (solid shape): outline of 1090 points within 88.33,153.94 107.55,168.48
GND on IN2 (solid shape): outline of 1767 points within 21,23.52 57.9,62.84
GND on IN2 (solid shape): outline of 2177 points within 299.15,49.54 322.14,95.74
GND on IN2 (solid shape): outline of 7919 points within 0.51,0.51 323.99,193.19
GND on GND3 (solid shape): outline of 5935 points within 0.51,0.51 323.99,193.19
GND on VCC1 (solid shape): outline of 5471 points within 0.51,0.51 323.99,193.19
GND on VCC2 (solid shape): outline of 5530 points within 0.51,0.51 323.99,193.19
GND on GND4 (solid shape): outline of 5566 points within 0.51,0.51 323.99,193.19
GND on IN3 (solid shape): 13,57.04 13,53.03 12.78,52.81 11.69,52.81 9.94,54.56 9.94,56.75 10.31,57.13 12.9,57.13
GND on IN3 (solid shape): outline of 160 points within 24.48,80.69 40.41,101.74
GND on IN3 (solid shape): outline of 276 points within 0.63,46.38 13.25,59.7
GND on IN3 (solid shape): outline of 643 points within 3.53,57.89 18.4,79.09
GND on IN3 (solid shape): outline of 1010 points within 310.62,59.26 322.14,95.74
GND on IN3 (solid shape): outline of 1311 points within 0.54,5.06 22.77,31.54
GND on IN3 (solid shape): outline of 6400 points within 0.51,0.51 323.99,193.19
GND on GND5 (solid shape): outline of 5462 points within 0.51,0.51 323.99,193.19
GND on IN4 (solid shape): 21.05,28.3 19.5,28.3 19.5,29.1 21.05,29.1
GND on IN4 (solid shape): 21.05,26.8 19.5,26.8 19.5,27.6 21.05,27.6
GND on IN4 (solid shape): 41.4,13.35 40.6,13.35 40.6,14.9 41.4,14.9
GND on IN4 (solid shape): 42.9,13.35 42.1,13.35 42.1,14.9 42.9,14.9
GND on IN4 (solid shape): 14.48,58.54 14.84,58.27 15.2,58.54 16.89,58.54 18.94,56.5 18.94,51.33 18.39,50.78 15.35,50.78 14.73,51.4 12.78,51.4 9.99,54.19 9.99,58.25 10.28,58.54
GND on IN4 (solid shape): 22.36,35 22.36,28.25 21.97,27.86 21.94,27.87 21.58,27.73 21.52,27.34 21.52,26.78 21.4,26.65 19.54,26.65 18.64,27.55 18.52,27.55 18,28.07 18,30.19 17.65,30.54 16.9,30.54 16.72,30.72 16.72,35.03 17,35.3 22.05,35.3
GND on IN4 (solid shape): 112.7,130.72 112.7,130.66 112.71,130.66 112.71,130.09 112.33,129.71 112.33,126.89 112.33,126.89 112.33,126.83 111.34,125.84 109.37,125.84 109.14,126.07 109.14,126.21 109.15,126.66 108.71,126.75 108.69,126.75 108.59,126.85 108.59,127.34 108.65,127.4 108.75,127.4 108.89,127.38 109.02,127.41 109.2,127.41 109.35,127.27 109.3,127.04 109.4,126.83 109.4,126.69 109.63,126.08 109.93,126.66 109.93,126.8 110.04,126.91 110.04,128.82 111.58,130.36 111.55,130.44 111.54,130.52 111.56,130.61 111.67,130.72 111.75,130.74 111.84,130.73 111.92,130.7 111.93,130.71 112.29,130.71 112.4,130.82 112.6,130.82
GND on IN4 (solid shape): outline of 166 points within 201.31,133.78 211.44,152.66
GND on IN4 (solid shape): outline of 180 points within 37.88,12.62 46.34,17.63
GND on IN4 (solid shape): outline of 184 points within 284.63,144.56 322.08,168.33
GND on IN4 (solid shape): outline of 310 points within 0.58,46.36 13.07,59.09
GND on IN4 (solid shape): outline of 493 points within 39.85,163.93 54.18,191.3
GND on IN4 (solid shape): outline of 610 points within 0.58,5.14 28.7,15.28
GND on IN4 (solid shape): outline of 731 points within 219.26,9.99 242.67,22.31
GND on IN4 (solid shape): outline of 731 points within 3.64,60.97 20.52,79.11
GND on IN4 (solid shape): outline of 805 points within 34.99,88.22 53.21,127.82
GND on IN4 (solid shape): outline of 796 points within 70.95,152.35 90.35,184.55
GND on IN4 (solid shape): outline of 895 points within 69.37,4.1 157.46,15.85
GND on IN4 (solid shape): outline of 986 points within 310.62,59.26 322.14,93.32
GND on IN4 (solid shape): outline of 2185 points within 128.8,172.26 211.37,193.15
GND on IN4 (solid shape): outline of 2213 points within 95.01,162.3 127.58,189.74
GND on IN4 (solid shape): outline of 2865 points within 292.78,89.57 322.14,143.01
GND on IN4 (solid shape): outline of 3411 points within 0.51,0.51 323.99,193.19
GND on GND6 (solid shape): outline of 5354 points within 0.51,0.51 323.99,193.19
GND on TOP: 252.84,43.21 253.2,43.21
GND_LED on TOP (solid shape): outline of 897 points within 214.51,185.71 259.49,193.19
GND_LED on BOTTOM (solid shape): outline of 863 points within 214.51,185.71 259.49,193.19
GND_LED on GND1 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on IN1 (solid shape): outline of 764 points within 214.51,185.71 259.49,193.19
GND_LED on GND2 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on IN2 (solid shape): outline of 831 points within 214.51,185.71 259.49,193.19
GND_LED on GND3 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on VCC1 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on VCC2 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on GND4 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on IN3 (solid shape): outline of 831 points within 214.51,185.71 259.49,193.19
GND_LED on GND5 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_LED on IN4 (solid shape): outline of 831 points within 214.51,185.71 259.49,193.19
GND_LED on GND6 (solid shape): outline of 195 points within 214.51,185.71 259.49,193.19
GND_SIGNAL on TOP (solid shape): 282.89,36.38 282.89,35.4 282.66,35.18 282.38,35.18 282.28,35.27 282.28,35.55 282.13,35.7 281.15,35.7 280.84,36.02 280.84,36.46 280.91,36.54 282.73,36.54
GND_SIGNAL on IN3 (solid shape): outline of 1100 points within 265.64,26.73 285.98,42.06
VCC0P9_CIO on BOTTOM (solid shape): 293.6,42.4 293.6,42.22 293.38,41.99 293.15,41.99 293.05,41.89 293.05,40.49 292.94,40.39 292.56,40.39 292.54,40.42 292.54,42.35 292.69,42.5 293.5,42.5
VCC0P9_DP on TOP (solid shape): 292.63,41.42 292.65,41.37 292.65,41.32 292.63,41.31 292.51,41.04 292.65,40.79 292.65,40.63 292.63,40.56 292.44,40.37 292.43,40.37 292.34,40.33 292.13,40.13 292.11,40.12 292.04,40.1 291.97,40.06 291.94,40.04 291.75,40.04 291.71,40.07 291.71,40.11 291.67,40.15 291.67,40.62 291.83,40.77 291.83,40.94 291.85,41.07 291.83,41.2 291.83,41.51 291.87,41.56 292.49,41.56
VCC0P9_DP on TOP (solid shape): 294.49,43.5 294.77,43.34 295.05,43.5 295.39,43.5 295.47,43.46 295.49,43.38 295.52,43.24 295.62,43.13 295.64,43.11 295.64,42.93 295.62,42.92 295.53,42.82 295.49,42.7 295.49,42.44 295.36,42.3 295.13,42.3 295.1,42.3 295.06,42.3 294.49,42.3 294.45,42.35 294.45,42.35 294.41,42.53 294.28,42.66 294.28,43.36 294.36,43.44 294.41,43.5
VCC0P9_DP on IN2 (solid shape): outline of 657 points within 287.59,38.79 295.71,41.99
VCC0P9_DP on IN3 (solid shape): outline of 347 points within 291.57,39.36 295.64,43.31
VCC0P9_LVR on BOTTOM (solid shape): outline of 83 points within 297.56,33.24 299.93,37.36
VCC0P9_PCIE on TOP (solid shape): 294.9,39.83 294.9,39.61 294.86,39.53 294.84,39.45 294.82,39.43 294.82,38.69 295.19,38.32 295.19,37.49 295.13,37.42 295.11,37.42 294.8,37.73 294.55,37.73 294.22,37.62 294.3,37.29 294.3,37.16 294.17,37.03 294.01,37.03 293.57,37.46 293.57,38.15 293.58,38.16 293.7,38.23 293.78,38.35 293.78,38.36 293.93,38.51 293.93,38.58 294.05,38.8 293.93,39.02 293.93,39.23 294.05,39.41 293.99,39.61 293.98,39.64 293.99,39.66 294,39.68 294,39.82 294.38,40.21 294.53,40.21
VCC0P9_PCIE on BOTTOM (solid shape): 295,40.46 295,40.32 294.7,40.02 294.7,40.01 294.58,39.9 294.58,39.35 294.54,39.3 294.54,37.96 294.72,37.78 294.95,37.78 295.02,37.71 295.02,37.54 294.94,37.46 294.61,37.46 294.51,37.36 294.51,36.77 294.44,36.57 294.5,36.36 294.51,36.35 294.51,36.31 294.63,36.19 294.63,35.87 294.59,35.82 294.35,35.82 294.14,36.04 294.14,36.92 293.96,37.1 293.96,39.88 294.58,40.5 294.96,40.5
VCC0P9_SVR on TOP (solid shape): 302.23,51.44 302.23,50.71 302.49,50.45 302.49,50.15 302.81,49.82 307.35,49.82 307.66,49.51 307.66,48.67 307.2,48.21 302.57,48.21 301.27,49.51 298.7,49.51 298.24,49.97 298.24,51.22 298.68,51.67 301.99,51.67
VCC0P9_SVR on TOP (solid shape): 295.81,42.17 295.93,42.07 296.09,42.04 296.13,42.03 296.15,42 296.23,41.85 296.4,41.79 296.5,41.79 296.64,41.93 296.81,41.93 297.04,41.67 297.14,41.46 297.35,41.36 297.37,41.36 297.69,41.04 297.75,40.88 297.75,40.6 297.7,40.42 297.75,40.24 297.75,39.9 297.72,39.83 297.72,39.75 297.67,39.7 297.59,39.68 297.52,39.64 297.47,39.56 297.44,39.48 297.44,39.47 297.42,39.45 297.33,39.45 297.25,39.43 297.03,39.43 296.91,39.55 296.91,40.86 296.65,41.11 296.65,41.41 296.47,41.64 296.19,41.55 296.16,41.52 295.98,41.52 295.94,41.56 295.72,41.65 295.52,41.52 295.33,41.52 295.29,41.56 295.07,41.65 294.87,41.52 294.74,41.52 294.41,41.85 294.39,41.9 294.35,41.94 294.32,41.98 294.32,42.1 294.35,42.14 294.39,42.17
VCC0P9_SVR on BOTTOM (solid shape): outline of 100 points within 297.03,38.54 304.91,51.8
VCC0P9_SVR on IN4 (solid shape): outline of 536 points within 296.61,39.25 303.39,51.68
VCCIO_BST on BOTTOM (solid shape): 107.25,167.89 107.25,167.44 107.17,167.36 105.75,167.36 105.48,167.64 104.53,167.64 104.51,167.65 104.51,167.87 104.52,167.88 106.25,167.88 106.32,167.95 107.19,167.95
VCCIO_BST_R on BOTTOM (solid shape): 107.22,166.68 107.22,165.02 106.96,164.75 106.28,164.75 106.23,164.8 106.23,166.8 106.26,166.84 107.07,166.84
VCCIO_LX on BOTTOM (solid shape): 112.2,170.76 115.16,170.76 115.39,170.53 115.39,166.62 114.77,166 109.57,166 108.28,164.7 107.81,164.7 107.72,164.79 107.72,167.83 107.42,168.13 103.37,168.13 103.32,168.18 103.32,168.34 103.35,168.37 105.34,168.37 106.35,169.39 107.58,169.39 107.93,169.74 107.93,172.74 108.55,173.35 109.6,173.35
VCCIO_O on BOTTOM (solid shape): 117.04,165.46 117.04,160.35 115.9,159.21 115.9,158.7 115.89,158.69 115.89,158.35 115.72,158.18 113.01,158.18 112.46,158.73 107.07,158.73 106.94,158.86 106.94,160.87 108.28,162.21 108.28,164.06 109.89,165.66 116.84,165.66
VCCIO_RC on BOTTOM (solid shape): 107.64,171.8 107.64,170.36 107.52,170.24 105.27,170.24 104.67,170.84 104.67,171.23 104.78,171.34 105.29,171.34 106.01,172.07 107.37,172.07
VDD18 on TOP (solid shape): outline of 635 points within 149.22,67.71 158.22,84.36
VDD18 on BOTTOM (solid shape): 158.25,83.47 158.25,83.37 158.08,83.12 158.14,82.83 158.22,82.71 158.22,82.55 158.2,82.52 158.17,82.47 158.02,82.32 158,82.32 157.89,82.28 157.8,82.2 157.75,82.15 157.58,81.98 156.46,81.98 156.41,82.01 156.43,82.07 156.44,82.08 156.45,82.09 156.55,82.55 156.09,82.45 156.09,82.44 156,82.36 155.98,82.36 155.74,82.24 155.64,82 155.63,81.98 155.27,81.98 155.07,82.17 154.62,82.17 154.55,82.21 154.52,82.3 154.33,82.62 153.99,82.46 153.99,82.45 153.9,82.36 153.88,82.36 153.68,82.28 153.56,82.1 153.55,82.09 153.22,81.75 153.11,81.75 153.1,81.77 152.85,81.93 152.6,81.77 152.58,81.75 152.36,81.75 152.19,81.91 152.19,82.03 152.25,82.09 152.26,82.09 152.43,82.36 152.23,82.62 152.19,82.63 152.19,83.45 152.34,83.6 158.12,83.6
VDD_1P2V on TOP (solid shape): 299.73,87 299.78,86.99 299.83,86.99 300.4,86.99 300.49,86.9 300.49,86.09 300.23,85.83 298.71,85.83 298.71,86.32 299.7,86.32 299.83,86.44 299.83,86.54 299.7,86.67 299.22,86.67 299.19,86.7 299.19,86.98 299.22,87
VDD_1P2V on IN4 (solid shape): outline of 902 points within 293.99,78.81 300.34,87.74
VIN on TOP (solid shape): 55.75,190.01 55.75,189.89 55.75,189.68 55.86,189.51 55.86,189.41 55.96,189.31 55.96,187.46 55.71,187.21 54.82,187.21 54.74,187.28 54.74,187.71 55.23,188.2 55.23,190.05 55.25,190.08 55.68,190.08
+1P2V on TOP (solid shape): outline of 1580 points within 41.64,80.37 119.75,114.28
+1P2V on IN1 (solid shape): 137.35,34.19 137.35,33.17 137.05,32.87 135.87,32.87 135.62,33.13 135.62,34.01 135.74,34.26 135.67,34.53 137.01,34.53
+1P2V on IN1 (solid shape): outline of 1122 points within 218.8,46.08 244.95,72.85
+1P2V on IN2 (solid shape): 138.79,34.78 138.79,34.27 138.54,34.02 135.87,34.02 135.74,34.14 135.74,35.54 136.12,35.92 137.65,35.92
+1P2V on IN2 (solid shape): 120.76,82.53 120.76,80.5 120.69,80.44 119.96,80.44 119.88,80.49 119.87,80.59 119.78,81.07 119.29,81.06 119.22,81.03 119.15,81.06 118.66,81.07 118.57,80.59 118.57,80.49 118.48,80.44 116.12,80.44 116.06,80.5 116.06,82.53 116.19,82.66 120.63,82.66
+1P2V on IN3 (solid shape): outline of 940 points within 62.59,99.17 78.34,108.57
+1P2V_CPU on TOP (solid shape): outline of 5629 points within 73.64,86.19 112.3,111.78
