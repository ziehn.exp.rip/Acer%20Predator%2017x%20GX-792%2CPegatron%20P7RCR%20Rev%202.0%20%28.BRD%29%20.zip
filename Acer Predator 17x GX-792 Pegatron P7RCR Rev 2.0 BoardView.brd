# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMID_IFPE_DATA3_P: length 244.2
  TOP w0.108: v2(286,80.93) 285.89,80.81 285.89,80.65 286.06,80.48 287.55,80.48 287.84,80.19 289.41,80.19 290.05,80.83 290.38,80.83 ; 290.38,80.83 290.96,80.83 C1308.1 ; 290.38,80.83 v1(290.38,81.06)
  IN2 w0.089: v2(286,80.93) 285.6,81.34 285.17,81.34 284.45,80.61 284.45,79.85 280.13,75.53 280.13,70.56 277.72,68.16 277.17,68.16 274.5,65.49 271.81,65.49 270.6,64.28 270.6,63.3 271.54,62.36 271.54,62.24 271.31,62.01 271.19,62.01 270.25,62.95 269.58,62.95 268.88,62.25 268.88,60.34 268.51,59.98 267.98,59.98 267.63,59.63 267.63,57.11 265.05,54.53 264.21,54.53 262.05,52.37 262.05,49.31 256.86,44.13 256.39,44.13 254.12,41.86 251.85,41.86 247.17,37.18 243.65,37.18 243.29,36.82 207.11,36.82 206.75,37.18 196.26,37.18 195.82,36.74 193.34,36.74 192.62,37.46 188,37.46 187.15,36.61 153.48,36.61 152.48,37.61 152.48,37.9 151.09,39.29 151.09,39.73 149.36,41.47 149.01,41.47 148.83,41.29 148.71,41.29 148.48,41.52 148.48,41.64 148.66,41.82 148.66,42.17 148.28,42.55 147.93,42.55 147.69,42.3 147.56,42.3 147.34,42.53 147.34,42.66 147.58,42.9 147.58,43.24 147.2,43.63 146.85,43.63 146.61,43.38 146.48,43.38 146.26,43.61 146.26,43.73 146.5,43.98 146.5,44.32 146.12,44.7 145.77,44.7 145.53,44.46 145.41,44.46 145.18,44.69 145.18,44.81 145.42,45.05 145.42,45.4 141.93,48.89 140.98,48.89 139.93,49.94 139.93,50.48 138.27,52.14 137.8,52.14 136.76,53.18 136.76,53.65 136.1,54.31 135.64,54.31 134.35,55.61 134.35,61.61 133.88,62.08 133.88,81.28 138.9,86.3 142.49,86.3 144.06,84.73 145.76,84.73 145.85,84.64 145.85,84.34 146.01,84.18 146.39,84.18 146.51,84.31 146.51,84.59 146.34,84.77 v3(146.23,84.77)
  BOTTOM w0.108: U7000.BH14 146.55,85.08 v3(146.23,84.77)
HG_C: length 7.1
  IN4 w0.635: v4(99.93,155.94) 99.93,156.88 98.53,158.27 98.53,160.05 99.52,161.04 v4(99.78,161.04)
  BOTTOM w0.508: v1(99.17,155.86) 99.85,155.86 v4(99.93,155.94)
HOOK3_SPI_MOSI_VRM_PWRGD: length 16.5
  BOTTOM w0.102: R4414.1 R4411.2 R4417.1 61.85,125.82 61.67,126 C4403.1 62.11,126.32 62.13,126.34 62.89,126.34 v1(63,126.45) 63,127.79 61.06,129.72 59.34,129.72 59.07,130 59.07,134.05 59.97,134.95 XDP4400.47
HOOK6_ITP_PMODE_PLTRST_CPU#: length 15.5
  BOTTOM w0.102: v1(54.88,124.87) 55.53,125.52 SR4406.1 R4410.2 R4423.1 57.1,126.29 57.2,126.4 57.2,126.75 R4418.1 57.16,127.61 57.16,128.81 58.26,129.91 58.26,134.24 57.04,135.45 XDP4400.46
HPD_DDPD_DP_R: length 35.9
  TOP w0.102: v2(267.32,41.13) 267.32,41.71 266.52,42.51 U1401.11 ; U1101.AA2 290.09,45.57 290.09,46 289.69,46.39 v2(288.91,46.39)
  IN2 w0.102: v2(275.93,50.38) 275.37,49.82 275.37,48.7 274.67,48 272.59,48 267.32,42.73 v2(267.32,41.13)
  IN4 w0.102: v2(275.93,50.38) 279,50.38 279.14,50.51 279.47,50.51 280.12,49.87 282.74,49.87 283.3,50.43 283.64,50.43 283.77,50.3 283.81,50.3 283.94,50.43 284.27,50.43 284.4,50.3 284.44,50.3 288.35,46.39 v2(288.91,46.39)
  BOTTOM w0.102: v1(290.53,46.67) 290.38,46.51 R1142.1 289.03,46.51 v2(288.91,46.39)
HPD_IFPC_DP2: length 230.1
  TOP w0.102: R4605.2 292.16,106.59 v2(292.06,106.69)
  IN2 w0.102: v2(153.02,55.84) 151.28,55.84 151.24,55.88 149.71,55.88 149.14,55.31 149.14,54.6 153.37,50.37 153.37,47.26 155.87,44.76 185.55,44.76 186.5,43.81 190.54,43.81 192.58,45.85 193.04,45.85 195.87,48.68 195.87,56.5 204.46,65.1 204.46,68.98 207.02,71.54 208.77,71.54 215.2,77.96 231.53,77.96 232.19,77.3 235.72,77.3 236.62,78.2 238.72,78.2 240.32,79.8 243.11,79.8 243.66,80.35 243.66,82.44 243.54,82.56 243.54,83.38 246.63,86.47 252.12,86.47 252.89,87.24 252.89,87.9 254.2,89.21 257.89,89.21 259.19,90.51 259.19,92.98 259.93,93.73 260.56,93.73 261.43,94.59 263.88,94.59 265.68,96.39 268.34,96.39 278.33,106.37 279.34,106.37 280.52,107.55 283.62,107.55 284.49,106.69 v2(292.06,106.69) 292.41,106.33 297.75,106.33 299.57,108.16 299.57,108.8 307.23,116.45 307.23,117.18 309.92,119.87 311.96,119.87 CON4601.18
  BOTTOM w0.102: L7404.2 152.27,63.35 151.97,63.05 C7401.1 152.43,62.11 152.84,62.11 153.04,61.91 v1(153.04,60.1) 153.04,59.37 152.73,59.05 152.73,56.12 v2(153.02,55.84)
HPD_IFPD_DP: length 216.6
  TOP w0.102: U1401.9 265.52,42.67 266.02,42.17 266.02,39.87 264.64,38.49 262.06,38.49 261.52,37.95 260.39,37.95 259.94,38.41 258.61,38.41 v1(257.99,37.79) 256.77,36.57 256.77,34.5 v2(257.31,33.97)
  IN4 w0.102: v2(257.31,33.97) 256.92,33.97 254.05,31.1 248.83,31.1 241.12,23.39 230.25,23.39 229.34,22.48 214.82,22.48 214.26,21.93 211.03,21.93 210.9,21.8 210.9,20.41 206.45,15.96 192.89,15.96 190.71,13.77 179.22,13.77 178.71,13.27 158.05,13.27 155.78,15.54 146.27,15.54 145.24,14.5 131.54,14.5 129.77,16.26 124.06,16.26 120.77,19.55 119.04,19.55 v2(117.79,20.81)
  BOTTOM w0.102: C7407.1 135.76,54.52 L7401.2 135.15,54.12 134.77,53.74 134.77,52.2 135.74,51.23 135.74,46 132.85,43.1 132.85,41.45 126.12,34.72 126.12,31.93 127.54,30.51 127.54,30.06 127.33,29.86 127.33,26.94 124.01,23.61 122.04,23.61 119.74,21.32 119.64,21.32 119.13,20.81 v2(117.79,20.81)
HPD_IFPE_HDMI: length 248
  TOP w0.102: R1303.1 290.91,85.86 v2(288.93,85.86)
  IN1 w0.102: v2(281.29,87.74) 281.29,88.79 281.76,89.26 286.55,89.26 288.32,87.49 288.32,86.19 288.65,85.86 v2(288.93,85.86)
  IN3 w0.102: v2(281.29,87.74) 281.29,81.8 282.33,80.75 282.33,76.76 280.08,74.51 280.08,70.95 278.93,69.8 278.93,68.3 277.64,67.01 275.84,67.01 274.07,65.24 274.07,63.68 270.55,60.16 270.55,59.41 266.02,54.88 262.29,54.88 261.84,55.33 255.64,55.33 254.06,53.75 254.06,46.67 254.74,45.98 254.74,44.59 254.35,44.19 252.99,44.19 249.77,40.98 241.35,40.98 240.65,40.28 232.61,40.28 229.84,37.52 225.79,37.52 225.12,38.18 216.97,38.18 212.79,34 205.86,34 203.79,31.94 199.33,31.94 195.98,28.59 187.32,28.59 186.78,29.14 185.71,29.14 185.45,29.41 171.74,29.41 171.6,29.27 168.33,29.27 167.51,28.44 159.06,28.44 158.52,28.99 146.75,28.99 142.67,33.07 134.52,33.07 132.29,30.84 126.02,30.84 v2(125.71,31.16)
  BOTTOM w0.102: L7402.2 135.36,57.05 135.41,57 C7405.1 135.21,56.29 135.21,55.56 134.56,54.91 134.56,52.01 135.54,51.04 135.54,46.08 131.86,42.4 v1(131.86,41.89) 131.86,40.75 125.91,34.8 125.91,31.37 v2(125.71,31.16)
HPD_IFPE_HDMI_R: length 3.2
  TOP w0.102: R1303.2 292.36,86.21 v1(293.15,85.43) 293.88,84.7 U1301.3
HPD_IFPF_EDP: length 192.1
  TOP w0.102: CON4500.20 112.75,189.22 111.59,190.38 v2(111.59,191.93)
  IN1 w0.102: v2(118.12,191.24) 117.43,191.93 v2(111.59,191.93)
  IN3 w0.102: v2(129.42,168.66) 129.42,168.06 128.73,167.37 121.37,167.37 120,166 120,164.15 118.08,162.24 118.08,154.96 120.02,153.02 122.38,153.02 123.93,151.46 123.93,148.74 123.27,148.08 123.27,147.53 123,147.27 123.01,147.27 122.22,146.48 117.44,146.48 115.83,144.87 115.83,136.79 116.79,135.82 117.4,135.82 118.1,135.12 118.94,135.12 120.82,133.25 120.82,130.34 121.29,129.86 121.29,128.31 124.91,124.69 124.91,112.21 125.58,111.54 125.58,90.14 128.33,87.39 128.33,84.89 127.89,84.45 127.89,79.95 133.34,74.51 137.76,74.51 138.82,73.45 138.82,68.04 140.99,65.87 146.31,65.87 147.2,64.98 v2(147.3,64.98)
  IN4 w0.102: v2(129.42,168.66) 129.42,184.09 126.21,187.3 126.21,188.84 123.35,191.7 118.57,191.7 v2(118.12,191.24)
  BOTTOM w0.102: R4501.2 C4526.2 R4505.2 119.87,191.8 118.88,191.8 T4505.1 118.32,191.24 v2(118.12,191.24) ; v2(147.3,64.98) 147.5,65.18 C7403.1 148.45,65.18 148.47,65.17 L7403.2
HPOUT1_JD#: length 26.4
  TOP w0.254: v2(11.28,38.34) 11.54,38.08 12,38.08 C6717.1 12.25,38.93 D6703.1 11,38.97 10.39,39.58 10.39,40.06 v1(9.3,41.16) 10.04,41.16 10.29,41.41 v2(10.29,41.51) 10.99,42.21 Q6701.1 ; R3623.2 v2(14.46,27.54)
  IN4 w0.254: v2(11.28,38.34) 11.28,35.29 14.94,31.63 14.94,28.4 14.46,27.92 v2(14.46,27.54)
  BOTTOM w0.254: v2(10.29,41.51) 11.48,42.7 CON6700.17
HPOUT1_JD_EC: length 195.7
  TOP w0.102: Q6701.3 18.52,41.26 v1(18.9,40.88) 20.2,39.58 23.32,39.58 24.51,40.77 30.65,40.77 32.12,42.24 v2(32.24,42.36) ; U3002.126 161.56,32.71 161.4,32.87 161.4,33.76 161.65,34.02 163.94,34.02 R3005.2 165.77,35.84 167.85,35.84 170.48,33.21 170.48,32.03 171.53,30.98 v2(171.53,27.58)
  IN1 w0.102: v2(32.24,42.36) 32.24,39.58 32.59,39.23 32.59,38.06 33.97,36.68 34.15,36.68 34.69,36.15 34.69,35.11 38.9,30.89 42.98,30.89 46.37,27.5 98.62,27.5 99.45,28.33 108.62,28.33 114.33,34.04 128.22,34.04 v2(128.9,34.73)
  IN2 w0.102: v2(171.53,27.58) 171.13,27.99 170.52,27.99 169.86,27.33 168.51,27.33 167.6,28.23 165.97,28.23 165.8,28.06 163.48,28.06 162.8,27.38 162.12,27.38 161.62,26.88 151.95,26.88 150.86,27.97 135.08,27.97 130.26,32.79 130.26,33.37 v2(128.9,34.73)
HPOUT1_L: length 18.5
  TOP w0.203: U3600.32 8.14,33.6 v1(8.24,33.69) 8.5,33.95 8.55,33.95 v2(8.74,34.14)
  TOP w0.254: C6704.1 14.65,43.29 v2(14.77,43.16)
  IN1 w0.254: v2(8.74,34.14) 10.01,35.41 10.01,37.32 9.18,38.16 9.18,41.82 10.06,42.7 12.86,42.7 13.32,43.16 v2(14.77,43.16)
  BOTTOM w0.254: v2(14.77,43.16) 14.73,43.2 CON6700.18
HPOUT1_R: length 20.3
  TOP w0.203: U3600.33 7.74,33.91 v2(8.74,34.91)
  TOP w0.254: v2(14.77,43.8) 14.51,43.8 C6705.1 ; v1(9.35,35.16) 9,35.16 v2(8.74,34.91)
  IN1 w0.254: v2(14.77,43.8) 13.21,43.8 12.63,43.21 9.84,43.21 8.52,41.89 8.52,38.08 9.51,37.09 9.51,35.67 v2(8.74,34.91)
  BOTTOM w0.254: CON6700.19 14.68,43.7 v2(14.77,43.8)
I2C_EN_PIN: length 6.6
  TOP w0.102: U1301.8 v2(293.78,82.7)
  BOTTOM w0.102: R1320.1 293.32,83.17 v2(293.78,82.7) ; R1320.1 R1319.2 ; R1320.1 292.13,83.27 291.67,83.73 291.04,83.73 290.56,84.21 v1(289.72,84.21)
I2C_IRQ2Z: length 16
  TOP w0.076: 290.89,58.37 291.31,57.94 291.74,57.94 U1201.B6
  TOP w0.102: 290.89,58.37 290.78,58.48 290.05,58.48 289.73,58.79 286.58,58.79 285.84,58.05 285.8,58.05 v2(285.78,58.06) R1230.1 ; R3077.2 281.95,56.52 281.87,56.6 v2(281.87,56.83)
  IN2 w0.102: v2(281.87,56.83) 281.08,57.61 281.08,58.81 281.34,59.06 284.72,59.06 285.73,58.05 285.77,58.05 v2(285.78,58.06)
I2C_IRQ2Z_EC: length 150.5
  TOP w0.102: v2(155.61,20.9) 155.61,20.66 155.66,20.6 U3002.83 155.66,18.65 155.78,18.54 156.97,18.54 157.11,18.4 157.11,17.7 R3079.1 ; R3077.1 280.52,55.46 v2(280.19,55.46)
  IN1 w0.102: v2(155.61,20.9) 156.03,21.32 162.57,21.32 162.85,21.04 165.34,21.04 167.19,19.2 189.28,19.2 189.9,19.81 189.9,20.71 190.33,21.14 192.97,21.14 193.22,21.39 202.81,21.39 206.89,25.48 206.89,26.37 208.26,27.74 229.23,27.74 229.73,28.24 243.73,28.24 247.78,32.29 252.82,32.29 258.68,38.16 260.08,38.16 260.31,37.93 v2(260.31,37.45)
  IN2 w0.102: v2(260.31,37.45) 260.71,37.04 261.08,37.04 261.32,37.28 261.32,37.71 265.52,41.91 266.01,41.91 273.28,49.18 273.71,49.18 274.61,50.08 274.61,51 276.47,52.86 277.03,52.86 279.63,55.46 v2(280.19,55.46)
  BOTTOM w0.102: v2(155.61,20.9) 155.61,20.73 v1(155.15,20.28)
I2C_SCL2: length 192.5
  TOP w0.076: U1201.B5 291.73,57.44 291.21,57.44 291.14,57.51 290.91,57.51
  TOP w0.121: v2(289.41,66) 289.69,66.28 Q1202.3 291.42,66.28 292.21,67.06 v1(292.77,67.06) ; 290.91,57.51 290.53,57.89 289.77,57.89 289.36,57.49 287.89,57.49 287.79,57.39 R1231.1 287.47,58.05 v2(287.52,58.1)
  IN2 w0.083: v2(289.41,66) 289.41,64.02 287.92,62.52 287.92,61.42 288.33,61.01 288.33,58.91 v2(287.52,58.1) 287.52,57.71 286.62,56.81 283.8,56.81 282.57,55.58 281.92,55.58 280.47,54.14 279.74,54.14 277.55,51.95 277.55,46.94 275.06,44.46 275.06,43.85 270.64,39.43 270.64,38.39 264.45,32.19 255.19,32.19 253.57,30.56 248.08,30.56 241.08,23.56 239.56,23.56 238.86,22.86 235.55,22.86 235.48,22.92 227.04,22.92 226.07,21.95 v2(220.83,21.95)
  BOTTOM w0.121: v2(220.83,21.95) 219.82,20.94 214.1,20.94 212.96,19.79 211.05,19.79 207.88,16.62 198.1,16.62 194.01,12.53 190.19,12.53 188.12,14.6 166.99,14.6 165.39,16.2 156.57,16.2 155.12,17.65 155.12,18.9 159.49,23.27 159.49,24.47 160.07,25.05 160.67,25.05 161.27,25.64 162.98,25.64 164.34,27.01 SR3004.1
I2C_SDA2: length 188.8
  TOP w0.121: U1201.A5 291.24,57.7 290.76,58.17 289.34,58.17 289.19,58.02 v1(289.13,58.02) 288.32,58.02 287.79,58.55 287.21,58.55 v2(286.75,58.1) 286.64,57.98 R1232.1 ; Q1201.3 288.52,66.25 v2(288.78,66)
  IN2 w0.083: v2(220.07,21.95) 220.78,22.66 226.11,22.66 226.93,23.48 235.69,23.48 235.85,23.32 238.67,23.32 239.36,24.02 240.89,24.02 247.89,31.03 253.38,31.03 255,32.65 260.06,32.65 261.69,34.28 265.73,34.28 270.18,38.73 270.18,39.62 274.58,44.02 274.58,44.63 277.09,47.13 277.09,52.14 279.56,54.62 280.3,54.62 281.74,56.06 282.35,56.06 283.57,57.28 285.94,57.28 v2(286.75,58.1) 287.86,59.21 287.86,60.74 287.45,61.15 287.45,62.76 288.78,64.09 v2(288.78,66)
  BOTTOM w0.121: v2(220.07,21.95) 219.56,21.44 213.89,21.44 212.75,20.3 210.85,20.3 207.67,17.12 197.82,17.12 193.76,13.03 190.52,13.03 188.45,15.1 167.19,15.1 165.59,16.7 156.78,16.7 155.62,17.86 155.62,18.7 159.99,23.07 159.99,24.26 160.28,24.54 160.88,24.54 161.47,25.14 163.19,25.14 165.26,27.21 SR3003.1
ID_DET: length 44.4
  TOP w0.102: v2(259.82,33.95) 259.82,34.78 259.64,34.97 259.64,35.86 259.95,36.18 261.91,36.18 R8805.1 262.13,37.19 262.57,37.62 264.3,37.62 264.72,37.2 R8807.2 D8805.1
  IN4 w0.102: v2(259.82,33.95) 258.01,32.14 255.38,32.14 254.13,30.89 248.91,30.89 243.44,25.42 243.44,19.46 v2(245.01,17.89)
  BOTTOM w0.102: v1(241.79,20.53) 242.08,20.24 SR8812.2 242.63,18.87 242.63,18.07 243.19,17.51 244.63,17.51 v2(245.01,17.89)
IFP_IOVDD: length 7.1
  BOTTOM w0.25: v3(151.15,91.15) 150.86,91.45 U7000.BB23 ; U7000.BB21 150.62,89.92 150.18,89.92 U7000.BC21 ; v3(151.15,86.99) 150.89,87.25 U7000.BB17
  BOTTOM w0.254: v3(150.39,91.11) U7000.BC23 ; U7000.BC15 150.05,85.8 150.17,85.68 150.63,85.68 150.75,85.8 U7000.BB15 150.88,85.85 v3(151.15,86.12) ; U7000.BB21 v3(151.11,89.69) ; v3(151.19,88.15) 150.95,88.15 U7000.BB18 150.61,87.81 150.18,87.81 U7000.BC18 ; v3(150.4,89.01) 150.39,89.01 U7000.BC20 ; v3(150.38,86.9) 150.38,86.92 U7000.BC17 ; U7000.BB20 151.03,89.07 v3(151.18,89.07)
  vias: v1(150.17,92.01)
IFP_PLLVDD:
  vias: v1(141.34,85.58)
IFPAB_PLLVDD_R: length 0.5
  BOTTOM w0.254: U7000.BD21 149.68,90.38 149.69,90.38 v3(149.7,90.39)
  vias: v1(148.6,89.9)
IFPAB_RSET: length 4.8
  TOP w0.102: v3(149.7,91.1) 149.3,91.5 146.89,91.5 v1(146.67,91.27) 146.59,91.35 R7204.2
  BOTTOM w0.102: U7000.BD23 v3(149.7,91.1)
IFPCD_PLLVDD_R: length 1.3
  TOP w0.432: v3(149.71,88.3) 149.51,88.09 C7222.1
  BOTTOM w0.254: U7000.BD18 149.37,87.95 v3(149.71,88.3)
  vias: v1(145.85,87.81)
IFPCD_RSET: length 4.8
  TOP w0.102: v3(149.7,89.01) 149.53,89.01 149.13,89.42 145.94,89.42 R7212.2
  BOTTOM w0.102: v3(149.7,89.01) 149.69,89.01 U7000.BD20
IFPCDEF_PLLVDD_R: length 0.5
  BOTTOM w0.254: U7000.BD15 149.66,86.16 v3(149.66,86.24)
  vias: v1(148.47,85.48)
IFPEF_RSET: length 6.1
  TOP w0.102: v3(149.7,86.91) 149.55,86.91 149.13,87.33 146.08,87.33 145.83,87.08 145.83,86.65 146.31,86.16 R7221.2
  BOTTOM w0.102: U7000.BD17 149.69,86.91 v3(149.7,86.91)
ILIM_SEL: length 7.6
  TOP w0.102: R5206.1 300.21,65.18 300.26,65.13 U5200.4 ; R5206.1 299.32,65.62 297.8,65.62 297.6,65.42 R5207.2 ; R5206.1 300.26,65.69 300.87,65.69 v1(301.48,66.3)
ILIM_SEL_TBT: length 4.1
  TOP w0.102: v1(291.73,78.04) 292.39,77.38 292.59,77.38 R1205.2 R1206.1 293.49,75.56 U1202.4
IMON_A: length 4.8
  BOTTOM w0.102: U8000.14 58.17,179.92 58.6,179.48 v1(59.98,179.48) 60.61,179.48 60.79,179.3 C8035.2 R8092.2
IMON_B: length 7.2
  BOTTOM w0.102: U8000.2 59.87,185.34 60.41,185.88 v1(60.41,189.82) 60.41,190.33 60.43,190.35 R8029.2 C8014.2
IMON_C: length 3.4
  BOTTOM w0.203: C8004.1 R8038.1 51.49,181.92 v1(52.31,182.75) 52.77,182.75 52.97,182.54 U8000.28
IN+1: length 7.7
  TOP w0.387: U9702.12 91,179.25 90.79,179.03 90.79,178.29 90.66,178.16 89.73,178.16 C9708.2 89.36,178.53 v2(89.36,178.9)
  BOTTOM w0.387: v1(90.48,175.78) 90.48,176.03 91.27,176.82 R9731.2 91.04,177.1 89.36,178.77 v2(89.36,178.9)
IN+1_R: length 11.9
  TOP w0.387: R9702.2 96.67,169.03 95.38,170.31 95.38,171.81 91.85,175.34 v2(91.85,175.85)
  BOTTOM w0.387: R9731.1 92.13,176.66 91.85,176.38 v2(91.85,175.85) 92.28,175.42 v1(92.28,175.11)
IN+2: length 7.2
  TOP w0.387: v2(95.69,176.49) 95.79,176.59 R9709.2 ; v2(94.21,176.03) 94.21,176.46 93.74,176.93 C9707.1 93.74,177.42 93.4,177.76 U9702.15
  BOTTOM w0.387: v2(94.21,176.03) 94.21,177.2 94.43,177.41 v1(95.19,177.41) 95.63,177.41 95.84,177.2 95.84,176.64 v2(95.69,176.49)
IN+2_R: length 38.7
  TOP w0.387: v1(96.02,178.09) 95.51,178.09 94.93,177.5 R9709.1 94.93,176.46 95.54,175.85 99.75,175.85 100.49,176.59 v2(101.15,176.59)
  IN3 w0.254: v2(101.15,176.59) 105.67,176.59 110.93,171.33 116.01,171.33 119.13,168.21 v2(121.57,168.21)
  BOTTOM w0.387: R9715.2 118.62,170.45 118.62,169.76 120.17,168.21 v2(121.57,168.21)
IN+3: length 9
  TOP w0.387: v2(98.76,178.67) 98.15,179.28 97.68,179.28 C9726.1 95.81,179.72 95.63,179.89 U9702.2
  BOTTOM w0.387: v2(98.76,178.67) 98.28,178.67 97.97,178.37 97.97,177.81 98.18,177.6 99.02,177.6 99.17,177.45 v1(99.17,176.66) R9734.2
IN+3_R: length 25.6
  TOP w0.387: v2(117.96,177.91) 117.96,174.04 R9732.2
  BOTTOM w0.387: R9734.1 99.17,174.63 99.66,174.14 102.75,174.14 103.42,174.81 v1(108.13,174.81) 108.13,175.19 110.87,177.93 117.94,177.93 v2(117.96,177.91)
IN-1: length 5
  TOP w0.387: v2(90.2,178.92) 89.64,179.48 C9708.1 90.47,179.59 90.77,179.89 U9702.11
  BOTTOM w0.387: R9704.2 91.19,177.93 v2(90.2,178.92) 90.53,179.25 v1(90.94,179.25)
IN-1_R: length 13.5
  TOP w0.387: R9702.3 99.23,169.69 98.91,170.01 96.73,170.01 96.12,170.62 96.12,172.12 92.64,175.6 v2(92.64,175.85)
  BOTTOM w0.387: v2(92.64,175.85) 92.64,176.16 93.02,176.54 v1(93.02,176.89) 93.02,177.22 92.31,177.93 R9704.1
IN-2: length 8.3
  TOP w0.387: v2(93.5,176.05) 93.43,176.05 92.4,177.08 C9707.2 92.4,177.59 92.75,177.94 U9702.14 ; R9703.2 v2(96.58,176.46)
  BOTTOM w0.387: v2(96.58,176.46) 96.58,175.75 96.01,175.18 v1(94.83,175.18) 94.02,175.18 93.5,175.7 v2(93.5,176.05)
IN-2_R: length 35.2
  TOP w0.387: v2(101.15,177.35) 101.15,177.71 101.05,177.81 100.62,177.81 99.42,176.61 97.59,176.61 97.44,176.77 R9703.1
  IN3 w0.254: v2(101.15,177.35) 105.59,177.35 111.03,171.91 116.29,171.91 119.51,168.69 121.88,168.69 122.21,168.36 v2(122.21,168.21)
  BOTTOM w0.387: v2(122.21,168.21) 122.21,168.56 121.85,168.92 v1(121.01,168.92) 120.45,168.92 119.37,170 R9715.3
IN-3: length 8.9
  TOP w0.387: U9702.1 95.22,179.25 95.66,178.8 96.82,178.8 C9726.2 97.44,178.59 97.87,178.59 98.37,178.09 99.16,178.09 99.57,178.5 v2(99.57,178.7)
  BOTTOM w0.387: v2(99.57,178.7) v1(100.06,178.21) R9733.2
IN-3_R: length 25.4
  TOP w0.387: R9732.3 118.73,173.99 v2(118.73,177.91)
  BOTTOM w0.387: R9733.1 102.47,174.84 103.13,175.5 v1(105.5,175.5) 107.45,175.5 110.6,178.65 118.37,178.65 118.73,178.29 v2(118.73,177.91)
INT_SERIRQ: length 222.5
  TOP w0.121: SR2207.1 249.21,64.57 249.66,64.12 249.66,63.43 v2(250.2,62.9) ; U3002.5 159.26,35.9 159.49,36.13 159.99,36.13 160.65,36.78 160.65,37.54 R3013.2 161.47,38.03 161.95,38.5 161.95,39.63 162.11,39.79 162.11,41.02 162.01,41.12 v2(162.01,42.17) ; v2(238.31,30.4) 238.31,30.33 238.99,29.66 U6200.27
  IN1 w0.083: v2(238.31,30.4) 238.31,34.4 240.67,36.76 242.58,36.76 243.61,37.8 246.5,37.8 247.38,38.67 247.38,39.22 247.2,39.4 247.2,42.46 249.35,44.61 249.35,48.45 248.95,48.85 248.95,58 249.54,58.59 249.54,59.87 250.37,60.7 250.37,62.73 v2(250.2,62.9)
  IN4 w0.083: v2(238.31,30.4) 236.98,31.73 231.64,31.73 230.17,30.25 230.17,29.38 229.09,28.3 228.13,28.3 226.79,26.96 212.33,26.96 210.42,25.05 209.79,25.05 206.51,21.77 205.49,21.77 204.83,21.11 204.11,21.11 201.63,18.63 185.74,18.63 185.51,18.4 176.09,18.4 175.82,18.14 166.23,18.14 165.79,18.57 146.89,18.57 146.65,18.33 138.54,18.33 136.19,20.68 133.63,20.68 133.56,20.61 v2(127.92,20.61)
  BOTTOM w0.121: v2(127.92,20.61) 127.92,23.73 130.02,25.82 130.02,27 130.26,27.24 130.86,27.24 132.29,28.67 132.29,31.1 134.65,33.46 134.65,34.23 141.22,40.8 161.3,40.8 v1(161.83,41.33) 162.01,41.51 v2(162.01,42.17)
ISEN1_A: length 7.5
  BOTTOM w0.102: U8000.21 55.37,179.78 v1(55,179.41) 54.84,179.25 C8017.2 54.39,178.39 54.21,178.21 54.21,176.74 R8006.2 55.18,176.23 55.23,176.18 55.23,175.26 R80125.1
ISEN1_B: length 11.3
  BOTTOM w0.152: C8029.1 R80103.2 66.46,179.35 v1(66.17,179.64) 66.07,179.73 64.8,179.73 R80140.1 64.75,180.55 64.75,181.29 64.28,181.77 60.64,181.77 59.86,182.54 U8000.9
ISEN2_A: length 7.3
  BOTTOM w0.102: U8000.22 54.97,180.24 54.16,179.43 v1(53.14,179.43) 53.32,179.25 C8019.2 53.74,178.39 53.83,178.3 R8007.2 53.19,176.23 R80130.1
ISEN2_B: length 21.9
  IN4 w0.152: v2(63.48,181) 65.77,183.29 v2(65.77,184.46)
  BOTTOM w0.152: U8000.10 59.74,182.14 60.37,181.51 63.81,181.51 C8030.1 v2(63.48,181) ; R8091.2 70.52,182.38 69.85,182.38 69.75,182.48 69.75,183.27 R80145.1 69.35,184.89 69.93,185.48 69.93,186.43 69.66,186.7 68.38,186.7 v1(66.53,184.84) 66.15,184.84 v2(65.77,184.46)
ISEN3_A: length 11.2
  BOTTOM w0.102: v1(52.61,173.64) 52.53,173.72 52.53,175.19 R80135.1 R8034.2 52.56,175.98 52.56,176.81 52.37,177 52.12,177 51.92,177.19 51.92,177.88 C8011.2 52.13,178.69 52.13,179.74 52.31,179.93 54.27,179.93 54.57,180.22 U8000.23
ISH_I2C0_SCL: length 12.6
  TOP w0.121: v2(237.83,51.19) 238.42,51.19 240.17,49.45 241.52,49.45 242.73,48.24 v1(243.21,48.24) 245.64,48.24 245.96,48.56 245.96,49.95 R2417.2
  BOTTOM w0.121: U2000.BC38 237.83,51.3 v2(237.83,51.19)
ISH_I2C0_SDA: length 13.5
  TOP w0.121: R2416.2 246.46,49.61 246.46,48.62 v1(246.69,48.39) 246.03,47.73 242.53,47.73 241.31,48.95 239.96,48.95 238.22,50.69 237.69,50.69 v2(237.22,51.16)
  BOTTOM w0.121: U2000.BB38 237.43,51.37 v2(237.22,51.16)
ISH_I2C1_SCL: length 8.7
  BOTTOM w0.121: U2000.BD38 238.72,51.61 239.23,51.61 239.51,51.33 240.3,51.33 240.79,50.85 241.06,50.85 241.47,50.44 243.77,50.44 244.37,49.83 244.99,49.83 245.17,50.02 v1(245.55,50.02) 245.98,50.02 246.08,49.92 R2415.2
ISH_I2C1_SDA: length 8.4
  BOTTOM w0.121: U2000.BE39 240.12,51.06 241.25,49.94 v1(242.29,49.94) 243.56,49.94 244.17,49.33 245.73,49.33 R2414.2
ISUMN_A: length 7.8
  BOTTOM w0.102: R8008.2 C8018.1 ; C8018.1 57.05,177.75 57.05,176.84 57.54,176.36 v1(58.68,176.36) ; C8018.1 R8098.1 55.73,178.67 55.95,178.89 55.95,179.2 55.77,179.39 U8000.20
ISUMN_A_R: length 63.6
  IN3 w0.102: v2(55.53,179.05) 52.58,179.05 v2(52.56,179.03) 52.56,179.25 51.87,179.94 50.48,179.94 47.94,177.4 v2(47.94,174.35) 48.14,174.15 48.14,171.96 48.29,171.8 48.29,171.71 49.89,170.11 51.47,170.11 51.75,170.39 58.75,170.39 62.08,167.06 67.93,167.06 71.92,163.07 73.59,163.07 74.78,161.88 74.78,158.91 v2(74.66,158.78)
  BOTTOM w0.102: C8019.1 C8011.1 52.89,177.98 52.89,178.7 v2(52.56,179.03) ; R8082.1 v2(74.66,158.78) 74.48,158.96 v1(74.48,159.49) ; v2(47.94,174.35) R8059.1 R8061.1 47.48,176.64 C8020.2 SR8018.2 C8026.1 R8083.1 ; v2(55.53,179.05) 55.3,178.82 55.3,177.98 C8017.1 55.53,177.52 R8098.2 55.73,176.94 55.68,176.89 R80102.2 R8057.1
ISUMN_B: length 19.3
  BOTTOM w0.102: SR8017.2 72.2,182.88 73.11,183.8 v1(73.11,184.11)
  BOTTOM w0.152: SR8017.2 71.49,182.51 71.49,182.21 C8034.1 ; U8000.8 59.97,182.94 60.88,182.03 64.69,182.03 65.21,181.51 68.22,181.51 68.42,181.31 68.42,180.48 68.58,180.32 69.16,180.32 69.32,180.48 69.32,181.95 69.49,182.13 70.95,182.13 C8034.1 ; C8034.1 71.18,181.45 71.1,181.37 R8045.2
ISUMN_B_R: length 47.3
  TOP w0.203: R8088.2 v2(47.73,159.57)
  IN4 w0.203: v2(47.73,159.57) 47.96,159.8 48.44,159.8 48.98,160.33 48.98,162.47 57.16,170.64 61.68,170.64 63.1,172.07 63.1,177.17 v2(66.2,180.27)
  BOTTOM w0.102: R8043.1 72.68,180.19 v1(73.08,179.79)
  BOTTOM w0.152: C8028.1 C8027.2 R8044.2 67.93,180.25 C8029.2 68.44,179.73 R8040.2 68.87,179.56 68.69,179.38 68.69,178.58 68.96,178.32 69.33,178.32 69.73,178.71 69.73,178.75 70.47,179.48 70.47,179.99 70.67,180.19 R8045.1 R8043.1 71.99,179.81 71.91,179.74 R8066.1 ; C8028.1 66.15,180.32 v2(66.2,180.27) 66.09,180.17 R8064.1 65.21,180.62 65.18,180.65 C8030.2 65.56,181 65.64,181.08 C8028.1
ISUMN_C: length 5.1
  BOTTOM w0.102: R8032.2 51.26,186.11 R8035.1 50.65,185.78 50.58,185.71 C80106.1 51.17,184.69 v1(52.03,184.69) 52.17,184.54 U8000.33
ISUMN_C_R: length 86.8
  TOP w0.102: v2(50.65,187.86) 50.73,187.94 SR8019.2 SR8016.1 ; R8026.1 v2(89.77,153.7)
  IN1 w0.102: v2(50.65,187.86) 51.14,188.35 63.73,188.35 64.98,187.1 64.98,187.01 65.27,186.72 79.69,186.72 80.78,185.63 86.33,185.63 88.26,183.7 90.28,183.7 90.96,183.01 v2(90.96,182.61)
  IN4 w0.102: v2(90.96,182.61) 91.4,182.18 91.4,180.31 92.11,179.6 92.11,177.88 91.12,176.89 91.12,175.28 91.96,174.44 91.96,167.69 94.9,164.75 94.9,157.89 90.4,153.4 90.07,153.4 v2(89.77,153.7)
  BOTTOM w0.102: v1(47.15,187.26) 47.33,187.26 48.11,188.04 R8025.1 48.49,188.42 48.55,188.47 C80104.2 48.92,188.83 48.95,188.8 C80105.1 49.71,188.8 v2(50.65,187.86) R8035.2 R8036.2
ISUMP_A: length 29.4
  IN1 w0.254: v2(60.33,177.17) 60.1,177.4 51.77,177.4 49.31,179.86 v2(49.13,179.86)
  BOTTOM w0.102: C8026.2 R8083.2 ; R8083.2 50.68,178.03 R80101.2 51.42,177.07 51.21,176.86 R8060.1 R8058.1 ; R8083.2 50.53,178.67 C80133.2 C80109.2 50.16,180.03 49.92,180.03 49.64,180.31 49.64,180.6 v1(49.48,180.76) 49.3,180.57 49.3,180.33 49.13,180.17 v2(49.13,179.86) ; U8000.19 56.17,180.15 56.09,180.07 56.09,179.39 56.81,178.67 57.92,178.67 R8056.1 58.42,178.19 58.78,178.54 59.29,178.54 59.54,178.29 60.05,178.29 60.33,178.01 v2(60.33,177.17)
ISUMP_B: length 24.5
  IN3 w0.152: v2(63.56,179.99) 64.12,180.55 64.12,181.34 62.34,183.12 61.93,183.12 v2(61.37,183.67)
  BOTTOM w0.102: v1(69.48,186.24) 69.48,185.43 68.98,184.93 68.98,183.2 R8063.1
  BOTTOM w0.152: C80110.1 C8036.1 68.87,182.35 R8063.1 68.97,182.84 68.94,182.86 R8094.1 68.14,182.44 68.14,182.16 R8044.1 C8027.1 66.58,182.4 62.45,182.4 62.24,182.62 62.24,182.81 v2(61.37,183.67) 61.04,183.34 U8000.7 ; v2(63.56,179.99) R8062.1
ISUMP_C: length 21.6
  TOP w0.102: R8067.1 C80111.2 C80103.2 48.75,190.61 48.49,190.35 48.49,188.04 48.68,187.86 v2(50.02,187.86) 50.45,187.43 51.57,187.43 R8024.2
  BOTTOM w0.102: v2(50.02,187.86) 49.94,187.94 C80105.2 49.26,187.94 R8025.2 48.72,186.95 v1(48.72,186.24) 48.27,185.78 46.97,185.78 46.72,185.53 46.72,184.77 46.97,184.51 50.58,184.51 50.87,184.23 52.92,184.23 53,184.14 U8000.32
ITP_PMODE: length 350.3
  TOP w0.102: v2(57.87,121.09) v1(57.13,121.09)
  IN3 w0.102: v2(235.29,71.51) 235.72,71.94 236.42,71.94 238.22,73.74 238.22,75.54 237.31,76.45 236.31,76.45 236.14,76.61 234.31,76.61 233,77.92 233,78.26 232.71,78.55 217.17,78.55 215.04,76.42 215.04,73.87 213.18,72.01 205.58,72.01 200.74,67.17 200.74,64.29 197.87,61.42 197.87,48.49 194.27,44.88 190.7,44.88 187.7,41.87 170.01,41.87 169.47,41.34 154.61,41.34 148.53,47.42 142.38,47.42 141.86,46.9 134.32,46.9 128.94,41.52 121.4,41.52 118.76,38.88 102.59,38.88 96.16,32.44 49.57,32.44 47.86,30.73 47.86,29.24 47.28,28.66 46.15,28.66 42.89,31.92 42.89,40.73 38.09,45.53 38.09,69.15 53.35,84.4 53.35,99.28 51.09,101.54 51.09,106.79 57.87,113.57 v2(57.87,121.09)
  BOTTOM w0.089: U2000.AT2 234.92,69.52 234.8,69.64 234.8,69.97 234.85,70.02 234.85,70.31
  BOTTOM w0.102: v2(235.29,71.51) 234.85,71.07 234.85,70.31 ; SR4406.2 55.83,122.77 57.5,121.09 v2(57.87,121.09)
JD_PCH: length 302.7
  TOP w0.102: SR2410.2 251.57,56.16 v2(251.87,56.47) ; v2(14.79,15.63) 18.38,15.63 18.44,15.69 26.99,15.69 27.69,16.39 v1(30.36,16.39) 30.36,16.75 30.85,17.24 33.16,17.24 33.6,17.68 37.5,17.68 38.66,18.84 41.45,18.84 v2(43.67,21.06) ; U3600.48 5.71,27.37 5.31,26.98 v2(5.31,26.91) ; v2(190.91,20.5) 190.91,21.47 190.25,22.14 190.25,29.7 188.3,31.65 188.3,39.71 190.72,42.13 192.7,42.13 192.89,42.32 194.12,42.32 195.64,43.84 v2(196.73,43.84)
  IN2 w0.102: v2(190.91,20.5) 190.91,19.74 190.7,19.53 175.44,19.53 174.75,20.23 173.25,20.23 172.56,19.53 163.88,19.53 162.97,18.63 154.45,18.63 154.29,18.47 154.29,17.96 153.94,17.62 146.65,17.62 145.19,16.16 137.6,16.16 137.32,16.44 111.89,16.44 110.77,17.56 96.83,17.56 90.76,23.63 63.13,23.63 61.12,21.62 44.23,21.62 v2(43.67,21.06) ; v2(196.73,43.84) 196.73,45.52 197.67,46.46 209.45,46.46 210.5,45.42 239.6,45.42 240.68,46.5 240.68,52.36 240.43,52.61 240.43,53.67 242.37,55.61 250.2,55.61 251.06,56.47 v2(251.87,56.47)
  IN3 w0.102: v2(5.31,26.91) 4.76,26.35 4.76,25.18 10.37,19.57 14.03,19.57 15.07,18.52 15.07,15.91 v2(14.79,15.63)
JTAG_TCLK: length 6.4
  BOTTOM w0.102: U7000.BK24 144.88,92.15 144.58,92.45 143.51,92.45 143.25,92.2 139.46,92.2 T7406.1
JTAG_TDI: length 4.7
  BOTTOM w0.102: U7000.BM23 142.76,91.45 141.9,90.58 140.01,90.58 T7408.1
JTAG_TDO: length 7.4
  BOTTOM w0.102: T7409.1 137.24,90.96 137.98,90.96 138.37,91.36 139.36,91.36 140,92 143.34,92 143.49,92.15 U7000.BM24
JTAG_TMS: length 3.7
  BOTTOM w0.102: T7407.1 142.86,90.08 144.23,91.45 U7000.BL23
JTAG_TRST#: length 10.7
  BOTTOM w0.102: U7000.BL24 144.09,91.79 140.09,91.79 139.45,91.16 138.46,91.16 138.04,90.74 137.73,90.74 137,90 136.2,90 R7470.2 135.46,89.77 T7410.1
KBL_A_0: length 6.3
  TOP w0.102: v1(182.89,21.7) 182.43,21.24 182.43,21.11 182.28,20.96 181.54,20.96 R3142.1 180.55,21.37 180.19,21.01 180.19,20.61 R3141.2 179.32,19.74 U3102.2
KBL_A_1: length 8.9
  TOP w0.102: R3143.2 178.67,18.51 U3102.3 178.67,17.66 178.95,17.38 180.02,17.38 180.32,17.69 180.32,18.96 180.88,19.51 R3144.1 181.41,19.74 181.62,19.95 v1(183.22,19.95)
KBL_A_2: length 7
  TOP w0.102: R3146.1 180.96,18.63 180.55,18.22 180.55,17.58 180.09,17.13 178.49,17.13 178.02,17.59 U3102.4 178.02,19.78 R3145.2
KBL_A_3: length 8.2
  TOP w0.102: v1(176.03,20.17) 176.8,20.17 R3147.2 177.37,19.6 U3102.5 177.37,17.66 178.11,16.92 180.22,16.92 181.03,17.74 R3148.1
KBL_B_1: length 24.4
  TOP w0.102: v1(174.3,20.5) 174.81,20.5 175.42,19.89 U3102.8 175.42,17.66 v2(177.54,15.54)
  IN2 w0.102: v2(177.54,15.54) 178.36,14.73 185.64,14.73 186.05,14.32 189.05,14.32 v2(190.28,15.55)
  BOTTOM w0.102: CON3110.5 191,17.77 190.28,17.05 v2(190.28,15.55)
KBL_B_2: length 26.8
  TOP w0.102: v1(169.96,18.51) 170.86,19.41 171.86,19.41 172.17,19.1 U3102.13 172.17,15.63 v2(172.26,15.54)
  IN2 w0.102: v2(172.26,15.54) 173.09,16.36 186.66,16.36 v2(187.48,15.54)
  BOTTOM w0.102: CON3110.8 189.5,17.93 187.48,15.91 v2(187.48,15.54)
KBL_B_3: length 28.6
  TOP w0.102: U3102.17 172.82,13.55 171.41,14.97 170.61,14.97 v2(170.03,15.54) 170.01,15.56 v1(170.01,16.21)
  BOTTOM w0.102: CON3110.11 188,19.61 186.62,20.99 184.81,20.99 184.25,20.43 182.69,20.43 182.18,20.94 181.11,20.94 178.73,18.56 170.34,18.56 170.03,18.25 v2(170.03,15.54)
KBL_B_4: length 18.5
  TOP w0.102: U3102.22 176.07,15.48 v2(176.13,15.54)
  BOTTOM w0.102: CON3110.14 186.5,19.58 186.29,19.79 185.76,19.79 182.84,16.87 v1(181.95,16.87) 181.95,17.84 181.08,18.7 180.07,18.7 178.77,17.41 176.78,17.41 176.13,16.76 v2(176.13,15.54)
KBL_G_1: length 22.6
  TOP w0.102: v2(178.19,15.54) 176.07,17.66 U3102.7 ; v1(190.51,14.84) 190.51,15.15 v2(190.91,15.55)
  IN2 w0.102: v2(178.19,15.54) 178.8,14.93 185.73,14.93 186.13,14.52 188.67,14.52 190.11,15.96 190.51,15.96 v2(190.91,15.55)
  BOTTOM w0.102: v2(190.91,15.55) 190.91,16.92 191.5,17.51 CON3110.4
KBL_G_2: length 25.5
  TOP w0.102: v1(172.24,20.1) 172.82,19.52 U3102.12 172.82,15.59 v2(172.87,15.54)
  IN2 w0.102: v2(172.87,15.54) 173.5,16.16 186.39,16.16 186.92,15.63 186.92,15.52 187.32,15.13 187.7,15.13 v2(188.12,15.55)
  BOTTOM w0.102: CON3110.7 190,17.79 188.12,15.91 v2(188.12,15.55)
KBL_G_3: length 30.2
  TOP w0.102: U3102.16 172.17,13.69 171.23,14.64 170.28,14.64 v2(169.37,15.54) 168.7,16.21 v1(168.23,16.21)
  BOTTOM w0.102: v2(169.37,15.54) 169.37,17.88 170.26,18.76 178.6,18.76 181.13,21.29 186.82,21.29 188.5,19.61 CON3110.10
KBL_G_4: length 18
  TOP w0.102: v2(175.52,15.54) 175.42,15.44 U3102.21
  BOTTOM w0.102: CON3110.13 187,19.62 186.57,20.05 185.58,20.05 184.44,18.9 182.2,18.9 v1(181.95,18.65) 181.69,18.9 179.89,18.9 178.77,17.79 176.55,17.79 175.52,16.76 v2(175.52,15.54)
KBL_R_1: length 22.4
  TOP w0.102: U3102.6 176.72,17.66 v2(178.84,15.54) ; v1(192.18,15.32) 191.78,15.32 v2(191.55,15.55)
  IN2 w0.102: v2(178.84,15.54) 179.25,15.13 185.81,15.13 186.22,14.73 188.59,14.73 190.03,16.16 190.94,16.16 v2(191.55,15.55)
  BOTTOM w0.102: CON3110.3 192,17.02 191.55,16.57 v2(191.55,15.55)
KBL_R_2: length 28.2
  TOP w0.102: v2(173.5,15.54) 173.47,15.56 U3102.11
  IN2 w0.102: v2(188.75,15.54) 188.14,14.93 187.23,14.93 186.67,15.49 186.67,15.59 186.31,15.96 173.92,15.96 v2(173.5,15.54)
  BOTTOM w0.102: v1(189.9,23.48) 189.9,20.17 190.1,19.97 190.28,19.97 190.5,19.75 CON3110.6 190.5,17.91 188.75,16.16 v2(188.75,15.54)
KBL_R_3: length 30
  TOP w0.102: v2(168.76,15.54) 169.37,14.94 169.37,14.62 v1(169.8,14.18) 171,14.18 171.52,13.66 U3102.15
  BOTTOM w0.102: v2(168.76,15.54) 168.76,17.55 170.17,18.96 178.4,18.96 180.93,21.5 186.91,21.5 188.53,19.87 188.8,19.87 189,19.67 CON3110.9
KBL_R_4: length 19.4
  TOP w0.102: U3102.20 174.77,15.4 v2(174.91,15.54)
  BOTTOM w0.102: v2(174.91,15.54) 174.91,16.76 176.24,18.09 178.72,18.09 181.01,20.38 v1(181.67,20.38) 181.82,20.23 184.59,20.23 184.89,20.53 186.57,20.53 187.5,19.6 CON3110.12
KBL_RESET#_R: length 9.5
  TOP w0.102: R3137.1 181.41,16.62 ; 181.41,16.62 R3172.1 178.43,15.09 178.02,14.69 U3102.25 ; 181.41,16.62 181.62,16.42 v1(183.24,16.42)
KSI0: length 50.8
  TOP w0.102: U3002.58 144.8,23.51 141.94,26.37 136.72,26.37 130.11,19.76 130.11,17.54 130.92,16.73 CN5.1 131.2,16 131.19,15.98 v2(131.19,15.86)
  BOTTOM w0.102: v2(131.19,15.86) v1(130.34,15.86) 129.42,15.86 127.18,18.09 116.21,18.09 112.81,14.69 112.81,11.34 112.5,11.03 CON3100.19
KSI1: length 52.2
  TOP w0.102: v2(131.82,15.86) 131.7,15.98 CN5.3 131.7,17.15 131.57,17.28 130.79,17.28 130.31,17.76 130.31,19.06 130.61,19.36 131.35,19.36 138.16,26.17 141.85,26.17 144.91,23.11 U3002.59
  BOTTOM w0.102: CON3100.20 v1(111.5,11.36) 112.58,12.44 112.58,14.97 115.93,18.32 127.39,18.32 129.35,16.36 131.32,16.36 v2(131.82,15.86)
KSI2: length 52.7
  TOP w0.102: v2(132.46,15.86) 132.2,16.11 CN5.5 132.2,17.3 132.3,17.41 132.87,17.41 133.15,17.69 133.15,20.88 138.24,25.97 141.77,25.97 145.02,22.71 U3002.60
  BOTTOM w0.102: v2(132.46,15.86) 131.72,16.59 129.79,16.59 127.23,19.16 116.29,19.16 112.33,15.2 112.33,13.95 111.13,12.76 v1(110.45,12.76) 110.45,12.02 110.5,11.96 CON3100.21
KSI3: length 54.2
  TOP w0.102: U3002.61 145.14,22.31 141.68,25.76 138.32,25.76 133.38,20.82 133.38,17.06 133.05,16.73 CN5.7 132.7,16.25 v2(133.09,15.86)
  BOTTOM w0.102: CON3100.22 109.5,12.81 110.39,13.7 111.39,13.7 v1(111.72,14.03) 111.72,14.87 116.2,19.36 129.59,19.36 130,18.95 130,18.21 131.41,16.8 132.15,16.8 v2(133.09,15.86)
KSI4: length 55.1
  TOP w0.102: U3002.62 145.25,21.91 141.6,25.56 138.41,25.56 133.76,20.91 133.76,17.06 134.09,16.73 CN6.1 134.37,16 v2(134.23,15.86)
  BOTTOM w0.102: v2(134.23,15.86) 133.09,17 131.49,17 130.2,18.29 130.2,19.03 129.67,19.57 115.97,19.57 109.2,12.79 109.2,11.87 v1(108.8,11.47) 108.5,11.17 CON3100.23
KSI5: length 56.6
  TOP w0.102: v2(134.87,15.86) 134.87,15.86 CN6.3 134.87,17.25 134.77,17.36 134.14,17.36 134.04,17.46 134.04,20.91 138.49,25.36 141.51,25.36 145.36,21.51 U3002.63
  BOTTOM w0.102: CON3100.24 107.5,11.66 115.61,19.77 129.8,19.77 130.4,19.17 130.4,18.38 130.94,17.84 v1(131.55,17.84) 132.89,17.84 v2(134.87,15.86)
KSI6: length 58
  TOP w0.102: U3002.64 145.47,21.11 141.43,25.15 138.58,25.15 135.95,22.52 135.95,19.34 136.25,19.03 136.25,17.53 136.12,17.41 135.58,17.41 135.37,17.2 CN6.5 135.37,15.99 v2(135.5,15.86)
  BOTTOM w0.102: v2(135.5,15.86) 135.5,16.54 134.51,17.53 v1(134.09,17.53) 133.05,18.57 133.05,18.99 132.05,19.99 114.48,19.99 114.15,19.67 114.15,18.6 106.5,10.95 CON3100.25
KSI7: length 63.4
  TOP w0.102: U3002.65 148.47,18.75 148.29,18.57 147.72,18.57 141.35,24.95 138.66,24.95 136.15,22.44 136.15,19.45 136.56,19.04 136.56,17.12 136.17,16.73 CN6.7 135.87,16.12 v2(136.14,15.86)
  BOTTOM w0.102: CON3100.26 v1(105.5,11.41) 105.5,12.4 106.19,13.09 108.35,13.09 113.9,18.63 113.9,19.79 114.3,20.19 132.14,20.19 133.25,19.07 133.25,18.66 133.95,17.96 134.36,17.96 136.14,16.19 v2(136.14,15.86)
KSO0: length 59.6
  TOP w0.102: v2(116.49,14.97) 116.44,15.02 116.44,16.12 116.39,16.17 CN1.1 116.09,16.73 115.83,16.98 115.83,19.12 116.85,20.13 116.85,21.08 118.63,22.87 121.07,22.87 122.19,23.98 129.16,23.98 135.2,30.03 143.65,30.03 145.93,32.31 U3002.36
  BOTTOM w0.102: v2(116.49,14.97) 117.87,16.34 123.98,16.34 125.9,14.42 127.15,14.42 v1(128.26,13.3) 130.5,11.06 CON3100.1
KSO1: length 57.9
  TOP w0.102: v2(117.13,14.97) 116.89,15.21 CN1.3 116.89,17.28 116.79,17.38 116.19,17.38 116.06,17.51 116.06,19.06 117.05,20.05 117.05,21 118.69,22.64 121.13,22.64 122.27,23.78 129.24,23.78 135.28,29.83 143.74,29.83 145.82,31.91 U3002.37
  BOTTOM w0.102: CON3100.2 v1(129.5,11.36) 129.5,11.43 126.74,14.19 125.84,14.19 123.92,16.11 118.27,16.11 v2(117.13,14.97)
KSO2: length 55.4
  TOP w0.102: U3002.38 145.71,31.51 143.82,29.62 135.37,29.62 129.32,23.58 122.36,23.58 121.21,22.44 118.78,22.44 117.33,20.99 117.33,19.99 118.21,19.11 118.21,17.52 118.07,17.38 117.6,17.38 117.39,17.17 CN1.5 117.39,15.34 v2(117.76,14.97)
  BOTTOM w0.102: CON3100.3 128.5,10.62 v1(127.57,11.56) 126.69,12.44 126.69,13.05 123.86,15.88 118.68,15.88 v2(117.76,14.97)
KSO3: length 52
  TOP w0.102: U3002.39 145.59,31.11 143.9,29.42 135.45,29.42 129.41,23.38 122.76,23.38 v1(122.05,22.66) 121.01,21.62 119.51,21.62 118.88,20.99 118.88,20.82 118.88,20.82 118.88,20.09 118.41,19.62 118.41,16.85 118.29,16.73 CN1.7 117.89,15.48 v2(118.4,14.97)
  BOTTOM w0.102: v2(118.4,14.97) 119.08,15.65 123.8,15.65 126.08,13.38 126.08,11.97 127.5,10.55 CON3100.4
KSO4: length 52.6
  TOP w0.102: U3002.40 145.48,30.71 143.99,29.22 135.54,29.22 129.49,23.17 123.27,23.17 122.26,22.16 121.91,22.16 121.17,21.42 119.6,21.42 119.08,20.91 119.08,20.01 118.62,19.55 118.62,16.86 118.76,16.73 CN2.1 119.18,16.17 118.91,15.9 118.91,14.54 118.61,14.23 v2(118.61,13.6)
  BOTTOM w0.102: v2(118.61,13.6) 120.44,15.42 123.74,15.42 125.2,13.97 125.2,13.52 v1(125.51,13.22) 125.51,11.57 126.5,10.57 CON3100.5
KSO5: length 51
  TOP w0.102: U3002.41 145.37,30.31 144.07,29.01 135.62,29.01 129.58,22.97 123.36,22.97 122.34,21.95 121.99,21.95 121.26,21.22 119.68,21.22 119.29,20.82 119.29,19.92 118.85,19.49 118.85,17.51 118.95,17.41 119.55,17.41 119.68,17.28 CN2.3 119.68,16.04 119.24,15.6 v2(119.24,13.6)
  BOTTOM w0.102: CON3100.6 125.5,10.77 v1(124.97,11.31) 124.97,13.92 123.66,15.22 120.87,15.22 v2(119.24,13.6)
KSO6: length 46.6
  TOP w0.102: v2(119.88,13.6) 119.88,15.74 120.18,16.05 CN2.5 120.18,17.35 120.24,17.41 120.88,17.41 120.99,17.51 120.99,17.62 120.99,17.62 120.99,19.29 121.88,20.17 122.48,20.17 125.07,22.77 129.66,22.77 135.71,28.81 144.16,28.81 145.26,29.91 U3002.42
  BOTTOM w0.102: v2(119.88,13.6) 120.78,14.49 v1(121.11,14.49) 121.61,14.99 123.6,14.99 124.5,14.09 CON3100.7
KSO7: length 45.2
  TOP w0.102: v2(120.51,13.6) 120.51,14.18 v1(120.82,14.49) 120.82,15.81 120.68,15.94 CN2.7 121.08,16.73 121.27,16.91 121.27,19.28 121.91,19.92 123.43,19.92 126.07,22.56 129.75,22.56 135.79,28.61 144.24,28.61 145.14,29.51 U3002.43
  BOTTOM w0.102: CON3100.8 123.5,12.31 124.28,13.09 124.28,14.03 123.54,14.76 122.15,14.76 121.44,14.05 120.97,14.05 v2(120.51,13.6)
KSO8: length 44.2
  TOP w0.102: v2(121.36,13.6) 122.36,14.6 v1(122.36,15.42) CN3.1 121.9,16.73 121.47,17.16 121.47,19.19 121.94,19.67 123.46,19.67 126.15,22.36 129.83,22.36 135.88,28.4 144.33,28.4 145.03,29.11 U3002.44
  BOTTOM w0.102: v2(121.36,13.6) 122.32,14.56 123.46,14.56 124.07,13.94 124.07,13.17 122.5,11.6 CON3100.9
KSO9: length 43.3
  TOP w0.102: U3002.45 144.92,28.71 144.41,28.2 135.96,28.2 129.91,22.16 126.24,22.16 123.54,19.46 122.1,19.46 121.67,19.03 121.67,17.48 121.8,17.36 122.73,17.36 122.86,17.22 CN3.3 122.86,14.46 v2(121.99,13.6)
  BOTTOM w0.102: v2(121.99,13.6) 122.7,14.31 123.42,14.31 123.87,13.86 123.87,13.26 v1(122.02,11.4) 121.5,10.89 CON3100.10
KSO10: length 40.9
  TOP w0.102: v2(122.63,13.6) 123.36,14.33 CN3.5 123.36,17.28 123.47,17.38 124.01,17.38 124.21,17.58 124.21,19.84 126.32,21.95 130,21.95 136.04,28 144.49,28 144.81,28.31 U3002.46
  BOTTOM w0.102: CON3100.11 120.5,10.52 120.25,10.78 v1(120.25,11.49) 120.91,12.15 122.39,12.15 123.67,13.43 123.67,13.76 123.43,14 123.03,14 v2(122.63,13.6)
KSO11: length 39.5
  TOP w0.102: v2(123.26,13.6) 123.86,14.19 v1(123.86,14.31) CN3.7 124.11,16.73 124.44,17.06 124.44,19.79 126.41,21.75 130.08,21.75 136.13,27.79 142.53,27.79 144.01,26.31 U3002.51
  BOTTOM w0.102: v2(123.26,13.6) 122.07,12.4 120.3,12.4 119.5,11.61 CON3100.12
KSO12: length 47.6
  TOP w0.102: v2(125.22,15.86) 125.48,16.12 CN4.1 125.13,16.73 124.9,16.96 124.9,19.96 126.49,21.55 130.17,21.55 136.21,27.59 142.44,27.59 144.12,25.91 U3002.52
  BOTTOM w0.102: CON3100.13 118.5,10.75 v1(117.98,11.28) 117.8,11.46 116.78,11.46 115.93,12.3 115.93,15.12 117.41,16.59 124.48,16.59 v2(125.22,15.86)
KSO13: length 48.2
  TOP w0.102: v2(125.85,15.86) 125.98,15.99 CN4.3 125.98,17.28 125.88,17.38 125.25,17.38 125.23,17.41 125.1,17.53 125.1,19.87 126.57,21.34 130.25,21.34 136.3,27.39 142.36,27.39 144.24,25.51 U3002.53
  BOTTOM w0.102: CON3100.14 117.5,10.6 117.2,10.9 116.82,10.9 115.5,12.22 v1(115.5,12.91) 115.5,15.15 117.2,16.85 124.86,16.85 v2(125.85,15.86)
KSO14: length 47.2
  TOP w0.102: v2(126.49,15.86) 126.48,15.86 CN4.5 126.48,17.28 126.59,17.38 127.18,17.38 127.3,17.5 127.3,19.19 128.12,20 129.2,20 136.38,27.19 142.27,27.19 144.35,25.11 U3002.54
  BOTTOM w0.102: CON3100.15 116.5,10.71 115.04,12.17 115.04,15.09 117.05,17.1 125.24,17.1 v2(126.49,15.86) 126.02,15.38 v1(126.02,15.2)
KSO15: length 47.7
  TOP w0.102: U3002.55 145.85,24.71 145.67,24.9 144.27,24.9 142.19,26.98 136.47,26.98 129.28,19.8 128.2,19.8 127.51,19.11 127.51,16.98 127.26,16.73 CN4.7 126.98,16 v2(127.12,15.86)
  BOTTOM w0.102: CON3100.16 115.5,11.2 114.66,12.05 114.66,15.15 116.87,17.36 125.62,17.36 v2(127.12,15.86) 127.63,15.35 v1(127.74,15.35)
KSO16: length 48
  TOP w0.102: U3002.56 145.85,24.31 145.47,24.69 144.19,24.69 142.1,26.78 136.55,26.78 129.37,19.6 128.29,19.6 127.74,19.05 127.74,16.96 127.98,16.73 CN7.1 128.28,16 v2(128.14,15.86)
  BOTTOM w0.102: v2(128.14,15.86) 126.41,17.58 116.59,17.58 114.28,15.27 114.28,11.92 114.5,11.7 v1(114.5,11.28) CON3100.17
KSO17: length 49.2
  TOP w0.102: U3002.57 145.88,23.91 145.32,24.47 144.13,24.47 142.02,26.58 136.63,26.58 129.45,19.39 128.37,19.39 127.95,18.97 127.95,17.56 128.17,17.33 128.67,17.33 128.78,17.22 CN7.3 128.78,15.86 v2(128.77,15.86)
  BOTTOM w0.102: v2(128.77,15.86) 126.79,17.84 116.41,17.84 113.5,14.93 v1(113.5,12.73) CON3100.18
L1+: length 13
  BOTTOM w0.121: CON5500.3 313.5,52.27 313.39,52.16 313.01,52.16 312.13,51.27 311.69,51.27 310.11,49.69 310.11,47.67 309.11,46.68 308.38,46.68 308.21,46.85 308.21,47.45 D5502.1 308.34,48.42 308.34,49.13 308.61,49.4 L5501.2
L1-: length 13.1
  BOTTOM w0.121: L5501.3 307.81,49.4 308.1,49.11 308.1,48.65 D5501.1 307.97,47.48 307.97,46.75 308.28,46.44 309.21,46.44 310.34,47.57 310.34,49.59 311.79,51.04 312.22,51.04 313.11,51.92 313.39,51.92 313.5,51.81 CON5500.2
L2+: length 9.3
  TOP w0.121: v6(309.18,79.46) 309.38,79.26 310.24,79.26 310.66,78.83 312.27,78.83 312.73,79.3 312.73,79.83 CON5501.3
  BOTTOM w0.121: L5504.2 306.26,79.88 306.6,79.54 307.25,79.54 D5504.1 308.59,79.46 v6(309.18,79.46)
L2-: length 10
  TOP w0.121: CON5501.2 313.5,79.58 313.32,79.76 313.09,79.76 312.97,79.65 312.97,79.2 312.37,78.6 310.57,78.6 310.14,79.03 309.45,79.03 v2(309.2,78.78)
  BOTTOM w0.121: L5504.3 306.29,79.08 306.51,79.31 307.44,79.31 D5503.1 308.24,79.23 308.75,79.23 v2(309.2,78.78)
LAD0_ESPI_IO0: length 10.6
  TOP w0.121: v1(233.83,60.85) 234.26,60.42 234.34,60.42 v2(234.66,60.1) 235.33,59.43 237.04,59.43 237.17,59.56 241.1,59.56 241.78,60.24 242.49,60.24 SR2202.2
  BOTTOM w0.121: v2(234.66,60.1) 234.66,59.81 U2000.AT22
LAD0_ESPI_IO1: length 11.8
  TOP w0.121: SR2203.2 245.34,60.63 245.19,60.49 244.78,60.49 v1(244.38,60.89) 243.98,60.49 241.68,60.49 241,59.81 237.06,59.81 236.94,59.68 235.78,59.68 v2(235.36,60.1)
  BOTTOM w0.121: U2000.AV22 235.61,59.85 v2(235.36,60.1)
LAD0_ESPI_IO2: length 12.8
  TOP w0.121: v1(232.4,61.89) 233.68,61.89 v2(234.33,61.24) 235.03,60.54 236.86,60.54 237.11,60.28 240.8,60.28 242.04,61.52 242.04,61.93 242.25,62.13 SR2204.2
  BOTTOM w0.121: U2000.AT19 234.61,60.97 234.6,60.97 v2(234.33,61.24)
LAD0_ESPI_IO3: length 4.6
  BOTTOM w0.102: 239.47,62.38 239.29,62.2 238.91,62.2 238.76,62.29 238.75,62.3 238.66,62.3 U2000.BD16
  BOTTOM w0.121: SR2205.2 242.32,62.67 242.03,62.38 239.47,62.38
LAN_CLKREQ#: length 89
  TOP w0.121: R2432.2 243.08,52.13 v1(242.47,52.13) 242.35,52.25 240.7,52.25 240.57,52.38 239.67,52.38 239.33,52.72 239.05,52.72 237.93,53.84 237.13,53.84 236.99,53.98 236.48,53.98 v2(236.05,54.41) ; v2(288.91,95.23) 289.16,95.49 SR3302.1
  IN3 w0.083: v2(236.05,54.41) 236.81,55.18 237.29,55.18 238.92,56.8 238.92,66.73 240.85,68.66 242.18,68.66 242.23,68.72 242.35,68.72 245.04,71.41 245.04,71.52 250.59,77.07 254.84,77.07 257.6,79.83 258.14,79.83 258.55,80.25 258.55,83.07 261.63,86.15 269.55,86.15 270.99,87.59 274.13,87.59 275.14,88.6 276.83,88.6 283.46,95.23 v2(288.91,95.23)
  BOTTOM w0.121: v2(236.05,54.41) 236.25,54.41 236.63,54.8 236.63,55.06 236.96,55.39 237.27,55.39 237.6,55.05 U2000.BB31
LAN_GND: length 1.4
  TOP w0.508: v2(306.3,155.89) C3401.2
  vias: v1(299.8,151.37) v2(299.45,154.67) v2(299.45,153.78) v2(299.45,152.51) v2(299.6,145.37) v2(299.73,149.96) v2(299.73,148.11) v2(299.68,146.97) v2(299.7,143.99) v2(299.83,155.43) v2(300.87,143.26) v2(301.73,153.37) v2(301.73,152.69) v2(301.73,150.27) v2(301.81,149.59) v2(301.76,147.3) v2(301.76,146.67) v2(301.76,144.63) v2(301.78,143.97) v2(302.24,143.22) v2(303,143.24) v2(305.99,150.91) v2(306.18,142.02) v2(306.29,149.18) v2(307.17,140.93) v2(307.96,140.82) v2(308.46,140.32) v2(308.82,139.36) v2(309.61,139.3) v2(310.24,138.64) v2(310.24,138.03) v2(312.12,137.24) v2(312.46,153.2) v2(312.55,148.52) v2(312.46,145.58) v2(312.59,150.44) v2(312.59,143.11) v2(312.58,141.08) v2(312.57,139.26) v2(313.64,155.49) v2(314.48,136.8) v2(315.16,155) v2(315.5,136.81) v2(320.55,154.98) v2(321.86,155.92) v2(321.86,136.29)
LAN_MDI0_N: length 63
  TOP w0.108: U3300.12 281.29,103.13 281.33,103.17 281.33,103.48 283.52,105.68 284.34,105.68 v2(284.61,105.95) ; v2(293.73,152.71) 294.01,152.99 294.21,152.99 294.66,152.54 U3401.3
  IN4 w0.083: v2(293.73,152.71) 294.16,152.71 294.24,152.79 294.24,153.04 294.28,153.09 295.74,153.09 298.15,150.68 298.15,136.43 293.1,131.38 293.1,120.43 292.18,119.51 292.18,113.86 284.99,106.66 284.99,106.33 v2(284.61,105.95)
LAN_MDI0_N_C: length 8.7
  BOTTOM w0.108: 307.93,151.92 307.93,152.46 307.53,152.86 305.67,152.86 L3403.3 ; 307.93,151.92 307.93,150.83 309.03,149.73 309.89,149.73 310.51,149.11 310.51,148.78 CON3400.2 ; 307.93,151.92 v1(307.7,151.92)
LAN_MDI0_N_L: length 4
  TOP w0.108: v2(302.44,152.64) 302.59,152.78 303.57,152.78 303.81,152.54 U3401.22
  BOTTOM w0.108: v2(302.44,152.64) 302.77,152.96 303.47,152.96 303.81,152.62 L3403.4
LAN_MDI0_P: length 63.1
  TOP w0.108: v6(285.3,105.9) 284.87,105.47 284.64,105.47 284.49,105.32 283.67,105.32 281.69,103.33 U3300.11 ; U3401.2 293.88,153.54 v2(293.73,153.4)
  IN4 w0.083: v6(285.3,105.9) 285.3,106.2 285.3,106.2 285.3,106.53 292.49,113.73 292.49,119.38 293.41,120.3 293.41,131.25 298.46,136.3 298.46,150.81 295.87,153.4 v2(293.73,153.4)
LAN_MDI0_P_C: length 8.7
  BOTTOM w0.108: L3403.2 305.63,153.22 306.81,153.22 ; CON3400.1 310.66,149.47 310.04,150.1 309.18,150.1 308.29,150.98 308.29,152.61 307.68,153.22 306.81,153.22 ; v1(306.81,153.45) 306.81,153.22
LAN_MDI0_P_L: length 4
  TOP w0.108: v2(302.44,153.47) 302.77,153.14 303.41,153.14 303.81,153.54 U3401.23
  BOTTOM w0.108: L3403.1 303.45,153.42 303.36,153.32 302.6,153.32 v2(302.44,153.47)
LAN_MDI1_N: length 58.3
  TOP w0.108: v2(293.73,149.71) 293.94,149.92 294.29,149.92 294.66,149.54 U3401.6 ; v6(281.27,105.58) 281.43,105.42 281.43,105.08 280.11,103.76 280.11,103.28 280.09,103.25 U3300.15
  IN4 w0.083: v6(281.27,105.58) 281.3,105.58 287.13,111.42 288.35,111.42 290.3,113.38 290.3,130.32 296.45,136.47 296.45,147.75 294.16,150.04 294.06,150.04 v2(293.73,149.71)
LAN_MDI1_N_C: length 9.5
  IN1 w0.083: CON3400.6 310.18,145.46 309.43,146.21 308.9,146.21 308.36,146.75 308.36,149.26 307.53,150.08 306.78,150.08 v2(306.48,149.78)
  BOTTOM w0.108: v2(306.48,149.78) 306.37,149.66 305.65,149.66 RN3402.2
LAN_MDI1_N_L: length 3.8
  TOP w0.108: v2(302.49,149.66) 302.7,149.87 303.49,149.87 303.81,149.54 U3401.19
  BOTTOM w0.108: v2(302.49,149.66) 302.59,149.76 303.47,149.76 303.78,149.44 RN3402.1
LAN_MDI1_P: length 58.3
  TOP w0.108: v2(293.73,150.35) 293.93,150.54 U3401.5 ; U3300.14 280.49,103.19 280.47,103.21 280.47,103.61 281.83,104.97 281.83,105.48 v2(281.96,105.61)
  IN4 w0.083: v2(281.96,105.61) 281.96,105.8 287.26,111.11 288.47,111.11 290.61,113.25 290.61,130.19 296.76,136.34 296.76,147.88 294.29,150.35 v2(293.73,150.35)
LAN_MDI1_P_C: length 9.5
  IN1 w0.083: v2(306.49,150.39) 307.66,150.39 308.67,149.38 308.67,146.88 309.02,146.52 309.35,146.52 310.26,147.43 CON3400.3
  BOTTOM w0.108: v2(306.49,150.39) 306.13,150.03 305.64,150.03 RN3402.4
LAN_MDI1_P_L: length 3.9
  TOP w0.108: U3401.20 303.86,150.54 303.54,150.23 302.58,150.23 v2(302.46,150.35)
  BOTTOM w0.108: v2(302.46,150.35) 302.69,150.12 303.38,150.12 303.5,150.24 RN3402.3
LAN_MDI2_N: length 54.1
  TOP w0.108: v2(293.73,146.91) 294.2,146.91 294.57,146.54 U3401.9 ; U3300.18 278.89,103.15 278.93,103.19 278.93,104.79 279.25,105.11 279.25,105.84 279.2,105.88 279.2,105.9 v6(279.15,105.95)
  IN4 w0.083: v6(279.15,105.95) 279.53,106.32 279.53,106.56 282.2,109.24 282.2,109.72 283.72,111.24 283.72,113.42 288.8,118.49 288.8,130.14 294.89,136.23 294.89,146.88 294.54,147.23 294.17,147.23 294.11,147.17 294.11,146.95 294.08,146.91 v2(293.73,146.91)
LAN_MDI2_N_C: length 7.5
  BOTTOM w0.108: L3401.3 305.65,146.87 307.67,146.87 308,146.54 308,145.96 ; CON3400.5 310.59,145.39 310.4,145.19 308.43,145.19 308,145.63 308,145.96 ; v1(307.77,145.96) 308,145.96
LAN_MDI2_N_L: length 3.9
  TOP w0.108: U3401.16 303.81,146.54 303.54,146.81 302.62,146.81 v2(302.44,146.64)
  BOTTOM w0.108: v2(302.44,146.64) 302.69,146.89 303.64,146.89 L3401.4
LAN_MDI2_P: length 54.1
  TOP w0.108: v2(293.73,147.54) U3401.8 ; U3300.17 279.29,104.64 279.61,104.96 279.61,105.72 v2(279.84,105.95)
  IN4 w0.083: v2(293.73,147.54) 294.67,147.54 295.2,147.01 295.2,136.1 289.11,130.01 289.11,118.36 284.04,113.29 284.04,111.11 282.51,109.59 282.51,109.11 279.84,106.43 v2(279.84,105.95)
LAN_MDI2_P_C: length 7.5
  BOTTOM w0.108: v1(306.86,147.46) 306.86,147.23 ; 306.86,147.23 307.82,147.23 308.36,146.69 308.36,145.78 308.58,145.56 310.25,145.56 310.52,145.83 310.52,146.07 CON3400.4 ; 306.86,147.23 305.64,147.23 L3401.2
