# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 205.02,142.4 205.02,141.04 204.77,140.79 202.21,140.79 202.15,140.85 202.15,142.53 202.2,142.59 204.83,142.59
GND on TOP (solid shape): 210.6,112.99 210.6,112.4 209.84,111.64 209.48,111.64 209.3,111.82 209.3,112.88 209.48,113.06 210.52,113.06
GND on TOP (solid shape): 256.27,76.26 256.27,75.01 256.09,74.84 255.12,74.84 254.97,74.99 254.97,75.98 255.38,76.38 256.14,76.38
GND on TOP (solid shape): 262.64,74.24 262.64,72.6 262.41,72.37 262.03,72.37 261.45,72.96 261.45,74.33 261.52,74.4 262.48,74.4
GND on TOP (solid shape): 266.86,48.8 266.86,44.66 266.45,44.25 262.47,44.25 262.28,44.44 262.28,48.81 262.38,48.91 266.74,48.91
GND on TOP (solid shape): 281.7,38.77 281.7,37.42 281.63,37.35 280.95,37.35 280.85,37.44 280.85,39.11 280.96,39.22 281.25,39.22
GND on TOP (solid shape): 294.41,109.55 294.41,107.53 294.29,107.41 293.38,107.41 293.18,107.61 293.18,109.41 293.43,109.66 294.3,109.66
GND on TOP (solid shape): 297.06,104.85 297.06,103.65 296.87,103.47 295.64,103.47 295.34,103.77 295.34,104.86 295.43,104.95 296.95,104.95
GND on TOP (solid shape): 303.61,64.62 303.61,62.92 303.59,62.89 301.94,62.89 301.86,62.97 301.86,64.57 301.94,64.65 303.59,64.65
GND on TOP (solid shape): 303.96,108.8 303.96,107.97 303.77,107.78 301.02,107.78 300.84,107.96 300.84,108.84 300.89,108.89 303.86,108.89
GND on TOP (solid shape): 43.01,115.83 43.01,114.84 42.96,114.79 41.51,114.79 41.48,114.82 41.48,116.52 41.54,116.57 42.27,116.57
GND on TOP (solid shape): 153.75,73.28 153.75,70.36 153.44,70.05 153.15,70.05 152.48,70.71 152.48,73.01 153.02,73.55 153.48,73.55
GND on TOP (solid shape): 159.35,76.93 159.35,75.5 159.17,75.31 158.94,75.31 158.33,75.92 158.33,77.32 158.52,77.51 158.77,77.51
GND on TOP (solid shape): 179.3,107.73 179.3,106.9 179.08,106.68 178.53,106.68 178.14,107.08 178.14,107.58 178.38,107.81 179.21,107.81
GND on TOP (solid shape): 1.25,18.78 2.01,18.78 2.14,18.65 2.14,16.24 0.87,14.97 0.62,14.97 0.62,18.9 0.74,19.03 1,19.03
GND on TOP (solid shape): 23.64,51.5 24.66,51.5 24.72,51.44 24.72,49.74 24.11,49.13 22.71,49.13 20.85,50.99 20.85,51.7 20.95,51.8 23.35,51.8
GND on TOP (solid shape): 26.55,54.59 26.55,53.32 26.47,53.25 25.46,53.25 25.1,53.6 25.1,54.59 25.36,54.85 26.3,54.85
GND on TOP (solid shape): 34.75,24.62 36.25,24.62 36.35,24.52 36.35,24.16 36.15,23.96 34.31,23.96 34.16,24.11 34.16,24.49 34.29,24.62 34.75,24.62
GND on TOP (solid shape): 79.89,141.35 79.89,138.68 79.64,138.43 73.13,138.43 72.89,138.66 72.89,140.85 73.18,141.14 73.18,142.11 73.28,142.2 79.04,142.2
GND on TOP (solid shape): 108.44,14.59 108.44,12.81 108.31,12.68 103.87,12.68 103.74,12.81 103.74,14.71 103.87,14.84 108.18,14.84
GND on TOP (solid shape): 111.67,74.66 111.67,70.45 111.54,70.32 107.35,70.32 107.22,70.45 107.22,75.93 107.52,76.23 110.1,76.23
GND on TOP (solid shape): 111.7,119.22 111.7,118.27 111.53,118.09 111.11,118.09 110.6,118.6 110.6,119.23 110.72,119.36 111.56,119.36
GND on TOP (solid shape): 128.61,84.39 128.61,83.57 128.45,83.42 128.17,83.42 127.77,83.83 127.01,83.83 126.9,83.93 126.9,84.44 127.06,84.59 128.4,84.59
GND on TOP (solid shape): 141.68,139.81 141.68,139.62 141.56,139.49 141.36,139.49 140.96,139.9 140.52,139.9 140.46,139.95 140.46,140.31 140.48,140.33 141.16,140.33
GND on TOP (solid shape): 141.71,137.4 141.71,137.2 141.57,137.06 141.31,137.06 141.17,137.19 140.24,137.19 140.21,137.22 140.21,137.75 140.22,137.76 141.35,137.76
GND on TOP (solid shape): 160.7,128.64 160.7,127.7 160.5,127.49 159.89,127.49 159.5,127.88 159.17,127.88 159.09,127.97 159.09,128.55 159.37,128.82 160.51,128.82
GND on TOP (solid shape): 166.1,46.67 166.1,46.44 165.94,46.29 165.94,45.04 165.92,45.02 165.39,45.02 165.36,45.04 165.36,46.46 165.72,46.82 165.94,46.82
GND on TOP (solid shape): 167.42,48.34 168.18,48.34 168.23,48.29 168.23,47.89 168.21,47.86 167.24,47.86 166.78,48.32 166.78,48.47 166.96,48.65 167.11,48.65
GND on TOP (solid shape): 167.72,127.94 167.72,126.23 168.5,125.45 168.5,125.17 168.44,125.11 168.06,125.11 167.31,125.87 167.31,127.95 167.44,128.08 167.59,128.08
GND on TOP (solid shape): 169.27,156.45 169.27,144.3 168.84,143.87 157.13,143.87 156.83,144.18 156.83,156.57 157.08,156.83 168.89,156.83
GND on TOP (solid shape): 176.38,131.44 176.38,131.07 176.27,130.97 175.91,130.97 175.49,130.55 174.87,130.55 174.79,130.62 174.79,131.44 174.88,131.53 176.29,131.53
GND on TOP (solid shape): 177.02,142.73 177.02,141.84 176.89,141.71 176.01,141.71 175.57,142.15 175.57,142.59 175.84,142.86 176.89,142.86
GND on TOP (solid shape): 180.46,128.66 180.46,125.63 180.31,125.48 179.93,125.48 179.88,125.53 179.88,125.93 180.06,126.11 180.06,128.65 180.17,128.76 180.36,128.76
GND on TOP (solid shape): 194.52,77.1 194.52,76.94 193.63,76.05 193.05,76.05 193.02,76.08 193.02,76.49 193.05,76.51 193.48,76.51 194.19,77.22 194.39,77.22
GND on TOP (solid shape): 194.98,118.93 194.98,118.73 194.19,117.94 192.94,117.94 192.89,117.99 192.89,118.52 192.92,118.55 194.04,118.55 194.57,119.08 194.82,119.08
GND on TOP (solid shape): 195.81,79.71 195.81,79.53 195.69,79.41 195.48,79.41 195.38,79.51 193,79.51 192.97,79.53 192.97,79.97 193,79.99 195.54,79.99
GND on TOP (solid shape): 196.4,75.27 196.4,74.58 196.42,74.56 196.42,73.67 196.4,73.64 195.84,73.64 195.81,73.67 195.81,75.24 196.02,75.45 196.22,75.45
GND on TOP (solid shape): 197.16,106.71 197.16,105.8 196.6,105.24 196.42,105.24 196.27,105.39 196.27,105.54 196.7,105.98 196.7,106.71 196.73,106.74 197.14,106.74
GND on TOP (solid shape): 197.54,75.29 197.54,75.09 197.29,74.84 197.29,73.9 197.26,73.87 196.86,73.87 196.83,73.9 196.83,75.11 197.16,75.45 197.39,75.45
GND on TOP (solid shape): 210.37,106.03 210.37,105.44 210.34,105.42 209.58,105.42 209.2,105.04 208.9,105.04 208.79,105.14 208.79,105.37 209.48,106.05 210.34,106.05
GND on TOP (solid shape): 210.7,181.71 210.7,174.18 210.29,173.77 207.4,173.77 206.89,174.29 206.89,181.87 206.97,181.95 210.46,181.95
GND on TOP (solid shape): 219.58,98.66 219.58,98.13 219.48,98.03 219.18,98.03 219.04,98.17 218.32,98.17 218.18,98.32 218.18,98.68 218.41,98.91 219.32,98.91
GND on TOP (solid shape): 220.64,53.45 220.64,53.17 220.5,53.03 219.99,53.03 219.84,52.88 218.83,52.88 218.79,52.92 218.79,53.49 218.87,53.57 220.52,53.57
GND on TOP (solid shape): 261.14,85.25 261.14,84.39 260.99,84.23 258.39,84.23 258.33,84.18 257.14,84.18 256.99,84.34 256.99,84.55 257.77,85.33 261.07,85.33
GND on TOP (solid shape): 262.26,28.61 262.26,25.85 261.86,25.45 258.61,25.45 257.03,27.03 257.03,29.57 257.45,29.99 260.88,29.99
GND on TOP (solid shape): 310.45,58.78 310.45,56.94 309.88,56.37 307.04,56.37 306.91,56.51 306.91,58.78 307.16,59.03 310.2,59.03
GND on TOP (solid shape): 311.22,43.53 311.22,42.49 310.87,42.15 309.78,42.15 309,42.93 308.29,42.93 308.04,43.17 308.04,43.64 308.14,43.75 311,43.75
GND on TOP (solid shape): 319,113 319,112.88 321.04,112.88 321.04,113 322.14,113 322.14,111 310.8,111 310.8,113 317.42,113
GND on TOP (solid shape): 15.84,62.52 15.84,60.9 15.71,60.77 14.67,60.77 14.4,61.03 14.4,62.59 14.43,62.61 15.75,62.61
GND on TOP (solid shape): 16.04,36.62 16.04,34.73 15.89,34.58 15.46,34.58 15.38,34.66 15.38,35.35 15.23,35.5 15.23,36.7 15.41,36.88 15.78,36.88
GND on TOP (solid shape): 29.7,21.7 29.7,20.56 29.57,20.43 28.94,20.43 28.81,20.56 27.16,20.56 26.88,20.84 26.88,23.22 27.01,23.35 28.05,23.35
GND on TOP (solid shape): 59.04,103.18 59.04,100.57 58.91,100.44 55.48,100.44 55.35,100.57 55.35,102.6 56.37,103.61 58.6,103.61
GND on TOP (solid shape): 82.75,124.42 82.75,120.23 82.63,120.11 81.49,120.11 81.37,120.23 81.37,124.39 81.45,124.47 82.69,124.47
GND on TOP (solid shape): 100.72,103.13 100.72,102.57 100.67,102.52 100.46,102.52 99.9,101.96 99.25,101.96 99.12,102.1 99.12,102.88 99.42,103.18 100.67,103.18
GND on TOP (solid shape): 127.51,167.28 128.63,166.16 128.63,165.64 128.52,165.53 128.31,165.53 128.3,165.51 120.88,165.51 120.61,165.79 120.61,167.01 120.89,167.29 127.51,167.29
GND on TOP (solid shape): 139.71,87.51 139.71,85.76 139.51,85.56 136.74,85.56 136.33,85.96 136.33,87.03 136.96,87.66 139.55,87.66
GND on TOP (solid shape): 153.13,128.51 154.19,128.51 154.26,128.44 154.26,127.75 154.17,127.66 153.3,127.66 152.43,128.53 152.43,128.72 152.54,128.83 152.81,128.83
GND on TOP (solid shape): 179.29,103.57 179.29,102.65 179.17,102.53 178.45,102.53 178.09,102.89 178.09,103.26 178.54,103.71 179.14,103.71
GND on TOP (solid shape): 179.65,92.72 179.65,92.16 179.42,91.93 177.96,91.93 177.48,92.42 177.48,92.59 177.58,92.69 177.89,92.69 178.09,92.89 179.47,92.89
GND on TOP (solid shape): 208.59,75.27 208.59,73.87 208.57,73.84 208.01,73.84 207.98,73.87 207.98,75.11 207.58,75.52 207.58,75.72 207.75,75.9 207.96,75.9
GND on TOP (solid shape): 209.4,80.09 210.55,80.09 210.57,80.07 210.57,79.66 210.55,79.64 209.2,79.64 208.69,80.14 208.69,80.35 208.82,80.47 209.02,80.47
GND on TOP (solid shape): 226.57,81.06 226.57,78.47 226.5,78.39 221.95,78.39 221.16,79.18 221.16,81.67 221.46,81.97 225.66,81.97
GND on TOP (solid shape): 228.44,55.25 228.44,55.01 228.2,54.77 226.38,54.77 226.27,54.87 226.27,55.25 226.33,55.3 227.48,55.3 227.62,55.44 228.25,55.44
GND on TOP (solid shape): 4.4,24.72 4.4,24.1 4.28,23.98 4.28,22.57 3.98,22.27 2.73,22.27 2.65,22.36 2.65,23.78 3.66,24.8 4.32,24.8
GND on TOP (solid shape): 9.12,46.97 9.12,46.34 9,46.21 7.85,46.21 7.6,46.46 6.46,46.46 6.2,46.21 4.43,46.21 4.3,46.34 4.3,46.97 4.43,47.1 9,47.1
GND on TOP (solid shape): 53.96,155.81 53.96,151.24 53.32,150.6 53.32,148.57 52.56,147.81 50.15,147.81 46.21,151.75 46.21,155.81 46.72,156.32 53.45,156.32
GND on TOP (solid shape): 60.56,17.51 60.56,15.73 60.43,15.6 58.4,15.6 58.27,15.73 55.68,15.73 55.58,15.83 55.58,17.48 55.73,17.63 60.43,17.63
GND on TOP (solid shape): 74.96,112.53 74.96,111.44 74.89,111.36 74.45,111.36 74.33,111.49 74.33,112.22 74,112.55 73.51,112.55 73.36,112.71 73.36,113.04 73.41,113.09 74.4,113.09
GND on TOP (solid shape): 88.66,109.76 88.66,107.6 88.47,107.41 87.71,107.41 87.65,107.47 87.65,107.88 87.86,108.1 87.86,108.97 87.86,108.98 87.86,109.77 87.97,109.89 88.54,109.89
GND on TOP (solid shape): 88.99,116.19 88.99,112.83 88.97,112.81 88.58,112.81 88.42,112.96 86.9,112.96 86.67,112.73 86.33,112.73 86.32,112.74 86.32,116.56 86.43,116.67 88.51,116.67
GND on TOP (solid shape): 91.76,124.42 91.76,120.28 91.66,120.17 90.47,120.17 90.39,120.25 90.39,124.44 90.44,124.49 91.69,124.49
GND on TOP (solid shape): 92.97,3.61 92.97,3.05 93.24,2.78 93.24,2.3 93.14,2.21 92.69,2.21 92.66,2.23 92.66,2.77 92.37,3.06 92.37,3.65 92.49,3.77 92.81,3.77
GND on TOP (solid shape): 107.14,7.86 110.12,7.86 110.34,7.63 110.34,5.32 110.22,5.19 107.53,5.19 105.73,6.99 105.73,7.63 106.07,7.97 106.07,7.98 107.01,7.98
GND on TOP (solid shape): 111.74,38.84 111.74,34.4 111.61,34.27 108.06,34.27 106.82,35.51 106.82,37.86 108.06,39.1 111.49,39.1
GND on TOP (solid shape): 112.25,129.27 112.25,128.89 112.12,128.76 111.61,128.76 111.49,128.63 111.49,128.25 111.36,128.12 110.98,128.12 110.47,128.63 110.47,129.27 110.6,129.39 112.12,129.39
GND on TOP (solid shape): 142.22,157.21 142.22,144.6 142.11,144.48 135.71,144.48 135.36,144.83 135.36,146.94 134.43,147.88 134.43,150.68 134.51,150.77 134.51,155.7 136.2,157.39 142.04,157.39
GND on TOP (solid shape): 142.29,131.39 142.29,131.15 142.18,131.04 141.62,131.04 141.49,130.91 140.15,130.91 140.12,130.94 140.12,131.45 140.14,131.47 141.33,131.47 141.35,131.49 142.18,131.49
GND on TOP (solid shape): 152.92,127.1 152.92,126.77 153.1,126.6 153.1,125.58 153.04,125.52 152.3,125.52 152.23,125.6 152.23,126.39 152.31,126.47 152.31,127.09 152.48,127.27 152.75,127.27
GND on TOP (solid shape): 157.69,96.98 157.69,95.21 157.59,95.1 157.28,95.1 157.13,95.26 157.13,96.17 156.9,96.4 156.78,96.4 156.75,96.43 156.75,96.98 156.78,97.01 157.66,97.01
GND on TOP (solid shape): 169.56,77.67 169.56,76.02 169.42,75.88 168.81,75.88 168.64,76.05 168.64,77.37 168.82,77.55 168.85,77.58 168.88,77.6 169.12,77.85 169.38,77.85
GND on TOP (solid shape): 171.2,138.01 172.65,138.01 172.68,137.98 172.68,137.52 172.65,137.5 171.51,137.5 171.25,137.75 170.85,137.75 170.69,137.9 170.69,138.06 170.85,138.21 171,138.21
GND on TOP (solid shape): 174.73,52 175.22,52 175.39,51.82 175.39,51.62 175.14,51.37 174.83,51.37 174.63,51.16 173.82,51.16 173.79,51.19 173.79,52.08 173.82,52.1 174.63,52.1
GND on TOP (solid shape): 181.13,130.09 181.13,129.75 181.09,129.71 180.4,129.71 180.37,129.68 178.82,129.68 178.75,129.76 178.75,130.03 178.85,130.13 181.08,130.13
GND on TOP (solid shape): 187.74,47.66 187.74,46.86 187.64,46.77 186.9,46.77 186.37,46.24 186.06,46.24 185.99,46.31 185.99,46.49 186.87,47.38 186.87,47.66 186.9,47.68 187.71,47.68
GND on TOP (solid shape): 188.46,140.85 188.46,140.16 188.29,139.99 187.49,139.99 187.3,139.79 187.1,139.79 186.96,139.94 186.96,140.19 187.5,140.73 187.5,140.91 187.51,140.92 188.39,140.92
GND on TOP (solid shape): 194.42,102.85 194.85,102.85 194.98,102.72 194.98,102.55 194.85,102.42 193.68,102.42 193.43,102.67 193.2,102.67 193.17,102.7 193.17,103.11 193.2,103.13 194.14,103.13
GND on TOP (solid shape): 195.23,106.74 195.23,105.29 195.18,105.24 195.18,104.53 195.08,104.43 194.85,104.43 194.72,104.55 194.72,105.47 194.77,105.52 194.77,106.74 194.8,106.76 195.21,106.76
GND on TOP (solid shape): 196.01,114.77 196.01,114.55 195.92,114.46 194.24,114.46 193.91,114.13 193.91,113.93 193.88,113.9 193.38,113.9 193.35,113.93 193.35,114.38 193.88,114.92 195.87,114.92
GND on TOP (solid shape): 196.68,94.14 196.68,93.66 196.5,93.48 196.5,92.72 196.48,92.69 195.94,92.69 195.92,92.72 195.92,93.68 196.09,93.86 196.09,94.11 196.27,94.29 196.53,94.29
GND on TOP (solid shape): 215.5,28.38 215.5,28.02 215.3,27.82 214,27.82 213.65,28.18 213.65,28.51 213.9,28.76 215.12,28.76
GND on TOP (solid shape): 306.6,140.22 306.64,140.22 311,135.85 311,135.11 310.75,134.86 309.35,134.86 309.06,135.15 309.06,136.85 305.14,140.77 305.14,141.09 305.33,141.28 305.55,141.28
GND on TOP (solid shape): 309.86,69.58 309.86,67.42 309.73,67.29 307.32,67.29 306.94,66.91 306.94,66.15 306.81,66.02 306.3,66.02 306.18,66.15 306.18,69.45 306.43,69.7 309.73,69.7
GND on TOP (solid shape): 1.76,41.26 1.76,40.7 1.73,40.67 1.73,39.5 1.89,39.35 1.89,36.94 1.76,36.81 1.38,36.81 1.25,36.94 1.25,41.26 1.38,41.38 1.63,41.38
GND on TOP (solid shape): 87.04,124.42 87.04,120.25 86.96,120.17 85.74,120.17 85.68,120.24 85.68,124.36 85.81,124.49 86.96,124.49
GND on TOP (solid shape): 99.33,130.84 99.33,129.44 99.22,129.33 99.2,129.32 98.85,129.32 98.78,129.36 98.7,129.44 98.7,130.84 98.82,130.97 99.2,130.97
GND on TOP (solid shape): 101.62,130.84 101.62,129.44 101.49,129.32 101.21,129.32 101.14,129.36 101.05,129.39 101.04,129.39 100.98,129.44 100.98,130.84 101.11,130.97 101.49,130.97
GND on TOP (solid shape): 104.16,130.84 104.16,129.44 104.1,129.39 104.09,129.39 104,129.36 103.93,129.32 103.65,129.32 103.52,129.44 103.52,130.84 103.65,130.97 104.03,130.97
GND on TOP (solid shape): 105.55,103.13 105.55,102.58 104.86,101.89 104.41,101.89 104.03,102.27 104.03,102.53 104.04,102.59 104.05,102.66 104.58,103.19 105.49,103.19
GND on TOP (solid shape): 165.6,127.27 165.6,125.15 165.52,125.07 164.88,125.07 164.74,125.21 164.74,127.39 164.52,127.61 164.22,127.61 164.05,127.78 164.05,127.89 164.25,128.08 164.79,128.08
GND on TOP (solid shape): 167.5,116.72 167.5,116.52 167.42,116.43 167.06,116.43 166.93,116.3 166.93,115.34 166.88,115.29 166.34,115.29 166.2,115.44 166.2,116.53 166.48,116.81 167.42,116.81
GND on TOP (solid shape): 179.13,56.14 179.79,56.14 179.81,56.12 179.81,55.71 179.79,55.68 178.37,55.68 178.31,55.7 178.25,55.7 178.03,55.91 178.03,56.12 178.19,56.27 179,56.27
GND on TOP (solid shape): 180.12,142.32 180.12,140.91 180.54,140.48 180.54,140.31 180.44,140.2 180.26,140.2 179.68,140.78 179.68,141.83 179.54,141.96 179.54,142.4 179.58,142.43 180,142.43
GND on TOP (solid shape): 183.71,143.08 183.71,142.73 184.74,141.69 184.74,141.54 184.56,141.36 184.16,141.36 183.73,141.79 183.13,141.79 182.99,141.92 182.99,143.27 183.05,143.33 183.46,143.33
GND on TOP (solid shape): 186.83,142.8 186.83,142.3 187.42,141.71 187.42,141.49 187.29,141.36 186.99,141.36 186.45,141.9 186.32,141.9 186.25,141.96 186.25,142.82 186.3,142.88 186.75,142.88
GND on TOP (solid shape): 191.12,180.07 191.12,174.23 190.68,173.79 186.56,173.79 186.08,174.26 186.08,180.07 186.21,180.19 190.99,180.19
GND on TOP (solid shape): 209.78,11.54 209.78,8.87 209.66,8.74 201.53,8.74 201.28,9 201.28,11.28 201.4,11.41 206.1,11.41 206.36,11.67 209.66,11.67
GND on TOP (solid shape): 2.9,53.45 2.9,53.02 3.16,52.76 3.16,52.48 3.13,52.46 3.11,52.46 2.88,52.23 2.88,51.98 2.75,51.85 2.24,51.85 2.11,51.98 2.11,53.42 2.22,53.52 2.83,53.52
GND on TOP (solid shape): 93.51,125.75 93.41,125.64 93.35,125.64 93.13,125.86 93.13,126.04 93.1,126.04 93.1,126.11 92.92,126.29 92.92,127.25 93.06,127.39 93.13,127.39 93.13,127.81 93.14,127.81 93.51,127.81
GND on TOP (solid shape): 142.25,122.8 142.25,121.32 142.02,121.09 137.29,121.09 137.05,121.33 135.83,121.33 135.29,120.78 135.29,114.57 135.05,114.33 134.32,114.33 131.5,117.15 131.5,127.26 132.11,127.87 137.18,127.87
GND on TOP (solid shape): 142.3,142.7 142.3,141.79 142.58,141.51 142.58,141.15 142.42,141 142.2,141 141.78,141.42 141.74,141.49 141.69,141.55 141.69,142.7 141.71,142.73 142.27,142.73
GND on TOP (solid shape): 156.09,52.69 156.83,52.69 156.95,52.56 156.95,52.38 156.83,52.25 156.29,52.25 156.19,52.15 155.96,52.15 155.76,52.36 155.07,52.36 155.05,52.38 155.05,52.79 155.07,52.81 155.96,52.81
GND on TOP (solid shape): 156.37,55.43 156.85,55.43 156.98,55.3 156.98,55.15 156.85,55.02 155.66,55.02 155.56,55.13 154.41,55.13 154.39,55.15 154.39,55.71 154.41,55.73 155.38,55.73 155.61,55.96 155.84,55.96
GND on TOP (solid shape): 156.39,62.92 156.39,61.93 155.78,61.32 155.53,61.32 155.38,61.17 155.38,60.61 155.35,60.59 154.46,60.59 154.44,60.61 154.44,61.22 155.45,62.24 155.45,62.92 155.48,62.95 156.37,62.95
GND on TOP (solid shape): 173.23,127.12 173.23,126.39 173.16,126.32 172.44,126.32 172.08,125.95 172.08,124.94 172.03,124.9 171.57,124.9 171.53,124.93 171.53,126.18 171.65,126.3 171.65,126.99 171.85,127.19 173.17,127.19
GND on TOP (solid shape): 176.27,135.81 176.75,135.81 177,135.55 177,135.42 176.89,135.31 176.71,135.31 176.55,135.47 175.69,135.47 175.65,135.43 175.2,135.43 175.12,135.5 175.12,135.85 175.14,135.87 176.21,135.87
GND on TOP (solid shape): 179.84,50.93 180.45,50.93 180.47,50.91 180.47,50.5 180.45,50.48 179.86,50.48 179.81,50.43 179.81,50.05 179.69,49.92 179.48,49.92 179.36,50.05 179.36,50.93 179.51,51.09 179.69,51.09
GND on TOP (solid shape): 187.76,129.34 187.76,129.03 187.92,128.88 188.88,128.88 188.96,128.79 188.96,128.09 188.91,128.03 187.88,128.03 187.33,128.58 187.33,129.34 187.46,129.47 187.64,129.47
GND on TOP (solid shape): 189.95,136.29 189.95,135.98 189.86,135.9 189.59,135.9 189.49,136 188.47,136 188.32,135.85 186.71,135.85 186.6,135.96 186.6,136.17 186.92,136.5 187.33,136.5 187.52,136.69 189.54,136.69
GND on TOP (solid shape): 204.93,99.85 204.93,99.04 204.96,99.02 205.47,99.02 205.59,98.89 205.59,98.71 205.44,98.56 204.55,98.56 204.43,98.69 204.43,98.89 204.48,98.94 204.48,99.85 204.5,99.88 204.91,99.88
GND on TOP (solid shape): 209.76,120.15 210.9,120.15 210.93,120.12 210.93,119.56 210.9,119.54 210.09,119.54 209.58,119.03 209.38,119.03 209.23,119.18 209.23,119.46 209.28,119.51 209.28,120.23 209.38,120.33 209.58,120.33
GND on TOP (solid shape): 210.78,153.1 210.78,143.88 210.04,143.15 202.54,143.15 202.22,143.48 202.22,147.02 201.15,148.09 201.15,153.36 201.8,154.01 209.87,154.01
GND on TOP (solid shape): 210.78,82.4 210.78,82.06 210.77,81.98 210.78,81.91 210.78,81.85 210.75,81.82 209.28,81.82 209.05,81.59 208.79,81.59 208.64,81.74 208.64,81.95 209.12,82.43 210.75,82.43
GND on TOP (solid shape): 210.9,117.43 210.9,116.24 211.08,116.06 211.08,115.55 211.05,115.53 210.19,115.53 209.58,114.92 209.38,114.92 209.28,115.02 209.28,117 209.66,117.38 209.91,117.38 209.99,117.46 210.88,117.46
GND on TOP (solid shape): 258.96,77.71 258.96,77.65 258.22,76.92 257.82,76.92 257.69,77.05 257.69,77.11 257.71,77.23 257.69,77.35 257.69,77.76 258.02,78.09 258.58,78.09
GND on TOP (solid shape): 287.79,60.64 288.82,60.64 289.13,60.33 289.75,60.33 289.92,60.15 289.92,59.62 289.79,59.49 285.43,59.49 285.38,59.54 285.38,60.61 285.53,60.76 287.66,60.76
GND on TOP (solid shape): 307.33,27.92 309.99,27.92 310.11,27.79 310.11,27.03 309.86,26.78 308.95,26.78 307.85,25.69 305.62,25.69 305.16,26.14 305.16,28.31 305.42,28.57 306.69,28.57
GND on TOP (solid shape): 23.6,14.36 23.6,13.95 23.48,13.82 20.4,13.82 20.2,13.62 20.2,10.68 20.05,10.52 18.9,10.52 18.52,10.9 18.52,14.08 18.93,14.49 23.48,14.49
GND on TOP (solid shape): 53.91,190 53.91,189.62 54.34,189.19 54.34,188.37 54.26,188.3 53.68,188.3 53.07,188.91 53.07,189.39 52.81,189.64 52.81,190 52.91,190.1 53.8,190.1
GND on TOP (solid shape): 118.85,11.79 118.85,10.65 119.11,10.4 119.79,10.4 119.87,10.32 119.87,9.33 119.79,9.25 116.19,9.25 115.93,9.51 115.93,13.19 116.06,13.32 117.33,13.32
GND on TOP (solid shape): 130.54,75.18 130.54,73.26 130.33,73.06 129.65,73.06 129.44,72.85 129.44,72.12 129.24,71.91 128.38,71.91 128.23,72.07 128.23,75.11 128.48,75.37 130.35,75.37
GND on TOP (solid shape): 139.73,80.17 140.72,80.17 140.9,79.99 140.9,79.64 140.7,79.44 139.62,79.44 139.3,79.76 138.33,79.76 138.17,79.92 138.17,80.46 138.34,80.63 139.27,80.63
GND on TOP (solid shape): 146.49,130.06 146.49,129.74 146.43,129.68 145.98,129.68 145.98,129.69 145.76,129.69 145.69,129.62 144.24,129.62 144.14,129.72 144.14,129.93 144.22,130.02 145.49,130.02 145.6,130.13 146.42,130.13
GND on TOP (solid shape): 160.71,140.42 160.71,140.11 160.61,140.01 160.61,139.3 160.51,139.2 160.23,139.2 160.13,139.3 160.13,139.61 159.92,139.81 159.01,139.81 158.93,139.88 158.93,140.52 158.98,140.57 160.56,140.57
GND on TOP (solid shape): 176.16,139.96 176.99,139.96 177.12,139.83 177.12,139.66 176.97,139.5 175.98,139.5 175.57,139.91 175.19,139.91 175.16,139.94 175.16,140.39 175.19,140.42 175.7,140.42
GND on TOP (solid shape): 176.33,138.23 176.33,137.57 176.41,137.5 176.41,137.24 176.26,137.09 175.54,137.09 175.16,137.47 174.86,137.47 174.83,137.5 174.83,138.06 174.86,138.08 175.75,138.08 176.03,138.36 176.21,138.36
GND on TOP (solid shape): 182.35,47.45 182.35,46.11 182.45,46.01 182.45,43.76 182.23,43.54 181.23,43.54 180.66,44.11 180.66,45.58 181.25,46.17 181.27,46.18 181.73,46.18 181.85,46.31 181.85,47.46 181.96,47.57 182.23,47.57
GND on TOP (solid shape): 183.2,78.48 183.2,78.03 183.2,78.03 183.2,77.82 183.05,77.68 181.38,77.68 181.28,77.77 181.28,78 181.51,78.23 181.51,78.45 181.69,78.63 183.05,78.63
GND on TOP (solid shape): 199.02,106.76 199.02,105.7 199.14,105.57 199.14,104.71 199.04,104.6 198.84,104.6 198.71,104.73 198.71,105.37 198.56,105.52 198.56,106.76 198.58,106.79 198.99,106.79
GND on TOP (solid shape): 77.99,193.17 78.07,192.82 78.26,192.51 78.26,192.37 78.15,192.37 78.15,185.7 69.65,185.7 69.65,193.17
GND on TOP (solid shape): 78.72,5.95 79.74,5.95 79.86,5.82 79.86,1.38 79.74,1.25 75.67,1.25 75.55,1.38 75.55,5.82 75.93,6.2 78.47,6.2
GND on TOP (solid shape): 81.24,127.71 81.24,127.4 81.28,127.36 81.48,127.36 81.52,127.32 81.52,126.32 81.19,125.98 81.19,125.65 81.15,125.61 80.92,125.61 80.88,125.65 80.88,127.8 80.9,127.82 81.13,127.82
GND on TOP (solid shape): 97.78,127.88 97.78,127.45 97.84,127.39 98.04,127.39 98.09,127.34 98.09,126.15 97.99,126.04 97.82,126.04 97.78,126.01 97.78,125.6 97.72,125.54 97.32,125.54 97.22,125.63 97.22,127.81 97.31,127.9 97.76,127.9
GND on TOP (solid shape): 115.97,125.43 115.9,125.23 115.96,125.03 114.53,123.6 113.95,123.6 113.77,123.78 113.77,125.53 113.91,125.67 115.73,125.67
GND on TOP (solid shape): 161.74,114.23 161.74,112.83 161.54,112.64 161.35,112.66 161.18,112.58 161.1,112.58 160.97,112.7 160.97,114.23 161.1,114.35 161.61,114.35
GND on TOP (solid shape): 172.32,142.7 172.32,141.36 172.14,141.18 171.38,141.18 171.33,141.24 171.36,141.41 171.29,141.58 171.29,142.69 171.36,142.76 172.27,142.76
GND on TOP (solid shape): 177.19,127.39 177.19,127.22 176.87,126.89 176.87,124.98 176.79,124.91 176.4,124.91 176.33,124.98 176.33,125.83 175.89,126.26 174.73,126.26 174.7,126.29 174.7,126.75 174.73,126.78 175.34,126.78 176.05,127.49 177.09,127.49
GND on TOP (solid shape): 179,46.62 179,46.26 179.2,46.06 179.2,45.24 179.18,45.22 178.29,45.22 178.26,45.24 178.26,46.03 178.19,46.11 177.68,46.11 177.55,46.24 177.55,46.44 177.68,46.57 178.14,46.57 178.49,46.92 178.7,46.92
GND on TOP (solid shape): 206.99,99.6 206.99,98.93 206.96,98.85 206.95,98.77 206.84,98.66 206.84,96.7 206.74,96.6 206.51,96.6 206.41,96.7 206.41,98.86 206.51,98.97 206.51,99.6 206.53,99.63 206.97,99.63
GND on TOP (solid shape): 209.3,77.02 209.3,76.38 209.78,75.9 210.86,75.9 210.86,75.86 210.88,75.83 210.88,75.34 210.85,75.32 209.4,75.32 208.74,75.98 208.74,76.99 208.92,77.17 209.15,77.17
GND on TOP (solid shape): 234.95,14.83 240.75,14.83 240.85,14.73 240.85,13.86 240.85,13.86 240.85,13.63 242.46,12.03 242.46,7.35 241.97,6.86 231.48,6.86 231.25,7.09 231.25,9.77 232.04,10.56 232.04,14.81 232.81,15.57 234.21,15.57
GND on TOP (solid shape): 258.07,73.54 258.07,72.45 257.84,72.22 256.57,72.22 256.48,72.26 256.39,72.28 256.31,72.36 256.31,73.12 256.88,73.69 257.92,73.69
GND on TOP (solid shape): 280.12,95.68 280.12,91.52 279.89,91.29 278.75,91.29 278.21,91.83 278.21,93.05 277.98,93.28 277.07,93.28 276.87,93.48 276.87,94.37 277.09,94.6 278.49,94.6 278.75,94.85 279.68,95.79 280.02,95.79
GND on TOP (solid shape): 290.84,14.94 290.84,14.31 291.05,14.1 292.03,14.1 292.3,13.83 292.3,13.19 292.18,13.06 288.55,13.06 288.3,13.32 288.3,14.84 288.51,15.05 290.72,15.05
GND on TOP (solid shape): 1,31.2 1,30.77 1.68,30.08 1.68,29.57 1.35,29.24 1.35,28.12 1.76,27.72 1.76,24.67 1.73,24.65 1.33,24.65 0.87,24.19 0.54,24.19 0.51,24.21 0.51,31.22 0.57,31.27 0.92,31.27
GND on TOP (solid shape): 67.42,157.59 67.42,147.76 66.76,147.1 66.76,146.13 66.4,145.78 64.5,145.78 64.24,146.03 64.24,150.86 63.86,151.24 61.83,151.24 61.45,151.62 61.45,157.59 61.83,157.97 67.04,157.97
GND on TOP (solid shape): 87.74,178.32 87.74,177.78 88.93,176.59 89.72,176.59 89.9,176.41 89.9,175.09 89.72,174.91 86.54,174.91 85.2,176.26 85.2,178.04 85.53,178.37 87.69,178.37
GND on TOP (solid shape): 94.8,102.9 94.8,102.12 94.68,101.99 94.53,101.98 94.4,101.91 94.24,101.91 94.14,102.01 93.25,102.01 93.2,102.06 93.2,102.85 93.4,103.05 94.65,103.05
GND on TOP (solid shape): 104.86,127.78 104.86,127.39 104.91,127.34 105.08,127.34 105.19,127.22 105.19,126.25 105.12,126.18 104.94,126.18 104.86,126.1 104.86,125.76 104.82,125.72 104.57,125.72 104.52,125.77 104.52,127.78 104.58,127.84 104.8,127.84
GND on TOP (solid shape): 160.86,126.01 160.86,124.81 160.82,124.77 160.36,124.77 160.32,124.81 160.32,125.77 160.32,125.82 160.17,125.96 159.45,125.96 159.41,126.01 159.41,126.35 159.46,126.4 160.22,126.4 160.25,126.42 160.46,126.42
GND on TOP (solid shape): 162.24,142.83 162.24,141.56 162.34,141.46 162.69,141.46 163.2,140.95 163.2,140.22 163.1,140.11 162.82,140.11 162.77,140.16 162.77,140.8 162.54,141.03 161.7,141.03 161.55,141.18 161.55,142.81 161.6,142.86 162.21,142.86
GND on TOP (solid shape): 162.87,46.64 162.87,46.46 162.74,46.34 162.13,46.34 162.08,46.29 162.08,45.73 161.83,45.47 161.83,45.04 161.8,45.02 161.25,45.02 161.22,45.04 161.22,45.47 160.84,45.85 160.84,46.67 160.94,46.77 162.74,46.77
GND on TOP (solid shape): 175.85,46.49 175.85,46.41 175.84,46.34 175.85,46.27 175.85,44.99 175.83,44.97 175.27,44.97 175.24,44.99 175.24,46.11 175.19,46.16 174.68,46.16 174.5,46.34 174.5,46.54 174.66,46.69 175.65,46.69
GND on TOP (solid shape): 194.59,88.5 194.59,88.43 194.6,88.42 194.6,87.59 194.9,87.28 194.9,87.03 194.77,86.9 193.76,86.9 193.58,87.08 193.58,87.87 193.66,87.94 193.66,88.52 193.72,88.59 194.51,88.59
GND on TOP (solid shape): 205.9,76.28 205.9,75.7 206,75.6 206,74.2 205.97,74.18 205.57,74.18 205.54,74.2 205.54,75.42 205.44,75.52 205.44,75.72 205.47,75.75 205.47,76.28 205.59,76.41 205.77,76.41
GND on TOP (solid shape): 241.69,21.12 241.69,20.56 241.15,20.02 241.15,15.98 241.03,15.86 240.52,15.86 240.39,15.98 240.39,20.17 239.86,20.71 239.86,21.12 239.9,21.17 241.41,21.17 241.64,21.17
GND on TOP (solid shape): 17.51,46.24 17.51,43.16 17.38,43.03 16.24,43.03 16.11,43.16 16.11,45.55 15.45,46.21 14.53,46.21 14.38,46.36 13.09,46.36 12.99,46.26 11.94,46.26 11.84,46.36 11.84,47.33 12.06,47.54 16.2,47.54
GND on TOP (solid shape): 35.13,103.59 35.13,96.22 27.79,88.88 27.79,85.2 27.41,84.82 23.48,84.82 22.96,85.34 20.62,85.34 20.38,85.58 20.38,87.71 21.82,89.16 21.82,90.02 31.98,100.18 31.98,101.45 33.39,102.86 33.39,103.63 34.09,104.32 34.4,104.32
GND on TOP (solid shape): 100.17,127.72 100.17,127.42 100.25,127.34 100.33,127.34 100.42,127.24 100.42,126.34 100.1,126.02 100.1,125.83 100.05,125.78 99.88,125.78 99.8,125.86 99.8,127.8 99.81,127.81 100.08,127.81
GND on TOP (solid shape): 101.73,157.94 101.73,157.15 101.84,157.04 101.84,156.53 102.11,156.27 102.16,156.27 102.21,156.22 102.21,155.9 102.13,155.83 101.86,155.83 101.57,156.12 101.57,156.94 101.36,157.15 100.24,157.15 100.12,157.26 100.12,157.88 100.23,157.99 101.69,157.99
GND on TOP (solid shape): 102.47,127.7 102.47,127.39 102.53,127.33 102.69,127.33 102.76,127.26 102.76,126.24 102.69,126.17 102.51,126.17 102.45,126.11 102.45,125.81 102.38,125.74 102.17,125.74 102.14,125.77 102.14,127.78 102.18,127.82 102.36,127.82
GND on TOP (solid shape): 159.59,62.47 159.59,61.5 158.71,60.61 158.58,60.61 158.54,60.65 158.52,60.66 158.46,60.7 158.41,60.77 158.4,60.79 158.38,60.82 158.38,60.94 159.14,61.7 159.14,62.47 159.16,62.49 159.57,62.49
GND on TOP (solid shape): 167.27,62.72 167.54,62.72 167.72,62.54 167.72,61.98 167.8,61.91 168.69,61.91 168.71,61.88 168.71,61.32 168.69,61.3 167.44,61.3 167.19,61.55 167.19,61.83 167.14,61.88 166.6,61.88 166.58,61.91 166.58,62.8 166.6,62.82 167.16,62.82
GND on TOP (solid shape): 179.29,101.77 179.29,101 179.11,100.82 178.58,100.82 178.58,100.82 178.19,100.82 178.01,101 177.95,101.09 177.85,101.16 177.67,101.35 177.67,101.72 177.85,101.91 179.16,101.91
GND on TOP (solid shape): 186.62,57.41 187.79,57.41 187.81,57.39 187.81,56.5 187.79,56.47 186.62,56.47 186.49,56.34 186.16,56.34 186.01,56.5 186.01,57.44 186.19,57.61 186.42,57.61
GND on TOP (solid shape): 194.29,110.37 195.46,110.37 195.74,110.09 195.74,109.46 195.38,109.1 195.38,108.72 195.36,108.69 194.77,108.69 194.75,108.72 194.75,109.63 194.7,109.68 193.22,109.68 193.2,109.71 193.2,110.6 193.22,110.62 194.04,110.62
GND on TOP (solid shape): 199.52,75.27 199.52,75.06 199.37,74.91 199.37,74.63 199.55,74.45 199.55,73.57 199.49,73.51 198.67,73.51 198.61,73.57 198.61,74.45 198.81,74.66 198.81,75.11 199.12,75.42 199.37,75.42
GND on TOP (solid shape): 209.86,102.42 209.86,102.01 209.84,101.99 208.77,101.99 208.57,101.78 208.31,101.78 208.24,101.71 208.24,101.23 208.08,101.07 207.93,101.07 207.8,101.2 207.8,101.84 207.7,101.94 207.7,102.12 207.83,102.24 208.34,102.24 208.57,102.47 209.81,102.47
GND on TOP (solid shape): 137.27,76.92 140.27,76.92 140.45,76.74 140.45,76.56 140.44,76.56 140.44,76.39 140.29,76.23 139.17,76.23 138.92,75.98 138.92,75.5 138.58,75.17 135.79,75.17 135.69,75.28 135.69,75.49 135.68,75.49 135.68,76.73 135.87,76.92 137.27,76.92
GND on TOP (solid shape): 163.13,62.82 163.13,60.51 163.36,60.27 163.44,60.13 163.58,60.04 163.58,59.82 163.48,59.72 163.15,59.72 162.21,60.66 162.21,62.82 162.26,62.87 163.07,62.87
GND on TOP (solid shape): 179.33,63.02 179.33,62.59 179.64,62.29 179.64,60.33 179.1,59.8 178.9,59.8 178.82,59.87 178.82,60.11 178.9,60.18 178.95,60.28 179.18,60.51 179.18,61.68 178.72,62.14 178.72,63.02 178.75,63.05 179.3,63.05
GND on TOP (solid shape): 193.68,85 194.42,85 194.54,84.87 194.54,84.69 194.47,84.61 194.47,83.85 194.34,83.73 194.16,83.73 194.04,83.85 194.04,84.13 193.99,84.18 192.62,84.18 192.58,84.22 192.58,85.03 192.68,85.12 193.55,85.12
GND on TOP (solid shape): 195.61,39.88 195.61,39.04 195.4,38.83 195.4,34.91 195.98,34.33 195.98,34.02 195.45,33.49 194.17,33.49 194.05,33.61 194.05,34.96 194.58,35.49 194.58,38.33 194.32,38.59 194.32,39.88 194.42,39.97 195.51,39.97
GND on TOP (solid shape): 197.49,115.5 197.49,114.69 198,114.18 198,113.88 197.9,113.77 197.62,113.77 197.34,113.49 197.34,113.27 197.24,113.16 196.96,113.16 196.91,113.21 196.91,114.79 197.01,114.89 197.01,115.5 197.03,115.53 197.47,115.53
GND on TOP (solid shape): 294.43,98.93 294.43,98.75 294.32,98.64 294.2,98.64 294.08,98.52 294.08,97.78 294.27,97.59 294.27,96.89 294.19,96.81 293.38,96.81 292.74,97.45 289.74,97.45 289.15,98.03 289.15,98.75 289.19,98.79 292.62,98.79 292.87,99.04 294.32,99.04
GND on TOP (solid shape): 53.19,120.89 53.19,114.54 52.94,114.28 48.44,114.28 48.11,114.61 48.11,116.85 48.34,117.08 48.34,120.4 48.11,120.63 47.35,120.63 47.22,120.76 47.22,121.01 47.35,121.14 52.94,121.14
GND on TOP (solid shape): 144.47,166.45 144.47,164.24 144.3,164.07 143.9,164.07 143.62,164.35 143.62,165.24 143.4,165.46 142.14,165.46 142.01,165.59 142.01,165.85 142.13,165.97 142.4,165.97 142.61,165.76 142.61,165.72 142.61,165.71 143.44,165.71 143.71,165.99 143.71,166.45 143.88,166.61 144.31,166.61
GND on TOP (solid shape): 145.8,128.62 145.8,126.78 145.15,126.13 144.68,126.13 144.62,126.19 144.62,127.06 144.65,127.2 144.62,127.35 144.62,127.48 144.68,127.54 145.35,127.54 145.42,127.61 145.42,128.6 145.53,128.71 145.7,128.71
GND on TOP (solid shape): 149.28,98.87 149.28,98.82 149.29,98.77 149.32,98.71 149.32,98.63 149.34,98.61 149.34,97.9 149.32,97.87 148.91,97.87 148.72,98.06 148.72,98.49 148.64,98.57 148.12,98.57 148.05,98.64 148.05,98.86 148.25,99.06 149.09,99.06
GND on TOP (solid shape): 158.9,166.45 158.9,164.24 158.72,164.07 158.33,164.07 158.05,164.35 158.05,165.24 157.83,165.46 156.57,165.46 156.44,165.59 156.44,165.85 156.56,165.97 156.82,165.97 157.03,165.76 157.03,165.72 157.04,165.71 157.87,165.71 158.14,165.99 158.14,166.45 158.3,166.61 158.74,166.61
GND on TOP (solid shape): 171.85,166.45 171.85,164.24 171.68,164.07 171.28,164.07 171,164.35 171,165.24 170.78,165.46 169.52,165.46 169.39,165.59 169.39,165.85 169.51,165.97 169.78,165.97 169.99,165.76 169.99,165.72 169.99,165.71 170.82,165.71 171.09,165.99 171.09,166.45 171.26,166.61 171.69,166.61
GND on TOP (solid shape): 182.86,192.13 182.86,189.34 182.48,188.96 159.11,188.96 158.48,189.59 143.62,189.59 142.35,188.32 142.35,188.32 141.79,187.76 141.79,182.68 141.33,182.23 129.63,182.23 129.63,183.71 129.92,184 139.93,184 140.06,184.13 140.06,192.01 140.44,192.39 182.61,192.39
GND on TOP (solid shape): 183.91,165.69 183.91,163.48 183.74,163.3 183.35,163.3 183.07,163.59 183.07,164.47 182.85,164.69 181.59,164.69 181.45,164.83 181.45,165.08 181.58,165.21 181.84,165.21 182.05,164.99 182.05,164.96 182.06,164.95 182.88,164.95 183.16,165.23 183.16,165.69 183.32,165.85 183.76,165.85
GND on TOP (solid shape): 191.77,158.07 191.77,153.25 191.3,152.78 191.3,146.16 189.12,143.98 181.19,143.98 180.39,144.79 180.39,151.47 180.42,151.5 180.42,154.12 180.52,154.22 185.62,154.22 185.79,154.39 185.79,158.26 186.05,158.52 191.32,158.52
GND on TOP (solid shape): 207.5,96.25 207.5,95.54 207.63,95.41 207.63,94.09 207.8,93.91 207.8,93.07 207.73,93 205.59,93 205.57,93.02 205.57,94.62 205.85,94.9 206.15,94.9 206.25,94.8 206.81,94.8 207.02,95 207.02,95.51 207.07,95.56 207.07,96.25 207.19,96.37 207.37,96.37
GND on TOP (solid shape): 219.51,72.86 219.51,70.85 219.82,70.54 219.82,69.83 218.8,68.82 218.8,66.78 218.67,66.66 218.17,66.66 218.07,66.76 218.07,71.27 218.64,71.85 218.64,72.86 218.77,72.99 219.38,72.99
GND on TOP (solid shape): 280.9,19.79 280.9,14.59 280.37,14.05 274.55,14.05 274.06,14.55 274.06,16.39 273.87,16.59 272.7,16.59 272.44,16.85 272.44,19.36 272.75,19.67 278.11,19.67 278.49,19.29 278.49,17.63 278.87,17.25 280.02,17.25 280.27,17.51 280.27,19.79 280.4,19.92 280.78,19.92
GND on TOP (solid shape): 289.9,45.9 289.9,45.5 290.05,45.35 290.05,45.35 289.94,45.23 289.75,45.23 289.69,45.3 289.23,45.3 289.11,45.41 289.11,45.42 288.97,45.42 288.94,45.45 288.78,45.45 288.65,45.57 288.65,45.75 288.66,45.75 288.66,45.84 288.79,45.98 289.82,45.98
GND on TOP (solid shape): 308.48,14.38 308.48,13.39 308.28,13.19 300.73,13.19 300.61,13.31 300.61,14.04 300.43,14.22 299.9,14.22 299.8,14.31 299.8,14.88 299.89,14.97 307.89,14.97
GND on TOP (solid shape): 149.04,127.92 149.04,127.79 148.95,127.7 148.78,127.5 148.81,127.24 148.81,125.57 148.68,125.44 148.39,125.44 148.25,125.57 148.25,127.57 148.72,128.04 148.93,128.04
GND on TOP (solid shape): 74,55.38 74,54.74 73.73,54.47 73.7,54.48 73.64,54.49 73.58,54.49 73.52,54.49 73.46,54.48 73.42,54.47 73.38,54.45 72.84,54.45 72.79,54.5 72.79,54.98 72.83,55.03 72.95,55.03 73.4,55.47 73.9,55.47
GND on TOP (solid shape): 94.15,181.26 94.15,180.86 94.28,180.74 95.29,180.74 95.41,180.86 96.32,180.86 96.72,180.46 96.72,180.22 96.65,180.14 96.12,180.14 96.03,180.22 95.57,180.22 95.43,180.37 94.3,180.37 94.15,180.22 94.15,179.27 94.02,179.14 92.03,179.14 91.96,179.21 91.96,181.18 92.12,181.35 94.06,181.35
GND on TOP (solid shape): 148.74,142.64 148.74,141.51 148.87,141.38 149.31,141.38 149.43,141.26 149.43,141.05 149.31,140.93 148.65,140.93 148.57,140.85 148.57,140.34 148.42,140.19 148.24,140.19 148.11,140.32 148.11,140.93 148.01,141.03 148.01,141.48 147.84,141.66 147.84,142.59 147.95,142.7 148.67,142.7
GND on TOP (solid shape): 157.74,48.32 157.74,48.09 157.64,47.99 157.08,47.99 156.67,47.58 156.67,46.41 156.8,46.29 156.8,46.11 156.22,45.52 156.22,44.89 156.19,44.86 155.3,44.86 155.28,44.89 155.28,46.51 154.74,47.05 154.74,47.96 154.77,47.99 156.17,47.99 156.24,48.06 156.39,48.06 156.78,48.44 157.61,48.44
GND on TOP (solid shape): 187.26,50.78 187.26,50.35 187.23,50.32 186.59,50.32 186.54,50.27 186.54,49.61 186.42,49.49 186.21,49.49 186.11,49.59 185.48,49.59 185.35,49.71 185.35,49.89 185.48,50.02 186.01,50.02 186.06,50.07 186.06,50.55 186.32,50.81 187.23,50.81
GND on TOP (solid shape): 90.23,168.12 90.23,165.11 90.44,164.9 90.44,161.46 90.48,161.42 90.48,160.26 89.89,159.66 89.89,158.84 91.4,157.33 91.4,155.61 91.34,155.56 90.07,155.56 89.69,155.93 88.19,155.93 87.96,156.16 87.96,163.87 88.32,164.22 88.32,168.23 88.61,168.52 89.84,168.52
GND on TOP (solid shape): 108.21,54.95 108.21,53.89 108.13,53.81 107.57,53.81 107.52,53.76 107.52,51.84 107.65,51.71 107.65,50.37 107.43,50.15 107.13,50.15 107.02,50.26 107.02,51.33 107.23,51.53 107.23,53.93 107.63,54.33 107.63,54.86 107.78,55.01 108.16,55.01
GND on TOP (solid shape): 143.2,129.94 143.2,129.73 143.13,129.67 142.52,129.67 142.43,129.58 142.43,128.45 142.31,128.33 142.18,128.33 141.54,127.69 141.4,127.69 141.29,127.81 141.29,128.41 141.08,128.62 140.55,128.62 140.53,128.64 140.53,129.06 140.55,129.07 141.27,129.07 141.7,128.64 142.12,129.05 142.12,129.83 142.28,130 143.14,130
GND on TOP (solid shape): 177.97,86.99 179.64,86.99 179.71,86.92 179.71,86.5 179.55,86.35 178.24,86.35 178.15,86.44 178.01,86.66 177.75,86.71 177.58,86.71 177.51,86.77 177.51,87.06 177.6,87.15 177.81,87.15
GND on TOP (solid shape): 238.21,25.36 238.21,25.03 238.06,24.87 237.62,24.87 237.57,24.82 237.57,24.65 237.62,24.59 238.08,24.59 238.08,24.14 237.62,24.14 237.57,24.09 237.57,23.81 237.62,23.76 238.13,23.76 238.16,23.73 238.16,23.22 238.11,23.17 237.42,23.17 236.96,23.63 236.96,25.38 237.09,25.51 238.06,25.51
GND on TOP (solid shape): 110.69,117.2 110.79,117.19 110.89,117.2 111,117.2 111.03,117.18 111.03,116.47 111.18,116.31 111.44,116.31 111.56,116.19 112.2,116.19 112.33,116.06 112.33,115.88 112.21,115.76 111.57,115.76 111.54,115.73 111.28,115.73 111.11,115.55 110.6,115.55 110.55,115.6 110.55,117.18 110.57,117.2
GND on TOP (solid shape): 122.68,59.7 122.68,58.64 122.94,58.38 124.27,58.38 124.67,58.78 125.79,58.78 126.1,58.47 126.1,55.96 126.1,55.94 125.91,55.76 125.91,55.18 126.1,55 126.1,54.82 126.1,52.04 125.53,51.48 124.05,51.48 123.87,51.66 123.87,56.86 122.49,58.24 122.49,59.71 122.5,59.72 122.66,59.72
GND on TOP (solid shape): 150.67,81.39 150.67,79.7 150.6,79.64 150.07,79.64 150.02,79.69 150.02,79.76 149.98,80.11 149.66,80.25 149.62,80.3 149.62,80.98 150.08,81.44 150.62,81.44
GND on TOP (solid shape): 159.06,54.16 159.06,53.52 159.34,53.25 159.75,53.25 159.8,53.19 159.8,52.08 159.62,51.9 159.37,51.9 159.16,52.1 159.16,52.18 159.14,52.24 159.14,52.79 158.71,53.22 158.07,53.22 157.97,53.32 157.97,53.55 158.05,53.63 158.55,53.63 158.6,53.68 158.6,54.16 158.73,54.29 158.93,54.29
GND on TOP (solid shape): 205.47,106.97 206.76,106.97 206.79,106.94 206.79,105.72 206.86,105.65 206.86,105.34 206.74,105.21 206.15,105.21 206.03,105.09 206.03,104.73 205.87,104.58 205.72,104.58 205.57,104.73 205.57,105.06 205.37,105.26 204.88,105.26 204.78,105.37 204.78,105.42 204.52,105.67 204.52,105.95 204.5,105.98 204.5,106.99 204.53,107.02 205.42,107.02
GND on TOP (solid shape): 297.32,86.32 297.32,85.36 297.37,85.3 298.43,85.3 298.61,85.13 298.61,82.21 298.5,82.11 296.97,82.11 296.89,82.02 296.89,81.1 296.85,81.06 296.76,81.06 296.71,81.1 296.71,82.01 296.61,82.11 295.49,82.11 295.4,82.21 295.4,85.25 295.49,85.34 296.9,85.34 297.11,85.55 297.11,86.3 297.15,86.35 297.29,86.35
GND on TOP (solid shape): 28.84,39.58 28.84,37.22 27.43,35.81 26.97,35.81 26.48,35.31 26.04,35.31 25.99,35.36 25.99,36.33 26.07,36.41 26.19,36.41 26.55,36.76 26.55,37.19 26.68,37.32 27.01,37.32 27.16,37.47 27.16,39.73 27.29,39.86 28.56,39.86
GND on TOP (solid shape): 89.82,5.74 89.82,5.56 89.81,5.55 89.03,5.55 88.7,5.22 88.7,1.58 88.29,1.18 83.37,1.18 83.29,1.25 83.29,3.92 83.67,4.3 83.67,5.06 83.8,5.19 87.1,5.19 87.36,5.44 88.11,5.44 88.42,5.75 89.81,5.75
GND on TOP (solid shape): 102.81,124.49 102.81,121.85 102.89,121.78 102.89,116.57 102.76,116.44 102.17,116.44 101.28,115.55 101.28,112.14 101.18,112.05 100.02,112.05 99.92,112.15 99.92,116.23 100.26,116.57 100.26,123.51 100.26,123.51 100.26,124.48 100.35,124.57 102.74,124.57
GND on TOP (solid shape): 175.04,63 175.04,61.25 175.06,61.22 175.06,60.51 174.96,60.41 174.66,60.41 174.3,60.05 174.3,59.52 174.28,59.49 173.62,59.49 173.29,59.16 173.29,58.91 173.13,58.76 172.88,58.76 172.73,58.91 172.73,59.16 173.46,59.9 173.46,60.41 174.45,61.4 174.45,63 174.48,63.02 175.01,63.02
GND on TOP (solid shape): 194.98,123.65 194.98,123.32 195.33,122.97 195.33,121.95 195.15,121.77 194.7,121.77 194.16,121.24 193.15,121.24 193.12,121.27 193.12,121.67 193.17,121.72 193.78,121.72 194.42,122.36 194.42,123.34 194.47,123.51 194.43,123.69 194.54,123.81 194.82,123.81
GND on TOP (solid shape): 225.28,31.35 225.28,29.85 225.1,29.67 223.1,29.67 222.49,29.06 222.49,28.07 222.44,28.02 221.87,28.02 221.81,28.07 221.81,29.07 221.57,29.32 221.57,29.55 221.82,29.8 221.82,30.31 222.23,30.31 222.23,29.83 222.26,29.8 222.38,29.8 222.41,29.83 222.41,31.4 223.25,32.24 224.39,32.24
GND on TOP (solid shape): 309.53,64.78 309.53,63.34 309.41,63.23 309.05,63.23 308.9,63.38 308.9,63.77 308.74,63.93 307.92,63.93 307.88,63.88 305.62,63.88 305.47,64.03 304.95,64.03 304.81,64.17 304.81,64.49 304.91,64.6 307.07,64.6 307.15,64.68 307.27,64.68 307.6,65.01 309.3,65.01
GND on TOP (solid shape): 212.88,50.56 213.1,50.2 213.52,50.17 214.03,50.17 214.15,50.04 214.15,48.62 214.08,48.55 212.78,48.55 212.66,48.67 212.66,50.05 212.4,50.3 212.4,50.53 212.5,50.63 212.81,50.63
GND on TOP (solid shape): 309.53,117.81 309.53,117.41 309.29,117.16 309.29,115.59 308.87,115.17 308.87,114.05 308.82,114 308.39,114 308.26,114.13 308.26,115.15 307.78,115.63 307.78,117.48 307.94,117.64 308.27,117.64 308.5,117.89 309.45,117.89
GND on TOP (solid shape): 109.29,160.45 109.29,156.54 108.43,155.68 105.27,155.68 104.66,155.06 104.66,154.5 104.11,153.95 102.05,153.95 101.95,154.06 101.95,154.45 101.82,154.58 101.82,155.43 102.06,155.67 102.36,155.67 102.72,156.04 102.72,159.06 102.75,159.24 102.72,159.42 102.72,160.5 103.64,161.43 108.31,161.43
GND on TOP (solid shape): 160.33,58.73 160.99,58.73 161.02,58.71 161.02,58.27 160.99,58.25 160.1,58.25 159.62,57.77 159.32,57.77 159.21,57.87 159.21,58.22 159.31,58.32 159.34,58.32 159.67,58.35 159.81,58.64 160.03,58.86 160.2,58.86
GND on TOP (solid shape): 183.76,139.04 183.76,138.84 183.98,138.62 184.28,138.62 184.38,138.52 184.38,138.2 184.32,138.14 184.04,138.14 183.85,138.33 183.76,138.56 183.52,138.66 183.43,138.75 182.78,138.75 182.67,138.86 182.02,138.86 181.98,138.9 181.98,139.25 182.02,139.28 183.52,139.28
GND on TOP (solid shape): 186.49,60.69 186.49,60.36 186.65,60.21 187.23,60.21 187.26,60.18 187.26,59.77 187.23,59.75 186.72,59.75 186.7,59.72 186.7,59.27 186.72,59.24 187.2,59.24 187.23,59.21 187.23,58.81 187.2,58.78 186.59,58.78 186.54,58.73 186.21,58.73 186.06,58.88 186.06,60.28 186.04,60.31 185.43,60.31 185.3,60.43 185.3,60.64 185.48,60.81 186.37,60.81
GND on TOP (solid shape): 206.46,113.47 206.46,112.66 206.33,112.53 206.08,112.53 205.91,112.69 205.9,112.82 205.85,112.94 205.82,112.97 205.78,113 205.72,113.06 205.65,113.06 205.58,113.07 205.52,113.06 205.31,113.06 205.29,113.09 205.29,113.49 205.31,113.52 206.05,113.52 206.15,113.62 206.31,113.62
GND on TOP (solid shape): 217.1,98.74 217.1,94.29 216.64,93.83 213.27,93.83 212.73,94.37 212.73,97.12 213.1,97.49 214.23,97.49 214.61,97.57 214.73,97.94 215.73,98.94 216.9,98.94
GND on TOP (solid shape): 53.32,177.27 53.32,168.26 53.83,167.75 54.84,167.75 54.97,167.62 54.97,166.48 54.84,166.35 54.21,166.35 53.45,167.11 52.81,167.11 52.43,166.73 51.67,166.73 51.54,166.86 51.54,170.14 51.39,170.29 50.65,170.29 50.04,170.9 50.04,171.79 49,172.83 48.49,172.83 48.37,172.96 48.37,173.59 48.51,173.73 50.39,173.73 50.76,174.1 50.76,177.25 51.03,177.53 53.07,177.53
GND on TOP (solid shape): 229.75,16.34 229.75,15.27 231.25,13.77 231.25,10.73 231.17,10.65 228.38,10.65 228.3,10.73 228.3,14.24 227.58,14.96 223.47,14.96 223.45,14.98 223.45,15.19 223.48,15.21 225.71,15.21 225.98,15.48 225.98,17.72 226.08,17.83 228.26,17.83
GND on TOP (solid shape): 84,127.83 84.07,127.8 84.1,127.73 84.1,127.69 84.11,127.64 84.11,125.88 84.1,125.81 84.1,125.74 84.1,125.72 84.1,125.62 84.05,125.57 83.78,125.57 83.74,125.61 83.74,126.08 83.44,126.38 83.44,127.23 83.6,127.39 83.74,127.39 83.74,127.83
GND on TOP (solid shape): 88.83,127.79 88.82,127.76 88.83,127.65 88.88,127.54 88.88,125.98 88.83,125.83 88.84,125.68 88.85,125.65 88.74,125.54 88.57,125.54 88.43,125.67 88.43,126.04 88.41,126.07 88.28,126.07 88.23,126.12 88.23,127.16 88.43,127.36 88.43,127.79 88.49,127.84 88.77,127.84
GND on TOP (solid shape): 66.4,16.27 66.4,15.88 66.35,15.83 65.92,15.83 65.87,15.78 65.87,15.5 65.92,15.45 66.34,15.45 66.38,15.41 66.38,15.04 66.33,14.99 65.97,14.99 65.92,14.94 65.92,14.84 66.4,14.36 66.4,12.71 66.45,12.66 66.45,11.61 66.22,11.39 65.18,11.39 64.99,11.58 64.99,12.33 64.32,13 64.32,16.16 64.48,16.31 66.35,16.31
GND on TOP (solid shape): 183.04,56.12 183.04,55.81 182.91,55.69 182.58,55.61 182.49,55.29 182.28,55.07 181.31,55.07 181.29,55.1 181.29,55.51 181.31,55.53 182,55.53 182.07,55.61 182.25,55.61 182.51,55.86 182.51,56.12 182.63,56.24 182.91,56.24
GND on TOP (solid shape): 307.84,47.53 307.84,46.2 307.19,45.55 299.96,45.55 299.93,45.57 299.39,45.57 299.38,45.56 299.37,45.56 299.28,45.5 299.22,45.41 299.22,45.4 299.19,45.37 299.19,45.32 298.94,45.32 298.94,45.96 299.7,46.72 300.26,46.72 301.86,46.72 302.49,47.35 302.49,47.68 302.65,47.84 307.53,47.84
GND on TOP (solid shape): 80.43,112.69 80.43,111.92 80.22,111.72 78.72,111.72 78.62,111.82 78.62,112.33 78.72,112.43 79.18,112.43 79.62,112.18 79.86,112.62 80.02,112.77 80.34,112.77
GND on TOP (solid shape): 85.97,127.77 85.97,127.39 86.28,127.39 86.28,126.04 85.97,126.04 85.97,125.73 85.86,125.62 85.63,125.62 85.58,125.67 85.59,125.7 85.59,125.85 85.53,125.99 85.53,127.53 85.59,127.64 85.6,127.76 85.63,127.84 85.7,127.87 85.88,127.87
GND on TOP (solid shape): 123.98,18.9 123.98,17.66 123.93,17.61 123.76,17.61 123.73,17.64 123.73,18.36 123.69,18.4 123.52,18.4 123.48,18.36 123.48,17.64 123.44,17.6 123.28,17.6 123.23,17.66 123.23,18.4 123.2,18.43 123.03,18.43 122.98,18.38 122.98,17.66 122.93,17.61 122.76,17.61 122.73,17.64 122.73,18.36 122.69,18.4 122.52,18.4 122.48,18.36 122.48,17.64 122.44,17.6 122.28,17.6 122.23,17.66 122.23,18.88 122.36,19.01 123.87,19.01
GND on TOP (solid shape): 127.12,18.92 127.12,17.69 127.06,17.63 126.9,17.63 126.86,17.67 126.86,18.39 126.83,18.42 126.65,18.42 126.62,18.39 126.62,17.67 126.58,17.63 126.42,17.63 126.36,17.68 126.36,18.43 126.33,18.46 126.17,18.46 126.12,18.41 126.12,17.69 126.06,17.63 125.9,17.63 125.86,17.67 125.86,18.39 125.83,18.42 125.65,18.42 125.62,18.39 125.62,17.67 125.58,17.63 125.42,17.63 125.36,17.68 125.36,18.91 125.49,19.04 127,19.04
GND on TOP (solid shape): 129.9,18.94 129.9,17.7 129.85,17.65 129.69,17.65 129.65,17.68 129.65,18.4 129.61,18.44 129.44,18.44 129.4,18.4 129.4,17.68 129.37,17.64 129.2,17.64 129.15,17.7 129.15,18.45 129.12,18.48 128.96,18.48 128.91,18.42 128.91,17.7 128.85,17.65 128.69,17.65 128.65,17.68 128.65,18.4 128.61,18.44 128.44,18.44 128.4,18.4 128.4,17.68 128.37,17.64 128.2,17.64 128.15,17.7 128.15,18.92 128.28,19.05 129.79,19.05
GND on TOP (solid shape): 136,18.93 136,17.7 135.95,17.64 135.78,17.64 135.74,17.68 135.74,18.4 135.71,18.43 135.54,18.43 135.5,18.4 135.5,17.68 135.46,17.64 135.3,17.64 135.24,17.69 135.24,18.44 135.22,18.47 135.05,18.47 135,18.42 135,17.7 134.95,17.64 134.78,17.64 134.74,17.68 134.74,18.4 134.71,18.43 134.54,18.43 134.5,18.4 134.5,17.68 134.46,17.64 134.3,17.64 134.24,17.69 134.24,18.92 134.38,19.05 135.88,19.05
GND on TOP (solid shape): 163.61,52.2 163.61,51.85 163.53,51.77 163.17,51.73 163.06,51.39 162.96,51.29 162.87,51.29 162.79,51.21 161.88,51.21 161.86,51.24 161.86,51.67 161.88,51.7 162.82,51.7 163.18,52.05 163.18,52.23 163.28,52.33 163.48,52.33
GND on TOP (solid shape): 32.48,30.33 32.48,29.81 32.51,29.74 32.49,29.67 32.4,29.35 32.59,29.08 32.62,29.07 32.62,26.36 32.4,26.14 31.22,26.14 31.1,26.27 31.1,27.41 31.86,28.18 31.86,30.33 31.98,30.46 32.35,30.46
