# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_D<49>: length 40.6
  IN4 w0.075: 176.66,48.55 177.28,48.55
  IN4 w0.102: 167.83,79.2 167.83,77.04 167.78,76.99
  IN4 w0.127: v5(167.25,81.3) 167.25,81.29 167.27,81.27 167.27,81.25 167.7,80.83 167.7,79.33 167.83,79.2 ; 177.28,48.55 v5(177.61,48.22) ; 167.78,76.99 167.68,76.89 167.68,75.42 168.9,74.2 168.9,72.68 170.62,70.95 170.62,51.66 173.11,49.18 175.36,49.18 175.58,48.96 175.58,48.78 175.77,48.6 176.61,48.6 176.66,48.55
  BOTTOM w0.17: v5(177.61,48.22) 177.64,48.25 177.67,48.28 U7901.V12
  BOTTOM w0.184: U7000.V8 167.25,81.25 v5(167.25,81.3)
FBD_D<50>: length 42.1
  IN4 w0.075: U7901.U11 178.59,48 178.44,47.86
  IN4 w0.102: v5(167.25,79.2) 167.25,79.2 167.59,78.86 167.59,77.39 167.49,77.29
  IN4 w0.127: 178.44,47.86 175.78,47.86 175.39,48.25 172.9,48.25 169.96,51.19 169.96,70.96 167.17,73.74 167.17,76.97 167.49,77.29 ; U7901.U11 v5(178.91,49.52)
  BOTTOM w0.17: U7901.U11 v5(178.91,49.52)
  BOTTOM w0.184: v5(167.25,79.2) 167.25,79.25 U7000.V6
FBD_D<51>: length 41.2
  IN4 w0.075: U7901.U12 177.94,49.69 177.78,49.85 176.76,49.85
  IN4 w0.102: 168.13,79.42 168.13,76.2
  IN4 w0.127: v5(167.24,81.99) 168.13,81.1 168.13,79.42 ; 176.76,49.85 176.7,49.91 176.15,49.91 175.96,49.73 175.61,49.73 175.41,49.93 173.5,49.93 171.24,52.19 171.24,71.01 169.71,72.53 169.71,74.62 168.13,76.2 ; U7901.U12 v5(178.26,48.87)
  BOTTOM w0.17: U7901.U12 v5(178.26,48.87)
  BOTTOM w0.184: U7000.V9 167.24,81.96 v5(167.24,81.99)
FBD_D<52>: length 35.5
  IN4 w0.075: 176.66,50.5 178.59,50.5
  IN4 w0.102: 168.45,76.78 168.45,77.64 v5(168.62,77.81)
  IN4 w0.127: 176.66,50.5 176.59,50.43 176.1,50.43 175.77,50.76 174.15,50.76 171.89,53.02 171.89,71.19 170.48,72.6 170.48,74.75 168.45,76.78 ; 178.59,50.5 v5(178.91,50.82)
  BOTTOM w0.17: v5(178.91,50.82) U7901.P11
  BOTTOM w0.184: U7000.U4 168.59,77.81 v5(168.62,77.81)
FBD_D<53>: length 33.7
  IN4 w0.075: v5(177.61,50.82) 177.29,51.15 176.77,51.15
  IN4 w0.127: v5(169.34,78.51) 169.55,78.3 169.55,76.48 171.22,74.81 171.22,72.54 172.37,71.39 172.37,53.24 174.26,51.35 175.49,51.35 175.6,51.24 176.68,51.24 176.77,51.15
  BOTTOM w0.17: v5(177.61,50.82) U7901.P12
  BOTTOM w0.184: U7000.R5 169.34,78.54 v5(169.34,78.51)
FBD_D<54>: length 34.8
  IN4 w0.075: 176.74,51.8 178.59,51.8
  IN4 w0.127: 176.74,51.8 176.7,51.76 176.17,51.76 175.59,52.35 174.41,52.35 173.53,53.23 173.53,70.97 171.86,72.64 171.86,75.02 169.93,76.95 169.93,78.62 v5(169.33,79.23) ; 178.59,51.8 v5(178.91,52.12)
  BOTTOM w0.17: v5(178.91,52.12) U7901.N11
  BOTTOM w0.184: v5(169.33,79.23) U7000.R6
FBD_D<55>: length 35.1
  IN4 w0.102: 169.51,80.94 168.9,80.94 v5(168.55,81.3)
  IN4 w0.127: v5(177.61,52.12) 176.73,53 175.19,53 174.17,54.02 174.17,71.08 172.62,72.63 172.62,75.01 170.33,77.31 170.33,79.4 170.03,79.7 170.03,80.42 169.51,80.94
  BOTTOM w0.17: U7901.N12 177.94,51.8 v5(177.61,52.12)
  BOTTOM w0.184: v5(168.55,81.3) 168.55,81.25 U7000.U8
FBD_D<56>: length 40.1
  IN1 w0.075: 183.14,50.35 183.14,49.97 183.26,49.85 183.62,49.85 183.79,49.68 183.79,49.39 183.79,49.39 183.79,48.71 183.62,48.55 183.28,48.55
  IN1 w0.127: v5(170.67,79.88) 171.03,79.52 171.62,79.52 171.84,79.29 171.84,79.01 171.68,78.84 171.68,76.79 171.64,76.75 171.64,70.89 176.84,65.69 176.84,63.69 179.41,61.12 179.41,55.69 179.2,55.48 179.2,55.05 180.94,53.31 180.94,51.68 181.72,50.9 182.58,50.9 183.14,50.35 ; v5(182.81,48.22) 182.96,48.22 183.28,48.55
  BOTTOM w0.17: v5(182.81,48.22) U7901.V4
  BOTTOM w0.184: U7000.P6 170.67,79.87 v5(170.67,79.88)
FBD_D<57>: length 47.3
  IN1 w0.127: v5(184.11,48.22) 184.07,48.22 183.58,47.73 181.11,47.73 180.99,47.84 176.07,47.84 175.63,48.29 175.13,48.29 174.73,48.69 174.73,52.43 174.84,52.54 174.84,54.17 175.22,54.55 175.22,57.12 174.95,57.39 174.54,57.39 174.3,57.62 174.3,66.24 170.1,70.44 170.1,76.5 170.29,76.69 170.29,81.05 v5(169.34,81.99)
  BOTTOM w0.17: v5(184.11,48.22) U7901.V3
  BOTTOM w0.184: U7000.R9 169.34,81.96 v5(169.34,81.99)
FBD_D<58>: length 38.5
  IN1 w0.127: v5(181.36,48.91) 181.09,48.91 179.99,50.02 179.99,52.32 179.43,52.88 175.63,52.88 175.33,53.18 175.33,53.75 175.72,54.15 175.72,62.23 175.34,62.61 175.34,65.87 170.65,70.56 170.65,77.6 v5(170.76,77.71)
  BOTTOM w0.1: U7901.U4 182.81,48.87 181.67,48.87 181.63,48.91 v5(181.36,48.91)
  BOTTOM w0.184: U7000.P4 170.76,77.74 v5(170.76,77.71)
FBD_D<59>: length 37.8
  IN1 w0.075: 177.3,55.04 177.29,55.06 177.29,56.31
  IN1 w0.127: 177.29,56.31 177.37,56.4 177.37,56.94 177.19,57.13 177.19,58.17 177.44,58.42 177.44,62.04 176.23,63.26 176.23,65.64 171.17,70.7 171.17,76.76 171.39,76.98 171.39,77.84 v5(170.72,78.51) ; 177.3,55.04 177.33,55.01 177.71,54.63 178.97,54.63 180.47,53.12 180.47,51.02 181.79,49.71 181.79,49.34 182.06,49.07 183.26,49.07 v5(183.46,48.87)
  BOTTOM w0.17: v5(183.46,48.87) U7901.U3
  BOTTOM w0.184: v5(170.72,78.51) 170.69,78.51 U7000.P5
FBD_D<60>: length 35.4
  IN1 w0.127: v5(181.91,51.38) 181.41,51.87 181.41,53.51 180.05,54.87 180.05,61.34 177.43,63.96 177.43,65.77 172.22,70.98 172.22,76.44 172.09,76.57 172.09,79.93 v5(172.76,80.6)
  BOTTOM w0.1: v5(181.91,51.38) 182.01,51.47 182.81,51.47 U7901.P4
  BOTTOM w0.184: U7000.L7 172.76,80.56 v5(172.76,80.6)
FBD_D<61>: length 36
  IN1 w0.075: 183.11,51.15 183.73,51.15
  IN1 w0.127: v5(172.75,79.2) 172.35,78.8 172.35,76.88 172.81,76.42 172.81,71.05 178.08,65.78 178.08,64.31 180.6,61.8 180.6,54.99 181.97,53.61 181.97,52.92 182.43,52.46 182.43,51.83 183.11,51.15 ; 183.73,51.15 184.06,50.82 v5(184.76,50.82)
  BOTTOM w0.1: U7901.P3 184.11,50.82 v5(184.76,50.82)
  BOTTOM w0.184: v5(172.75,79.2) 172.75,79.25 U7000.L6
FBD_D<62>: length 30.9
  IN1 w0.127: v5(172.82,77.77) 172.69,77.65 172.69,77.14 173.34,76.5 173.34,71.19 178.79,65.73 178.79,64.74 181.18,62.36 181.18,55.07 182.45,53.8 182.45,53.12 182.81,52.76 v5(182.81,52.12)
  BOTTOM w0.17: v5(182.81,52.12) U7901.N4
  BOTTOM w0.184: U7000.L4 v5(172.82,77.77)
FBD_D<63>: length 32.4
  IN1 w0.127: v5(184.11,52.12) 184.11,52.2 182.99,53.32 182.99,53.98 181.77,55.2 181.77,63.42 174.29,70.9 174.29,77.6 173.76,78.13 173.12,78.13 172.75,78.5 v5(172.75,78.5)
  BOTTOM w0.17: v5(184.11,52.12) U7901.N3
  BOTTOM w0.184: v5(172.75,78.5) 172.75,78.55 U7000.L5
FBD_DBI<0>: length 20.3
  IN2 w0.127: v5(158.18,57.32) 158.43,57.57 158.43,59.31 158.98,59.86 158.98,61.38 159.73,62.12 159.73,71.74 v5(159.23,72.24)
  BOTTOM w0.102: v5(159.23,72.24) 159.75,72.75 159.75,75.95 U7000.AJ1
  BOTTOM w0.17: v5(158.18,57.32) U7900.R3
FBD_DBI<1>: length 22.4
  IN2 w0.075: 165,57.67 165,58.24 ; v5(164.03,57.32) U7900.R12 164.86,57
  IN2 w0.127: v5(161.94,74.47) 161.95,74.47 164.83,71.59 164.83,58.41 165,58.24 ; 165,57.67 165.12,57.55 165.12,57.26 164.86,57
  BOTTOM w0.102: v5(161.94,74.47) 161.64,74.47 161.25,74.86 U7000.AG1
  BOTTOM w0.17: U7900.R12 v5(164.03,57.32)
FBD_DBI<2>: length 37.2
  IN2 w0.075: 165.77,50.5 165,50.5
  IN2 w0.127: v5(165.11,80.58) 165.6,80.1 165.6,77.67 164.9,76.97 164.9,75.8 168.45,72.25 168.45,52.77 166.14,50.45 165.82,50.45 165.77,50.5 ; 165,50.5 v5(164.03,49.52)
  BOTTOM w0.1: v5(164.03,49.52) 164.03,50.17 164.35,50.5 U7900.E12
  BOTTOM w0.184: U7000.AA7 v5(165.11,80.58)
FBD_DBI<3>: length 37.2
  IN2 w0.075: 159.15,51.03 159.15,50.5 v5(158.83,50.17)
  IN2 w0.127: v5(162.99,78.48) 163.33,78.14 163.33,77.53 162.79,76.99 162.79,74.72 165.9,71.61 165.9,61.22 166.45,60.67 166.45,54.57 166.06,54.18 163.88,54.18 163.59,54.47 161.92,54.47 159.9,52.45 159.9,51.78 159.15,51.03
  BOTTOM w0.17: U7900.E3 158.51,50.5 v5(158.83,50.17)
  BOTTOM w0.184: v5(162.99,78.48) 162.99,78.49 U7000.AD5
FBD_DBI<4>: length 26.5
  IN2 w0.102: 178.03,78.13 178.53,78.13 178.74,77.92 178.74,77.53 178.75,77.52
  IN2 w0.114: 185.13,57.73 184.11,56.72 v5(184.11,56.67)
  IN2 w0.127: v5(177.68,77.78) 178.03,78.13 ; 178.75,77.52 178.75,75.22 185.13,68.84 185.13,57.73
  BOTTOM w0.17: U7901.E3 184.11,56.67 v5(184.11,56.67)
  BOTTOM w0.184: v5(177.68,77.78) 177.68,77.78 U7000.D3
FBD_DBI<5>: length 23.4
  IN2 w0.075: 179.13,57.65 178.59,57.65 178.26,57.32 v5(178.26,57.32)
  IN2 w0.127: 179.13,57.65 179.44,57.95 179.44,68.04 175.74,71.74 175.74,75.76 v5(175.36,76.14)
  BOTTOM w0.102: v5(175.36,76.14) 174.9,76.6 174.9,76.9 174.55,77.25 U7000.H3
  BOTTOM w0.17: v5(178.26,57.32) U7901.E12
FBD_DBI<6>: length 34.8
  IN2 w0.075: 176.59,50.45 176.63,50.5 U7901.R12 v5(178.26,50.17)
  IN2 w0.127: v5(168.57,78.51) 168.99,78.09 169.32,78.09 169.55,77.86 169.55,76.4 171.95,74 171.95,54.31 175.17,51.08 175.45,51.08 176.08,50.45 176.59,50.45
  BOTTOM w0.17: v5(178.26,50.17) U7901.R12
  BOTTOM w0.184: v5(168.57,78.51) 168.57,78.53 U7000.U5
FBD_DBI<7>: length 40.3
  IN2 w0.127: v5(171.41,81.99) 172.24,81.16 172.24,77.63 173.45,76.42 173.83,76.42 174.34,75.91 174.34,70.91 176.29,68.96 176.29,61.27 175.75,60.73 175.75,55.22 176.08,54.88 179.22,54.88 179.46,54.64 180.68,54.64 182.44,52.88 182.44,51.94 183.46,50.92 v5(183.46,50.82)
  BOTTOM w0.17: v5(183.46,50.82) U7901.R3
  BOTTOM w0.184: U7000.M9 v5(171.41,81.99)
FBD_EDC<0>: length 22.3
  IN2 w0.127: v5(159.15,71.15) 157.92,69.92 157.92,58.36 v5(157.53,57.97)
  BOTTOM w0.1: U7900.T3 158.18,57.97 v5(157.53,57.97)
  BOTTOM w0.102: 160.36,75.39 160.44,75.47 160.44,76.33 160.18,76.59 160.18,76.92 159.85,77.25 U7000.AJ3
  BOTTOM w0.17: v5(159.15,71.15) 159.52,71.15 ; 160.36,72.37 160.36,75.39
  BOTTOM w0.184: 159.52,71.15 159.54,71.15 160.36,71.97 160.36,72.37
FBD_EDC<1>: length 21.1
  IN2 w0.127: v5(161.95,73.45) 161.95,73.45 163.52,71.88 163.52,61.08 164.06,60.53 164.06,59.14 164.47,58.73 164.47,58.18 164.68,57.97 v5(164.68,57.97)
  BOTTOM w0.102: U7000.AG2 160.92,76.42 160.92,75.68 160.99,75.61
  BOTTOM w0.17: 160.99,75.61 160.99,74.2 161.74,73.45 v5(161.95,73.45) ; U7900.T12 164.68,57.97 v5(164.68,57.97)
FBD_EDC<2>: length 40
  IN2 w0.127: v5(165.33,50.17) 165.33,50.08 165.79,49.62 168.26,49.62 169.83,51.19 169.83,72.28 166,76.11 166,81.04 165.21,81.82 v5(164.92,81.82)
  BOTTOM w0.1: v5(165.33,50.17) 164.68,50.17 U7900.D12
  BOTTOM w0.184: v5(164.92,81.82) 165.27,81.82 U7000.AA9
FBD_EDC<3>: length 33.5
  IN2 w0.075: 157.87,49.83 157.86,49.84 157.33,49.84
  IN2 w0.127: 157.33,49.84 157.14,50.04 157.14,52.29 157.51,52.66 158.63,52.66 162.07,56.1 162.07,69.13 161.23,69.97 161.23,76.72 v5(162.32,77.81) ; 157.87,49.83 v5(158.18,49.52)
  BOTTOM w0.17: U7900.D3 v5(158.18,49.52)
  BOTTOM w0.184: U7000.AF4 162.23,77.87 162.26,77.87 v5(162.32,77.81)
FBD_EDC<4>: length 23
  IN2 w0.075: v5(184.11,57.97) 183.79,58.3 183.79,58.9 183.74,58.94
  IN2 w0.127: 183.74,58.94 183.74,67.1 177.65,73.19 177.65,76.45 v5(176.99,77.11)
  BOTTOM w0.17: v5(184.11,57.97) U7901.D3
  BOTTOM w0.184: v5(176.99,77.11) 176.95,77.15 U7000.E3
FBD_EDC<5>: length 20.8
  IN2 w0.127: v5(175.35,74.95) 174.94,74.54 174.94,71.66 177.61,68.99 v5(177.61,57.97)
  BOTTOM w0.102: U7000.H2 174.55,76.51 174.9,76.16 174.9,75.4 v5(175.35,74.95)
  BOTTOM w0.17: v5(177.61,57.97) U7901.D12
FBD_EDC<6>: length 36.9
  IN2 w0.075: 176.71,49.84 176.82,49.84 176.83,49.85 177.29,49.85 177.61,49.52 v5(177.61,49.52)
  IN2 w0.127: v5(168.56,79.89) 168.1,79.44 168.1,76.51 171.33,73.28 171.33,53.65 175.05,49.94 175.49,49.94 175.64,49.79 175.98,49.79 176.23,50.05 176.51,50.05 176.71,49.84
  BOTTOM w0.17: v5(177.61,49.52) 177.61,49.52 U7901.T12
  BOTTOM w0.184: v5(168.56,79.89) 168.56,79.86 U7000.U6
FBD_EDC<7>: length 38.5
  IN2 w0.075: 183.14,50.38 183.14,50 183.29,49.85 U7901.T3 v5(184.11,49.52)
  IN2 w0.127: v5(171.4,79.15) 171.81,78.74 171.81,76.79 173.29,75.31 173.29,71.03 175.07,69.24 175.07,61.65 175.28,61.43 175.28,55.02 175.81,54.49 179.12,54.49 181.49,52.12 181.49,51.26 181.96,50.8 182.72,50.8 183.14,50.38
  BOTTOM w0.17: v5(184.11,49.52) U7901.T3
  BOTTOM w0.184: v5(171.4,79.15) 171.7,78.85 U7000.M5
FBD_VREFC: length 17.8
  TOP w0.254: v2(169.2,53.09) 169.2,53.19 168.69,53.7 167.82,53.7 167.62,53.5 C7904.1 167.36,52.79 165.96,52.79 v5(165.33,53.42)
  TOP w0.35: v5(176.96,53.42) 176.13,52.59 174.81,52.59 v2(174.4,52.99)
  BOTTOM w0.15: v5(176.96,53.42) U7901.K13
  BOTTOM w0.2: U7900.K13 v5(165.33,53.42)
  BOTTOM w0.381: R7910.1 172.4,52.81
  BOTTOM w0.432: R7909.2 R7910.1 ; v2(169.2,53.09) 169.3,53.19 R7911.2 170.54,53.19 170.92,52.81 v1(171.51,52.81) C7903.1 174.22,52.81 v2(174.4,52.99)
FBD_VREFC_Q: length 2.2
  BOTTOM w0.381: Q7900.3 R7909.1
  BOTTOM w0.432: v1(170.39,49.89) 170.54,49.74 R7909.1
FBD_WCK01: length 26.3
  IN2 w0.114: v5(160.17,81.27) 160,81.1 159.76,81.1 159.35,80.69 159.35,76.38 160.3,75.44 160.39,75.34 160.39,69.01 160.54,68.86 160.54,58.52 159.68,57.66 159.68,57.52 v5(159.48,57.32)
  BOTTOM w0.122: U7900.T4 159.16,57.65 v5(159.48,57.32)
  BOTTOM w0.14: U7000.AJ8 v5(160.17,81.27)
FBD_WCK01*: length 26.3
  IN2 w0.114: v5(160.13,57.32) 159.98,57.32 159.9,57.4 159.9,57.57 160.76,58.43 160.76,68.95 160.61,69.1 160.61,75.43 159.57,76.47 159.57,80.6 159.85,80.88 160.07,80.88 160.15,80.8 v5(160.15,80.6)
  BOTTOM w0.122: v5(160.13,57.32) 159.81,57.65 U7900.T5
  BOTTOM w0.14: U7000.AJ7 159.85,80.5 159.95,80.6 v5(160.15,80.6)
FBD_WCK23: length 40.9
  IN2 w0.114: v5(159.48,49.52) 159.66,49.52 159.75,49.61 159.75,49.92 160.02,50.19 160.57,50.19 161.21,50.84 161.21,51.63 162.41,52.82 166.28,52.82 166.95,53.49 166.95,54.15 166.83,54.26 166.83,72.21 163.73,75.31 163.73,81.44 163.54,81.63 163.38,81.63 v5(163.05,81.3)
  BOTTOM w0.122: U7900.D4 v5(159.48,49.52)
  BOTTOM w0.14: U7000.AD8 163.05,81.25 v5(163.05,81.3)
FBD_WCK23*: length 41
  IN2 w0.114: v5(163.05,82) 163.2,81.85 163.63,81.85 163.95,81.53 163.95,75.4 167.05,72.3 167.05,54.35 167.16,54.24 167.16,53.4 166.37,52.6 162.5,52.6 161.43,51.54 161.43,50.75 160.66,49.98 160.11,49.98 159.96,49.83 159.96,49.69 v5(160.13,49.52)
  BOTTOM w0.122: U7900.D5 v5(160.13,49.52)
  BOTTOM w0.14: v5(163.05,82) 163.05,81.95 U7000.AD9
FBD_WCK45: length 29.4
  IN2 w0.075: 182.49,57 181.87,57 181.76,57.11
  IN2 w0.114: 182.49,57 v5(182.81,57.32) ; v5(173.55,79.9) 173.69,80.04 173.96,80.04 174.09,79.91 174.09,77.27 174.77,76.58 175.62,76.58 176.29,75.91 176.29,72.36 181,67.65 181,57.63 181.52,57.11 181.69,57.11 181.69,57.11 181.76,57.11
  BOTTOM w0.122: v5(182.81,57.32) U7901.D4
  BOTTOM w0.14: U7000.J6 173.55,79.85 v5(173.55,79.9)
FBD_WCK45*: length 29.6
  IN2 w0.114: v5(173.53,80.6) 173.53,80.3 173.58,80.26 174.05,80.26 174.3,80 174.3,77.36 174.86,76.8 175.71,76.8 176.51,76 176.51,72.45 181.22,67.74 181.22,57.72 181.61,57.32 v5(182.16,57.32)
  BOTTOM w0.122: v5(182.16,57.32) U7901.D5
  BOTTOM w0.14: U7000.J7 173.97,80.25 174.07,80.35 174.07,80.59 173.94,80.73 173.66,80.73 v5(173.53,80.6)
FBD_WCK67: length 44
  IN2 w0.114: v5(170.67,81.29) 170.21,81.29 170,81.08 170,77.05 172.49,74.57 172.49,70.38 173.62,69.25 173.62,54.36 173.68,54.3 174.73,53.25 175.48,52.5 179.82,52.5 180.27,52.05 180.27,48.94 180.87,48.34 181.81,48.34 182.67,49.2 182.67,49.38 v5(182.81,49.52)
  BOTTOM w0.14: U7000.P8 170.67,81.27 v5(170.67,81.29) ; v5(182.81,49.52) U7901.T4
FBD_WCK67*: length 43.9
  IN2 w0.114: v5(170.66,80.6) 170.66,80.86 170.6,80.93 170.52,80.93 170.37,81.07 170.3,81.07 170.22,80.99 170.22,77.14 172.7,74.66 172.7,70.47 173.83,69.33 173.83,54.45 174.89,53.4 175.57,52.72 179.91,52.72 180.49,52.14 180.49,49.03 180.96,48.56 181.72,48.56 182.45,49.29 182.45,49.38 182.31,49.52 v5(182.16,49.52)
  BOTTOM w0.122: v5(182.16,49.52) 182.31,49.52 182.49,49.69 U7901.T5
  BOTTOM w0.14: U7000.P7 170.28,80.25 170.21,80.32 170.21,80.5 170.31,80.6 v5(170.66,80.6)
FBD_ZQ_1_B: length 3.8
  TOP w0.432: v1(165.26,52.74) 165.26,52.19 v5(165.33,52.12) 165.42,52.12 165.94,51.6 166.45,51.6 166.92,52.08 R7912.2
  BOTTOM w0.254: U7900.H13 v5(165.33,52.12)
FBD_ZQ_2_B: length 3.7
  TOP w0.432: R7913.2 174.52,54.24 175.04,54.24 v1(175.55,54.74) 176.38,54.74 176.96,55.32 v5(176.96,55.37)
  BOTTOM w0.254: U7901.H13 176.96,55.37 v5(176.96,55.37)
FBVDDQ_GND_SENSE: length 69.5
  TOP w0.254: R7513.2 210.5,101.05 210.9,100.64 v2(211.05,100.64) 211.18,100.64 T8907.1 ; v2(252.18,85.02) 252.38,84.82 SR8913.1
  IN2 w0.254: v2(248.8,87.92) 248.6,87.71 246.12,87.71 243.3,84.89 241.87,84.89 240.54,83.57 240.54,82.3 239.19,80.94 236.4,80.94 235.67,80.22 217.66,80.22 215.98,81.9 215.98,94.65 215.22,95.41 215.22,99.04 214.78,99.47 212.5,99.47 211.33,100.64 v2(211.05,100.64)
  IN3 w0.254: v2(248.8,87.92) 248.8,87.68 250.52,85.96 251.97,85.96 252.2,85.73 252.2,85.05 v2(252.18,85.02)
  BOTTOM w0.254: v2(211.05,100.64) 211.13,100.57 SR7504.2 212.24,100.57 212.27,100.6 SR7502.2
FBVDDQ_GND_SENSE_IC: length 7.2
  TOP w0.203: U8900.10 250.49,83.63 v2(250.78,83.93)
  TOP w0.254: v2(250.78,83.93) 251.09,84.23 251.09,85.22 C8907.1 252.51,85.81 252.64,85.67 SR8912.2 253.63,85.26 SR8913.2 SR8906.2
  BOTTOM w0.102: v1(251.54,83.93) v2(250.78,83.93)
FBVDDQ_SENSE: length 66.2
  TOP w0.254: v2(250.15,87.94) 250.55,87.54 SR8914.1 ; R7512.1 210.38,100.63 v2(211.05,99.96) 211.18,100.08 211.33,100.08 T8908.1
  IN2 w0.254: v2(211.05,99.96) 211.49,99.96 212.32,99.12 214.64,99.12 214.86,98.89 214.86,95.26 215.6,94.53 215.6,81.77 217.51,79.86 235.82,79.86 236.54,80.59 239.34,80.59 240.93,82.18 240.93,83.45 242.01,84.54 243.45,84.54 246.26,87.36 249.97,87.36 250.15,87.54 v2(250.15,87.94)
  BOTTOM w0.254: SR7503.1 212.27,99.73 212.21,99.79 SR7501.2 211.22,99.79 v2(211.05,99.96)
FBVDDQ_SENSE_FBD: length 97.2
  TOP w0.254: v1(213.49,99.12) 213.49,99 v2(212.95,98.46)
  IN2 w0.254: v2(187.94,45.55) 188.07,45.42 188.71,45.42 189.85,46.56 189.85,55.81 193.18,59.14 193.18,62.16 204.43,73.41 208.49,73.41 209.89,74.81 209.89,75.95 214.89,80.96 214.89,94.11 214.08,94.93 214.08,96.5 213.14,97.44 213.14,98.28 v2(212.95,98.46)
  BOTTOM w0.254: SR7503.2 213.67,99.59 213.67,99.18 v2(212.95,98.46) ; v2(187.94,45.55) 187.84,45.65 186.65,45.65 185.83,44.84 161.95,44.84 R7511.1
FBVDDQ_SENSE_GPU: length 8.5
  TOP w0.292: R7504.1 174.89,118.04 v2(175.06,117.86)
  BOTTOM w0.125: U7000.E52 176.65,112.7 177.37,113.42 177.37,115.79 v1(176.38,116.77) 175.29,117.86 v2(175.06,117.86)
FBVDDQ_SENSE_GPU_R: length 67.9
  TOP w0.2: R7504.2 v2(174.89,120.33)
  IN1 w0.2: v2(193.48,123.53) 193.48,123.73 194.47,124.72 209.44,124.72 210.4,123.76 210.4,117.83 212.35,115.88 212.35,112.39 209.94,109.98 209.94,104.59 211.61,102.91 211.61,99.07 211.23,98.69 v2(211.12,98.69)
  IN3 w0.2: v2(193.48,123.53) 193.48,123.3 192.92,122.74 190.74,122.74 189.01,121.01 175.47,121.01 174.89,120.43 v2(174.89,120.33)
  BOTTOM w0.102: v1(174.89,121.01) v2(174.89,120.33)
  BOTTOM w0.2: SR7501.1 211.49,98.7 211.49,98.69 v2(211.12,98.69)
FBVDDQ_SENSE_GPU_RTN_R: length 63.7
  TOP w0.2: R7503.2 175.75,120.07 v2(175.49,120.33)
  IN1 w0.2: v2(211.12,101.95) 211.28,102.22 211.28,102.78 209.61,104.45 209.61,110.12 212.05,112.56 212.05,115.75 210.1,117.71 210.1,123.63 209.34,124.39 194.67,124.39 194.09,123.81 v2(194.09,123.53)
  IN3 w0.2: v2(194.09,123.53) 194.09,123.43 193.1,122.44 190.86,122.44 189.13,120.71 175.88,120.71 v2(175.49,120.33)
  BOTTOM w0.254: v1(212.1,102.34) 212.1,101.75 SR7504.1 211.2,101.95 v2(211.12,101.95)
FBVDDQ_SENSE_IC: length 6
  TOP w0.203: U8900.11 249.57,84.35 249.79,84.56 250.04,84.56
  TOP w0.254: 250.04,84.56 250.17,84.56 v2(250.6,85) 250.6,85.3 250.81,85.5 C8907.2 SR8914.2 R8909.1
  BOTTOM w0.102: v2(250.6,85) 251.34,85.73 v1(252.3,85.73)
FBVDDQ_SENSE_RTN_FBD: length 98.5
  IN2 w0.254: v2(213.62,98.43) 213.62,97.52 214.49,96.65 214.49,95.07 215.25,94.31 215.25,80.8 210.27,75.83 210.27,74.61 208.62,72.96 204.65,72.96 193.63,61.93 193.63,58.83 190.28,55.48 190.28,46.29 188.73,44.74 187.84,44.74 v2(187.48,45.1)
  BOTTOM w0.254: v2(187.48,45.1) 187.36,45.22 186.82,45.22 186.01,44.41 161.68,44.41 R7502.1 ; SR7502.1 213.92,100.6 214.46,100.06 v1(214.46,99.85) 214.46,99.42 213.62,98.58 v2(213.62,98.43)
FCCM_A: length 65.5
  TOP w0.254: v2(67.67,146.54) 69.3,148.17 69.3,164.07 68.28,165.08 v2(68.03,165.08) 68.03,165.11 69.17,166.25 69.17,168.13 68.93,168.37 68.93,171.81 67.16,173.58 67.16,177.1 v1(66.4,177.86) v2(65.61,178.65) 65.28,178.98 56.34,178.98 55.78,179.53 54.29,179.53 v2(53.33,180.5)
  IN1 w0.254: v2(77.83,181.21) 77.83,181.16 77.4,180.73 77,180.73 76.87,180.86 67.82,180.86 v2(65.61,178.65)
  BOTTOM w0.203: v2(53.33,180.5) 53.55,180.72 U8000.24
  BOTTOM w0.254: U8003.2 68.15,165.23 68.03,165.11 v2(68.03,165.08) ; v2(67.67,146.54) 67.82,146.69 U8001.2 ; v2(77.83,181.21) 77.98,181.06 U8002.2
FCCM_B: length 27.7
  TOP w0.102: v1(61.88,181.77) 61.58,181.77 v2(60.81,181)
  TOP w0.254: v2(65.01,172.57) 65.01,172.24 65.24,172.01 U8004.2 ; U8006.2 56.36,166.88 v2(56.42,166.82)
  IN2 w0.254: v2(56.42,166.82) 56.09,167.15 56.09,168.3 58.72,170.93 63.37,170.93 v2(65.01,172.57) 60.81,176.77 v2(60.81,181)
  BOTTOM w0.203: v2(60.81,181) 60.45,181 59.71,181.74 U8000.11
FCCM_C: length 77.1
  TOP w0.102: v2(51.8,185.68) 51.8,185.73 v1(50.63,186.9)
  TOP w0.254: v2(99.34,159.29) 100.52,159.29 100.7,159.11 U8005.7
  IN1 w0.254: v2(99.34,159.29) 100.23,159.29 100.56,159.62 100.56,162.49 100.74,162.67 100.74,173.93 93.49,181.19 90.8,181.19 90.8,181.19 90.51,181.19 90.21,181.18 89.37,182.02 88.75,182.02 85.98,184.79 80.62,184.79 80.01,184.18 78.25,184.18 76.75,185.68 61.72,185.68 61.19,185.15 59.23,185.15 58.47,184.39 53.01,184.39 51.8,185.6 v2(51.8,185.68)
  BOTTOM w0.203: v2(51.8,185.68) 51.8,185.43 52.04,185.19 52.33,185.19 52.58,184.94 U8000.34
FG0: length 3.8
  TOP w0.102: U4601.37 300.61,116 300.97,116.36 300.97,117.79 R4623.1 v1(302.16,118.04)
FG1: length 4.9
  TOP w0.102: U4601.38 300.53,116.5 300.67,116.64 300.67,117.71 R4625.1 300.11,118.04 299.9,118.24 299.9,119.74 v1(299.47,120.17)
FORCE_OFF#: length 64.8
  TOP w0.102: R5014.1 137.04,37.73 D5004.2 135.92,37.75 135.36,37.19 v2(135.36,34.3) 134.22,33.15 134.22,30.97 133.8,30.55 JRST5001.1 132.06,29.73 131.67,29.33 Q5002.6 ; Q9200.6 175.28,39.9 174.76,40.42 173.23,40.42 172.4,39.58 T9206.1 172.52,38.26 172.52,36.86 172.22,36.56 166.48,36.56 164.83,38.21 163.94,38.21 163.18,38.97 v2(163.18,39.45)
  BOTTOM w0.102: v2(163.18,39.45) 162.16,40.47 141.23,40.47 135.36,34.61 v2(135.36,34.3)
FORCE_OFF_PWR: length 142.4
  TOP w0.102: Q9200.3 173.33,38.6 173.23,38.69 173.23,39.12 173.36,39.25 Q9200.2 ; Q9200.3 173.92,37.54 v1(174.07,37.4) ; Q9200.3 174.57,38.6 175.09,38.08 176.18,38.08 C9200.1 177.22,37.45 R9204.2 R9205.1 177.7,33.88 v2(179.08,32.51) ; Q8106.5 260.12,66.4 260.46,66.74 ; 260.46,66.74 260.46,68.37 261.19,69.1 263.51,69.1 269.07,63.54 269.07,57.77 268.48,57.18 v2(268.48,53.14) ; 260.46,66.74 260.8,66.4 Q8106.2
  IN2 w0.102: v2(179.08,32.51) 179.48,32.1 187.88,32.1 188.69,32.91 192.14,32.91 193.11,31.95 199.05,31.95 199.39,32.29 216.46,32.29 218.7,30.06 230.56,30.06 231.2,29.42 239.82,29.42 241.2,30.81 241.2,32.31 241.95,33.05 244.62,33.05 245.18,33.61 248.62,33.61 249.41,34.4 251.94,34.4 265.56,48.02 265.56,48.88 268.48,51.8 v2(268.48,53.14)
FP_RST_DBR_N_CPUXDP: length 15.7
  BOTTOM w0.102: v1(52.25,134.63) 53.88,134.63 54.2,134.95 XDP4400.48 57.16,134.95 58.05,134.06 58.05,130.14 55.83,127.91 SR4407.1 55.53,127.15 55.42,127.04 55.42,126.39 55.32,126.29 C4402.1
FRAMELOCK#: length 12.8
  TOP w0.102: v2(141.89,66.36) 141.55,66.36 140.79,67.13 140.79,67.53 140.54,67.77 140.2,67.77 139.83,68.14 139.83,70.69 v1(139.73,70.79) 139.33,70.79 138.7,71.42 138.7,72.11 138.16,72.65 Q7406.3
  BOTTOM w0.102: v2(141.89,66.36) 141.2,67.04 141.2,67.86 SR7406.2
FRAMELOCK#_EDP: length 139
  TOP w0.102: Q7406.2 137.87,73.6 136.48,74.99 135.41,74.99 134.7,75.7 134.7,76.66 v1(133.92,77.45) 131.62,77.45 v2(129.98,75.81)
  IN1 w0.102: v2(130.03,167.62) 128.89,166.48 128.89,164.37 129.93,163.33 129.93,155.96 129.04,155.07 129.04,150.58 129.39,150.22 129.39,149.08 128.17,147.86 128.17,147.31 127.51,146.65 127.51,135.03 127.82,134.73 127.82,131.88 126.52,130.58 126.52,126.13 128.4,124.24 128.4,92.06 131.15,89.31 131.15,82.71 130.36,81.92 130.36,78.98 129.57,78.19 129.57,76.21 v2(129.98,75.81)
  IN4 w0.102: v2(130.03,167.62) 130.36,167.95 130.36,169.63 129.9,170.09 129.9,184.71 126.85,187.76 126.85,189.59 v2(126.6,189.85)
  BOTTOM w0.102: R4595.1 123.73,192.26 R4517.1 125.53,191.55 126.6,190.48 v2(126.6,189.85)
G1: length 15.2
  TOP w0.102: SR3702.2 67.51,15.65 R3707.1 67.93,16.75 67.29,17.38 64.12,17.38 v2(63.61,17.89)
  BOTTOM w0.102: U3700.11 63.35,14.91 62.91,15.35 62.69,15.35 62.46,15.58 60.56,15.58 v1(60.31,15.83) 61.19,16.72 61.19,17 62.21,18.02 63.48,18.02 v2(63.61,17.89)
G2: length 17.2
  TOP w0.102: SR3703.2 67.08,16.71 66.78,17 63.91,17 63.1,17.81 63.1,18.14 63.35,18.4 63.99,18.4 64.24,18.14 v2(64.24,17.89) 67.54,17.89 69.07,16.36 R3708.1
  BOTTOM w0.102: v2(64.24,17.89) 64.24,16.87 63.2,15.83 v1(62.85,15.83) 63.32,15.36 U3700.12
GATE_SQ14: length 9.4
  TOP w0.102: Q3101.2 v1(206.64,37.95)
  TOP w0.121: Q3101.5 210.04,37.95 209.66,37.57 209.66,36.48 R3114.1 209.35,35.87 209.15,35.67 208.01,35.67 207.58,36.1 R3112.1 208.21,36.81 208.51,36.81 208.9,37.19 208.9,37.68 208.62,37.95 Q3101.2
GC6_FB_EN: length 3.8
  BOTTOM w0.102: D7402.1 150.46,60.83 v1(150.22,61.07) 150.22,61.83 R7448.2 149.26,62.01 148.97,61.72 U7402.3
GC6_FB_EN_R: length 8
  BOTTOM w0.102: U7412.2 145.65,59.75 145.78,59.63 146.58,59.63 147.35,58.86 U7402.6 147.67,58.18 147.43,57.94 v1(147.43,57.55) R7442.2 147.99,57.22 147.99,57.9 148.32,58.22 U7402.5
GC6_FB_GPU: length 13.4
  BOTTOM w0.102: U2302.6 v1(240.63,39.76) 240.14,39.76 237.39,42.5 237.39,43.36 R2357.2 237.37,44.2 237.37,45.55 236.56,46.36 236.56,46.75 235.84,47.46 235.84,48.82 U2000.AV43
GEN1_I2C_SCL: length 4.1
  TOP w0.121: U5800.12 299.09,133.65 299.07,133.63 R5803.2 298.74,132.98 v1(298.43,132.67)
GEN1_I2C_SDA: length 6.3
  TOP w0.121: v1(301.56,127.82) 301.89,127.82 302.47,128.4 302.47,130.03 302.29,130.2 R5804.2 302.25,130.42 U5800.2
GPD8_SUSCLK: length 104.9
  TOP w0.102: v2(233.79,63.54) 233.15,64.17 233.15,67.01 R2458.1 233.9,68.62 233.9,71.68 T2411.1 232.57,75.18 v2(232.8,75.41) ; v2(306.81,99.93) 307.02,100.13 R2401.2
  IN2 w0.102: v2(232.8,75.41) 234.26,76.87 238,76.87 240.53,79.39 243.28,79.39 244.07,80.18 244.07,82.61 243.95,82.73 243.95,83.21 246.88,86.14 252.36,86.14 253.3,87.07 253.3,87.74 254.16,88.6 259.19,88.6 260.81,90.23 269.6,90.23 271.41,88.42 274.26,88.42 274.85,89.01 281.09,89.01 284.49,92.41 302.09,92.41 303.87,94.19 304.57,94.19 305.57,95.19 305.57,97.29 306.81,98.53 v2(306.81,99.93)
  BOTTOM w0.102: U2000.AN15 v2(233.79,63.54)
GPG2_EC: length 9.6
  TOP w0.102: U3002.100 163.2,22.31 163.86,21.65 163.86,20.06 164,19.92 R3001.2 165.31,19.62 165.47,19.46 166.81,19.46 167.69,18.58 v1(168.16,18.58) 168.16,19.12 168.26,19.21 SR3018.1
GPH7: length 8.1
  TOP w0.102: v1(163.91,35.03) 163.68,35.26 R3031.2 163.08,36.01 162.92,36.18 162.92,36.48 R3026.1 ; U3002.3 160.06,35.86 160.89,36.68 160.89,37.24 161.09,37.45 161.96,37.45 R3026.1 ; R3026.1 R3027.2
GPIO0: length 5.6
  TOP w0.076: 291.34,56.44 291.74,56.44 U1201.B2
  TOP w0.102: 291.34,56.44 290.9,56 290.24,56 289.73,55.49 v1(287.81,55.49) R1227.1
GPIO0_NVVDD_PWM_GPU: length 12.5
  TOP w0.102: v1(149.31,75.6) 149.46,75.45 v3(149.46,74.33) 149.07,74.33 148.75,74 148.75,73.79 148.62,73.67 147.86,73.67 147.12,72.93 147.01,72.81 147.01,72.12 SR7403.1
  IN4 w0.102: v3(149.46,74.33) 150.73,75.6 150.73,78.9 150.45,79.18 v3(149.74,79.18)
  BOTTOM w0.102: U7000.BD6 149.72,79.18 v3(149.74,79.18)
GPIO1_GC6FBEN: length 195.8
  IN1 w0.102: v3(150.35,78.54) 150.81,78.09 150.81,69.15 151.3,68.65 151.3,66.7 151.06,66.45 150.68,66.45 149.54,65.31 v2(149.54,63.19) ; v2(239.27,44.48) 239,44.76 237.63,44.76 237.37,44.5 237.37,44.18 236.72,43.54 211.1,43.54 209.76,42.2 209.76,41.43 209.18,40.85 209.18,38.34 205.64,34.81 204.92,34.81 196.48,26.36 143.66,26.36 140.83,29.19 129.22,29.19 v2(128.17,30.23)
  BOTTOM w0.102: v2(149.54,63.19) 149.09,63.19 R7436.2 148.32,62.42 U7402.2 148.32,60.71 149.99,59.04 151.47,59.04 151.97,58.54 151.97,55 152.76,54.21 152.76,48.61 149.32,45.17 141.05,45.17 v1(138.31,42.43) 138.31,41.68 131.41,34.78 131.32,34.78 129.81,33.27 129.81,31.87 v2(128.17,30.23) ; U2302.5 241.28,41.43 240.3,42.41 240.3,43.92 239.74,44.48 v2(239.27,44.48) ; v3(150.35,78.54) 150.53,78.72 150.62,78.72 U7000.BB5
GPIO2: length 12.9
  TOP w0.102: v5(293.22,59.8) 293.22,59.96 U1201.D10
  BOTTOM w0.102: T1208.1 282.23,60.76 285.32,60.76 285.98,60.1 288.04,60.1 288.72,59.42 292.85,59.42 v5(293.22,59.8)
GPIO2_GPU_EVENT#: length 14.3
  BOTTOM w0.102: U7000.BD1 149.35,75.87 149.06,75.57 149.06,75.31 148.1,74.35 147.91,74.35 147.53,73.97 147.15,73.97 146.03,72.86 146.03,70.11 146.28,69.85 146.28,68.97 145.83,68.51 145.83,67.06 R7437.2 146.51,66.38 146.61,66.38 146.78,66.22 U7404.6 147.49,65.58 v1(147.99,66.07)
GPIO3: length 11.9
  TOP w0.102: v2(293.97,62.55) 294.13,62.55 294.54,62.13 294.54,60.75 U1201.G11
  BOTTOM w0.102: v2(293.97,62.55) 293.19,63.33 284.92,63.33 T1207.1
GPIO3_NVVDDS_PWM_GPU: length 9.5
  BOTTOM w0.102: U7000.BE4 148.95,77.84 148.95,75.82 148.85,75.72 148.85,75.39 148.02,74.56 147.83,74.56 147.44,74.18 147.06,74.18 v1(145.6,72.72) 145.6,72.19 145.75,72.04 145.75,71.1 145.59,70.94 SR7405.1
GPIO4_1V8MAINEN: length 52.4
  TOP w0.102: v2(149.83,51.23) 149.38,50.79 v1(149.38,42.96)
  IN1 w0.102: v2(149.83,51.23) 152.1,53.51 152.1,61.35 151.54,61.91 149.13,61.91 149.02,62.01 149.02,67.73 147.68,69.07 144.94,69.07 144.51,68.64 144.51,67.8 144.8,67.51 v2(145.13,67.51)
  BOTTOM w0.102: U7410.2 146.54,50.47 146.71,50.64 147.09,50.64 147.9,51.44 149.62,51.44 v2(149.83,51.23) ; v2(145.13,67.51) 145.54,67.91 145.54,68.93 R7419.2 144.84,72.54 144.41,72.97 144.41,73.43 144.46,73.48 144.46,73.85 144.99,74.38 147.36,74.38 147.74,74.76 147.93,74.76 148.65,75.48 U7000.BE1
GPIO5_FL_INT_GPU: length 13.1
  IN1 w0.102: v3(147.67,76.32) 147.67,76.05 146.87,75.24 146.87,73.77 143.99,70.89 142.73,70.89 142.18,70.34 v2(142.18,70.33)
  BOTTOM w0.102: v1(142.37,72.73) 142.65,72.45 142.65,71.41 R7438.2 142.17,70.34 v2(142.18,70.33) 142.12,70.27 SR7406.1
  BOTTOM w0.109: U7000.BG2 v3(147.67,76.32)
GPIO6: length 4.3
  TOP w0.076: 294.75,61.37 294.74,61.36 294.74,60.44 U1201.G10
  TOP w0.102: v1(293.99,63.33) 293.99,63.18 295,62.16 R1229.1 294.75,61.53 294.75,61.37
GPIO6_NVVDD_PSI#: length 16.6
  TOP w0.102: SR7418.1 144.97,72.88 145.8,73.71 145.8,75.61 145.57,75.84 v1(145.57,76.32) 145.88,76.02 146.37,76.02 v3(148.34,74.05)
  BOTTOM w0.102: U7000.BD2 149.35,76.44 149.44,76.35 149.48,76.35 149.65,76.18 149.65,75.36 v3(148.34,74.05) 146.98,72.68 146.98,71.36 R7439.2 146.86,70.61 146.86,69.81 SR7409.1
GPIO7: length 9.4
  TOP w0.102: v5(292.49,58.71) 292.98,58.71 U1201.D7 ; v2(290.41,58.91) 290.12,59.2 286.32,59.2 284.93,57.81 R1228.1
  IN4 w0.102: v2(290.41,58.91) 290.79,58.53 291.47,58.53 291.65,58.71 v5(292.49,58.71)
GPIO7_BL_PWM: length 189.1
  TOP w0.102: U7406.3 v2(147.51,67.29) ; CON4500.26 109.75,191.36 v2(110.34,191.95)
  IN1 w0.102: v2(110.34,191.95) 111.18,191.12 116.82,191.12 117.46,190.48 122.15,190.48 122.54,190.1 123.3,190.1 123.68,190.48 125.2,190.48 v2(125.71,189.97)
  IN3 w0.102: v2(147.51,67.29) 147.18,66.96 140.2,66.96 139.02,68.14 139.02,73.53 137.84,74.71 133.43,74.71 128.48,79.66 128.48,82.81 128.75,83.08 128.75,84.49 128.53,84.72 128.53,87.47 125.78,90.22 125.78,111.63 125.11,112.29 125.11,124.77 121.49,128.39 121.49,129.94 121.02,130.42 121.02,133.33 119.02,135.33 118.19,135.33 117.49,136.02 116.88,136.02 116.03,136.87 116.03,144.79 117.52,146.28 122.3,146.28 123.47,147.45 123.47,147.99 124.14,148.66 124.14,151.54 122.41,153.27 120.06,153.27 118.28,155.04 118.28,162.15 120.22,164.09 120.22,165.94 121.45,167.16 128.81,167.16 v2(129.86,168.22)
  IN4 w0.102: v2(129.86,168.22) 130.05,168.41 130.05,169.65 129.7,170 129.7,184.39 126.65,187.43 126.65,189.03 v2(125.71,189.97)
  BOTTOM w0.102: v2(125.71,189.97) v1(125.71,189.24) 125.89,189.06 R4596.2 ; R4587.1 110.12,192.18 v2(110.34,191.95)
GPIO7_BL_PWM_GPU: length 14.8
  TOP w0.102: v1(149.74,73.72) 149.26,73.72 v3(149.13,73.84) 148.72,73.44 147.92,73.44 147.33,72.84 147.21,72.73 147.21,71.04 148.11,70.13 R7451.1 148.11,68.96 148.16,68.92 U7406.2
  IN4 w0.102: v3(149.13,73.84) 149.08,73.9 149.08,79.29 v3(149.69,79.9)
  BOTTOM w0.102: v3(149.69,79.9) 149.69,79.91 U7000.BD7
GPIO9_ALERT#: length 31
  IN4 w0.102: v2(138.16,62.92) 139.6,62.92 141.99,65.31 142.29,65.31 142.91,65.93 142.91,66.61 143.17,66.86 145.06,66.86 145.55,67.35 145.55,69.11 146.01,69.56 146.01,70.87 147.07,71.94 147.07,76.23 v3(146.2,77.09)
  BOTTOM w0.102: R7414.2 141.33,69.72 SR7410.1 140.94,69.62 140.77,69.45 140.77,67.2 140.23,66.66 139.09,66.66 138.74,66.31 138.74,64.14 138.33,63.74 v1(138.33,63.56) 138.33,63.1 v2(138.16,62.92) ; U7000.BJ3 146.2,77.09 v3(146.2,77.09)
GPIO10_FBVREF_SEL: length 297
  TOP w0.102: v2(214.36,97.85) 214.74,98.23 v1(214.74,100.67) 214.74,101.35 211.13,104.96 211.13,109.51 213.98,112.35 213.98,115.83 212.1,117.71 212.1,120.78 211.49,121.39 211.49,122.35 210.8,123.04 210.8,126.54 v2(208.26,129.08) 208.26,131.15 207.93,131.48 199.9,131.48 199.27,132.11 199.27,132.95 196.47,135.75 196.47,140.81 194.93,142.35 191.12,142.35 189.77,143.69 179.13,143.69 178.95,143.52 156.27,143.52 v2(155.61,142.86) 154.67,143.8 143.41,143.8 142.91,144.3 135.85,144.3 134.58,143.03 131.4,143.03 130.93,143.51 130.93,147.17 v2(129.9,148.19)
  IN2 w0.102: v2(148.11,72.22) 149.21,71.13 149.21,68.43 150.09,67.55 150.09,66.66 149.21,65.77 149.21,63.86 149.13,63.79 149.13,60.33 153.98,55.48 153.98,47.51 156.09,45.4 170.72,45.4 v2(171.35,46.03)
  IN3 w0.102: v2(148.11,72.22) 144.94,72.22 141.54,75.62 141.54,77.7 138.33,80.91 134.95,80.91 133.66,82.19 133.66,89.41 131.82,91.25 131.82,91.71 129.75,93.78 129.75,122.21 130.13,122.59 130.13,128.21 128.73,129.61 127.56,129.61 124.95,132.22 124.95,134.4 126.04,135.5 126.04,144.02 129.9,147.88 v2(129.9,148.19)
  IN4 w0.102: v2(210.7,96.76) 213.26,96.76 v2(214.36,97.85)
  BOTTOM w0.102: Q7800.1 207.86,91.81 210.7,94.65 v2(210.7,96.76) ; Q7700.1 v2(208.26,129.08) ; v2(148.11,72.22) 147.68,71.79 R7429.2 147.43,72.74 148.04,73.35 148.33,73.35 148.75,73.77 148.75,74.16 149.86,75.26 149.86,76.26 149.7,76.42 149.7,76.95 149.35,77.3 U7000.BD3 ; Q7900.1 172.3,45.79 171.91,45.4 171.48,45.4 171.35,45.52 v2(171.35,46.03) ; Q7600.1 155.65,142.82 v2(155.61,142.86)
GPIO11_PPEN_PWRBRK: length 18.2
  TOP w0.102: U7407.2 141.84,68.51 142.09,68.26 R7454.1 142.09,67.37 143.01,66.45 v2(143.34,66.45)
  IN4 w0.102: v3(146.2,77.79) 147.28,76.72 147.28,71.41 146.86,70.99 146.86,69.96 145.75,68.85 145.75,67.27 144.94,66.45 v2(143.34,66.45)
  BOTTOM w0.109: v3(146.2,77.79) 146.2,77.79 U7000.BH3
GPIO12_AC_BATT#: length 258
  TOP w0.102: SR7411.2 144.51,73.02 v3(144.79,73.3) ; v2(142.81,64.78) 142.81,65.25 142.55,65.51 Q7405.3 ; v2(263.58,35.39) 263.53,35.34 SR8810.2
  IN1 w0.102: v3(144.79,73.3) 144.79,72.49 143.58,71.27 142.55,71.27 141.77,70.5 141.77,67.9 142.81,66.85 142.81,64.78 v2(142.81,64.78)
  IN3 w0.102: v2(113.39,19.03) 114.1,18.32 133.11,18.32 137.6,22.8 141.11,22.8 142.32,21.6 176.27,21.6 176.61,21.94 187.13,21.94 187.93,22.74 199.26,22.74 201.41,24.89 201.82,24.89 204.78,27.85 220.8,27.85 224.51,24.14 225.63,24.14 227.11,25.62 227.11,26.79 230.12,29.8 231.78,29.8 231.97,29.61 243.6,29.61 246.77,32.77 249.52,32.77 250.86,34.11 252.67,34.11 253.57,35.01 255.95,35.01 256.18,34.78 262.97,34.78 v2(263.58,35.39) ; v2(140.75,53.99) 141.4,53.35 145.27,53.35 146.26,54.34 146.82,54.34 147.04,54.56 149.5,54.56 150.02,54.03 151.82,54.03 153.42,55.64 153.42,56.05 150.88,58.59 150.88,59.22 144.53,65.56 143.26,65.56 142.81,65.12 v2(142.81,64.78)
  BOTTOM w0.102: v2(113.39,19.03) 113.39,19.67 114.13,20.4 119.06,20.4 119.69,21.04 119.79,21.04 122.16,23.41 124.1,23.41 127.54,26.85 127.54,29.77 127.74,29.98 127.74,31.25 128.71,32.21 128.71,33.13 v1(129.85,34.27) 130.87,35.29 130.87,36.07 135.86,41.07 136.33,41.07 137.57,42.31 137.57,43.01 138.36,43.8 138.36,50.45 139.73,51.82 139.73,53.26 140.25,53.78 140.54,53.78 v2(140.75,53.99)
GPIO12_AC_DETECT: length 14.1
  TOP w0.102: R7423.2 144.51,70.15 v2(144.42,70.24) 144.51,70.33 SR7411.1
  IN1 w0.102: v3(148.25,79.15) 148.8,78.6 148.8,75.34 147.3,73.84 147.3,71.86 146.01,70.57 146.01,70.2 145.74,69.93 144.73,69.93 v2(144.42,70.24)
  BOTTOM w0.102: U7000.BE6 v3(148.25,79.15)
GPIO13_BLEN_FAN_TACH: length 6.4
  BOTTOM w0.102: U7000.BB1 150.75,74.88 150.04,74.17 v1(150.04,73.74) 149.61,73.74 149.16,73.28 R7456.1 149.16,71.47 149.29,71.34 U7408.2
GPIO17_IFPD_HPD: length 32.9
  TOP w0.102: v2(142.4,59.72) 142.4,58.99 v1(142.53,58.86)
  IN1 w0.102: v3(149.7,78.5) 149.21,78.01 149.21,76.56 150.09,75.67 150.09,71.74 147.81,69.45 143.11,69.45 142.6,68.94 142.6,67.8 143.87,66.53 143.87,64.5 142.32,62.95 142.32,59.8 v2(142.4,59.72)
  BOTTOM w0.102: U7403.6 138.85,58.46 R7458.2 139.97,59.58 142.26,59.58 v2(142.4,59.72) ; U7000.BD5 v3(149.7,78.5)
GPIO18_IFPE_HPD: length 54.8
  IN3 w0.102: v2(136.79,57.79) 136.79,57.09 140.94,52.94 145.44,52.94 146.43,53.93 146.98,53.93 147.21,54.15 149.29,54.15 149.69,53.75 149.81,53.63 151.99,53.63 153.83,55.47 153.83,56.22 151.75,58.3 151.75,63.61 149.92,65.44 149.92,66.61 150.5,67.19 150.5,73.83 148.98,75.34 v3(147.69,75.34)
  BOTTOM w0.102: U7403.3 137.55,54.35 137.34,54.14 R7466.2 136.93,54.17 136.93,54.83 136.66,55.1 v1(135.39,55.1) 135.85,55.56 135.85,57.02 136.62,57.79 v2(136.79,57.79) ; v3(147.69,75.34) 148.1,75.75 148.1,76.4 148.35,76.65 148.35,76.88 148.52,77.05 148.56,77.05 148.65,77.14 U7000.BE3
GPIO19_STEREO_OUT_SRV_HEAD: length 1.3
  TOP w0.102: T7402.1 149.74,77.83 v3(149.7,77.8)
  BOTTOM w0.111: U7000.BD4 v3(149.7,77.8)
GPIO20_GC5_MODE_GPU: length 11.4
  TOP w0.102: R7478.1 145.78,70.54 v2(145.57,70.34)
  IN1 w0.102: v3(148.25,78.58) 148.48,78.35 148.48,75.43 147.07,74.02 147.07,72.28 145.78,70.98 145.78,70.54 v2(145.57,70.34)
  BOTTOM w0.102: v3(148.25,78.58) 148.38,78.58 U7000.BE5 ; v2(145.57,70.34) 145.78,70.14 v1(145.78,69.7)
GPIO23_GPU_PEX_RST_HOLD: length 3.5
  BOTTOM w0.102: SR7415.2 144.29,68.49 v1(144.29,66.91) 144.29,66.72 143.49,65.92 U7003.2
GPIO23_PEXRSTHOLD_RASTERSYNC1: length 11.6
  TOP w0.102: v1(143.16,74.4) 143.5,74.06 143.66,74.06 v3(144.08,73.64)
  IN1 w0.102: v3(144.08,73.64) 144.25,73.64 145.17,74.56 145.88,74.56 147.25,75.93 147.25,76.74 v3(147.61,77.09)
  BOTTOM w0.102: v3(144.08,73.64) 144.08,72.88 144.53,72.43 144.53,71.33 R7457.2 144.13,70.57 144,70.44 SR7415.1
  BOTTOM w0.109: v3(147.61,77.09) 147.61,77.09 U7000.BG3
GPIO24_IFPF_HPD: length 19.4
  IN3 w0.102: v3(146.25,75.46) 146.71,75.93 149.84,75.93 150.9,74.87 v2(150.9,66.86)
  BOTTOM w0.102: v1(153.85,68.61) 153.4,69.07 151.54,69.07 151.35,68.88 U7405.6 151.35,67.55 151.52,67.37 R7477.2 150.98,66.95 v2(150.9,66.86)
  BOTTOM w0.109: U7000.BH1 146.25,75.75 v3(146.25,75.46)
GPIO27_IFPC_HPD: length 8.2
  BOTTOM w0.102: U7405.3 152.65,71.34 152.43,71.55 R7475.2 152.43,73.16 152.69,73.41 v1(152.69,73.74) 152.69,74.25 152.43,74.51 152.43,76 151.8,76.64 151.8,77.8 U7000.BA4
GPIO29_VRDUTY: length 175.7
  TOP w0.102: v1(186.65,162.21) 186.65,162.47 187,162.82 v2(187.64,162.82) 187.46,163 R74102.1
  IN3 w0.102: v2(149.97,69.35) 149.97,71.74 147.03,74.68 143.34,74.68 142.2,75.82 142.2,79.49 139.23,82.46 136.72,82.46 134.96,84.22 134.96,91.49 134.62,91.83 133.04,91.83 130.36,94.51 130.36,121.95 130.74,122.33 130.74,128.46 128.98,130.22 127.81,130.22 125.56,132.48 125.56,134.07 126.7,135.21 126.7,143.81 131.98,149.1 131.98,154.91 133.91,156.83 133.91,158.2 135.82,160.1 148.06,160.1 149.12,161.17 184.55,161.17 184.93,160.79 186.09,160.79 187.64,162.34 v2(187.64,162.82)
  BOTTOM w0.102: v2(149.97,69.35) 150.68,70.06 150.68,73.51 151.75,74.59 151.75,76.18 151.49,76.44 151.33,76.44 151.14,76.62 151.14,76.88 151.45,77.18 U7000.BA3
GPP_A6_SERIRQ: length 12.8
  TOP w0.121: SR2207.2 245.04,64.57 v1(244.56,65.06) 244.13,64.63 244.13,64.51 R2203.2 243.15,63.53 242.1,63.53 241.96,63.39 241.37,63.39 240.85,63.91 239.93,63.91 239.47,63.46 238.88,63.46 237.87,62.44 237.6,62.44 236.88,61.72 236.7,61.72 v2(236.21,61.24)
  BOTTOM w0.121: U2000.BA17 236.93,61.7 236.68,61.7 v2(236.21,61.24)
GPP_A14_SUS_STAT#_ESPI_RST#: length 12.6
  BOTTOM w0.089: 239.41,60.94 239.37,60.98 238.88,60.98 238.77,61.09 238.54,61.09 238.5,61.08 238.17,61.08 U2000.BC18
  BOTTOM w0.121: v1(248.67,63.68) 248.33,63.34 SR2209.2 247.59,62.01 247.08,62.01 246.47,61.4 246.12,61.4 245.97,61.55 244.8,61.55 244.33,61.08 240.71,61.08 240.48,60.85 239.5,60.85 239.41,60.94
GPP_D13: length 9.2
  BOTTOM w0.102: R2315.1 R2314.2 233.58,41.08 233.53,41.13 v1(233.53,41.46) 233.56,41.49 233.56,44.65 232.64,45.56 232.64,46.29 231.72,47.21 231.72,48.12 U2000.AK45
GPP_D14: length 10.6
  BOTTOM w0.102: R2316.2 R2317.1 234.83,40.9 234.66,41.07 234.34,41.07 233.97,41.44 233.97,41.72 233.76,41.93 233.76,45.02 v1(233.81,45.07) 232.95,45.93 232.95,46.27 231.93,47.29 231.93,47.96 231.95,47.98 231.95,48.25 231.83,48.44 231.83,48.52 U2000.AK44
GPP_D15: length 15.1
  BOTTOM w0.102: U2000.AL43 232.06,48.83 232.06,48.46 232.16,48.31 232.16,47.9 232.14,47.88 232.14,47.44 232.38,47.19 232.4,47.19 234.27,45.32 234.27,44.81 234.09,44.63 234.09,44.33 233.97,44.2 233.97,42.01 234.17,41.81 234.17,41.52 234.42,41.27 236.72,41.27 236.94,41.05 R2318.2 R2319.1 238.46,41.05 238.94,40.57 v1(238.94,39.35)
GPP_D16: length 10.6
  BOTTOM w0.102: R2321.1 R2320.2 232.75,41.31 233.36,41.92 233.36,44.53 232.16,45.72 v1(232.16,46.16) 231.51,46.81 231.51,47.92 231.4,48.04 231.4,48.75 U2000.AJ43
GPP_H23: length 13
  BOTTOM w0.102: v1(248.42,48.09) 248.6,48.27 R2463.2 248.14,49.51 248.14,50.07 247.78,50.43 246.4,50.43 246.29,50.53 244.38,50.53 243.75,51.16 242.77,51.16 242.62,51.32 242.28,51.32 242.05,51.09 241.53,51.09 241.28,51.34 240.59,51.34 240.39,51.54 239.6,51.54 239.32,51.82 238.89,51.82 238.74,51.98 238.69,51.98 U2000.BD36
GPP_H_16_SML4CLK: length 10.9
  BOTTOM w0.102: v1(247.15,46.69) 246.44,47.4 R2466.2 ; U2000.BD39 238.74,50.78 239.25,50.78 239.32,50.85 239.99,50.85 240.06,50.78
  BOTTOM w0.114: 240.06,50.78 241.76,49.09 245.39,49.09 245.98,48.5 245.98,48.22 R2466.2
GPP_H_17_SML4DATA: length 9.8
  BOTTOM w0.102: U2000.BE34 239.36,53.02 240.2,53.02 240.94,52.28 241.52,52.28 241.57,52.33 242.67,52.33 242.75,52.41 244.35,52.41 244.43,52.33 247.28,52.33 247.76,51.85 R2469.2
GPU_1V8_MAIN_EN: length 31.3
  TOP w0.102: v2(131.38,52.48) 132.8,53.91 132.8,69.86 SR9105.1
  IN3 w0.102: v2(138.9,50.33) 135.03,50.33 132.87,52.48 v2(131.38,52.48)
  BOTTOM w0.102: v1(139.07,49.54) 139.07,50.16 v2(138.9,50.33) 139.43,50.33 R7489.1 140.01,51.6 140.36,51.95 D7405.3
GPU_ALERT#: length 158.2
  TOP w0.102: v2(146.41,54.85) 145.65,54.08 145.65,51.44 136.45,42.25 134.12,42.25 v2(133.71,42.65)
  IN3 w0.102: v2(235.59,41.69) 235.08,41.18 211.67,41.18 211.35,41.5 210.18,41.5 209.56,42.12 204.38,42.12 199.22,36.96 198.28,36.96 196.39,35.08 196.39,33.68 195.29,32.57 194.81,32.57 190.51,32.57 189.83,31.9 188.69,31.9 187.19,33.39 165.19,33.39 164.83,33.04 164.83,32.23 164.56,31.97 162.24,31.97 160.89,33.32 148.18,33.32 144.48,37.01 142.98,37.01 142.76,37.24 133.02,37.24 131.3,35.52 128.25,35.52 v2(127.44,34.72)
  BOTTOM w0.102: v2(133.71,42.65) 133.61,42.55 v1(133.61,41.89) 133.61,41.34 127.44,35.17 v2(127.44,34.72) ; U2000.AT44 234.63,48.1 234.84,47.9 234.84,47.03 234.73,46.92 234.73,46.45 235.42,45.75 235.72,45.75 236.33,45.14 236.33,44.07 R2371.2 235.62,43.35 235.62,41.71 v2(235.59,41.69) ; v2(146.41,54.85) 146.41,55.39 U7413.3
GPU_BAT_THRO: length 145.1
  TOP w0.102: Q7405.1 140.84,66.46 141.28,66.02 141.28,65.23 141.61,64.9 v2(141.61,63.52) 141.39,63.74 139.96,63.74 v1(139.6,63.38)
  IN2 w0.102: v2(244.85,59.72) 244.85,59.41 243.82,58.38 243.82,57.51 240.23,53.92 240.23,52.52 240.46,52.3 240.46,46.56 239.52,45.63 210.58,45.63 209.21,46.99 195.83,46.99 191.99,43.15 186.3,43.15 185.3,44.15 155.61,44.15 152.03,47.74 152.03,51.14 148.83,54.34 145.85,54.34 145.37,54.82 145.37,57.4 143.52,59.25 143.52,61.12 141.61,63.02 v2(141.61,63.52)
  BOTTOM w0.089: 239.68,58.71 239.67,58.7 238.88,58.7 238.82,58.77 238.8,58.77 238.74,58.8 238.68,58.82 238.58,58.82 238.5,58.81 238.17,58.81 U2000.BC23
  BOTTOM w0.102: 239.68,58.71 239.96,58.99 239.96,59.57 240.3,59.91 240.75,59.91 241.01,60.17 244.4,60.17 v2(244.85,59.72) 245.22,59.72 245.27,59.77 R2409.2
GPU_EVENT#: length 181
  IN3 w0.102: v2(146.58,64.64) 146.58,63.8 151.09,59.3 151.09,58.68 153.63,56.14 153.63,55.55 151.9,53.83 149.94,53.83 149.42,54.35 147.12,54.35 146.9,54.13 146.35,54.13 145.36,53.14 141.02,53.14 140.24,53.93 v2(140.24,54.39) ; v2(128.11,34.72) 128.71,35.32 131.39,35.32 133.06,36.99 142.72,36.99 142.9,36.81 144.4,36.81 148.09,33.12 160.81,33.12 162.16,31.77 164.65,31.77 165.03,32.15 165.03,32.65 165.57,33.19 187.11,33.19 188.61,31.69 194.7,31.69 196.6,33.59 196.6,34.99 197.64,36.04 199.63,36.04 205.5,41.92 209.47,41.92 210.09,41.3 211.26,41.3 211.58,40.97 235.72,40.97 v2(236.43,41.69)
  BOTTOM w0.102: U2000.AU44 235.12,48.54 235.36,48.29 235.36,47.23 235.69,46.9 235.69,46.2 236.55,45.34 236.55,44.18 R2358.2 236.56,43.36 236.56,41.82 v2(236.43,41.69) ; v2(140.24,54.39) 140.24,54.06 139.53,53.35 139.53,51.95 138.11,50.53 138.11,44.11 136.81,42.81 v1(136.09,42.81) 135.37,42.81 128.11,35.55 v2(128.11,34.72) ; U7404.5 146.13,65.26 146.58,64.81 v2(146.58,64.64)
GPU_ID0: length 15.8
  TOP w0.102: R6113.2 218.52,41.51 218.52,43.36 R6114.1 218.93,45.32 v1(219.69,46.08) 220.07,46.46 223.32,46.46 224.29,47.43 224.29,51.01 v2(224.72,51.44)
  BOTTOM w0.102: U2000.U39 224.98,51.15 224.98,51.18 v2(224.72,51.44)
GPU_ID1: length 18
  BOTTOM w0.089: U2000.N42 223.14,49.46 222.84,49.16 222.56,49.16 222.26,48.85 222.26,48.45 222.14,48.34 222.14,48.33
  BOTTOM w0.102: R6115.2 211.08,41.71 v1(211.08,41.89) 211.08,42.45 211.26,42.63 211.26,43.54 211.49,43.77 R6116.1 211.94,44.35 214.18,46.59 219.45,46.59 220.21,47.35 221.27,47.35 221.9,47.99 221.9,48.09 222.14,48.33
GPU_IPC_SCL: length 152.4
  TOP w0.121: U9702.6 93.4,182.32 93.73,182.66 v2(93.73,183.09)
  IN3 w0.083: v2(139.83,77.58) 139.38,78.04 139.38,79.18 138.47,80.08 134.56,80.08 132.66,81.99 132.66,88.92 129.84,91.74 129.84,92.93 128.81,93.96 128.81,115.66 129.13,115.97 129.13,122.25 129.66,122.78 129.66,124.76 129.11,125.31 129.11,128.56 128.53,129.14 127.14,129.14 124.05,132.22 124.05,134.24 125.57,135.75 125.57,144.24 129.34,148.01 129.34,148.22 130.11,148.98 130.11,151.21 129.72,151.59 v2(129.44,151.59)
  IN4 w0.083: v2(93.73,183.09) 93.73,181.31 97.56,177.48 97.56,175.86 95.79,174.09 95.79,166.54 96.58,165.75 96.58,162.43 96.89,162.13 98.39,162.13 98.91,162.65 101.72,162.65 102.47,161.9 105.75,161.9 107.44,160.21 113.06,160.21 120.12,153.14 121.16,153.14 121.43,152.87 126.74,152.87 128.02,151.59 v2(129.44,151.59)
  BOTTOM w0.121: v1(94.24,181.69) 93.73,182.2 v2(93.73,183.09) ; v2(139.83,77.58) 139.33,77.58 139.12,77.36 SR7407.2
GPU_IPC_SDA: length 154.4
  TOP w0.121: v2(93.17,182.81) 92.87,182.51 92.87,182.41 92.75,182.28 U9702.7
  IN3 w0.083: v2(129.44,150.96) 129.62,150.78 129.62,149.15 128.86,148.39 128.86,148.19 125.1,144.43 125.1,135.95 123.59,134.43 123.59,132.03 126.94,128.67 128.34,128.67 128.65,128.37 128.65,125.12 129.19,124.57 129.19,122.98 128.66,122.44 128.66,116.16 128.35,115.85 128.35,93.77 129.38,92.74 129.38,91.54 132.19,88.73 132.19,81.79 134.37,79.61 138.21,79.61 138.91,78.91 138.91,77.84 139.58,77.17 140.32,77.17 v2(140.42,77.27)
  IN4 w0.083: v2(129.44,150.96) 128,150.96 126.55,152.41 121.16,152.41 120.94,152.64 119.87,152.64 112.76,159.75 107.25,159.75 105.56,161.44 102.28,161.44 101.53,162.19 99.1,162.19 98.59,161.67 96.69,161.67 96.12,162.24 96.12,165.55 95.32,166.35 95.32,174.28 97.1,176.05 97.1,177.18 93.17,181.11 v2(93.17,182.81)
  BOTTOM w0.121: v1(92.49,181.79) 92.49,182.13 v2(93.17,182.81) ; SR7408.2 138.31,76.97 139.25,76.97 139.35,77.07 140.21,77.07 v2(140.42,77.27)
GPU_OVERT#: length 168.6
  TOP w0.102: R2364.2 235.18,41.33 v2(235.18,42.32)
  IN1 w0.102: v2(127.13,30.23) 127.49,30.23 128.73,28.99 140.74,28.99 143.58,26.16 196.56,26.16 205.01,34.6 205.72,34.6 209.38,38.26 209.38,40.76 209.96,41.35 209.96,42.12 211.18,43.34 234.17,43.34 v2(235.18,42.32)
  BOTTOM w0.102: SR7404.1 138.31,60.84 138.18,60.97 137.62,60.97 137.47,60.81 137.47,60.28 137.18,59.99 135.59,59.99 135.22,59.61 133.84,59.61 133.53,59.3 133.53,56.7 134.18,56.05 134.18,51.9 134.55,51.53 134.55,47.15 v1(131.86,44.46) 130.87,43.47 130.87,40.36 125.51,35 125.51,33.51 125.1,33.1 125.1,30.89 125.76,30.23 v2(127.13,30.23) ; v2(235.18,42.32) 235.34,42.48 235.34,44.85 234.88,45.31 234.88,45.57 234.02,46.44 234.02,47.53 233.97,47.58 U2000.AR45
GPU_OVERT#_R: length 11.7
  BOTTOM w0.102: SR7404.2 140.39,60.84 140.52,60.97 140.52,61.3 140.42,61.4 140.18,61.4 140.05,61.53 U7417.6 ; SR7404.2 139.9,60.41 140.1,60.21 141.37,60.21 141.7,60.54 142.16,60.54 142.81,59.89 142.81,59.55 142.57,59.32 142.4,59.32 142.31,59.23 142.31,58.13 143.3,57.15 U7413.6 ; SR7404.2 139.9,61.21 139.84,61.27 139.05,61.27 v1(138.54,61.78)
GPU_THERM_ALERT#: length 18
  TOP w0.102: v2(142.42,55.48) 142.14,55.48 v1(141.06,56.56) 140.27,57.36 140.27,60.89 v2(139.4,61.75)
  BOTTOM w0.102: v2(142.42,55.48) 142.79,55.85 U7413.4 ; SR7410.2 141.23,68.33 141,68.1 141,66.76 140.67,66.43 139.15,66.43 138.95,66.23 138.95,62.21 v2(139.4,61.75)
GSEN_INT_1: length 4.1
  TOP w0.102: U5800.5 305.68,133.65 R5805.2 306.13,132.49 v1(306.43,132.19)
GSEN_INT_2: length 6.5
  TOP w0.102: U5800.6 305.7,134.15 305.76,134.22 R5807.2 R5811.2 306.58,134.78 307.22,134.78 307.36,134.92 307.36,135.17 v1(308.01,135.82)
GSENSOR_INT1_PCH: length 169
  TOP w0.102: v2(307.64,133.4) 307.45,133.2 R5805.1 ; R2246.2 217.61,41.53 217.61,44.58 v1(218.07,45.05) 218.07,45.43 220.1,47.45 220.1,48.09 222,49.99 222.61,49.99 222.9,50.29 222.9,52.1 v2(223.6,52.8)
  IN3 w0.102: v2(307.64,133.4) 305.34,131.1 304.32,131.1 303.38,130.16 296.39,130.16 287.55,121.31 287.55,117.4 287.69,117.26 287.69,114.84 288.32,114.21 288.32,113.04 289.16,112.2 289.16,107.68 291.83,105.01 291.83,96.88 291.32,96.37 289.41,96.37 287.64,98.15 285.42,98.15 280.42,93.15 277.07,93.15 275.32,91.39 275.32,90.17 273.34,88.19 270.74,88.19 269.3,86.75 261.38,86.75 257.33,82.7 257.33,80.41 254.59,77.67 250.34,77.67 244.44,71.77 244.44,71.65 242.1,69.32 240.65,69.32 238.26,66.92 238.26,57.14 237.21,56.09 233.89,56.09 232.34,54.54 232.34,51.66 230.05,49.37 225,49.37 224.16,50.21 224.16,52.24 v2(223.6,52.8)
  BOTTOM w0.102: v2(223.6,52.8) 223.76,52.8 U2000.R35
