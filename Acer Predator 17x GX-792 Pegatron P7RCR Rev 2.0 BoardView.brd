# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+FBVDDQ_ENABLE: length 134.1
  IN2 w0.102: v2(236.89,79.42) 236.48,79.01 215.38,79.01 208.67,72.3 205.6,72.3 200.04,66.73 200.04,64.26 195.07,59.29 195.07,48.46 192.87,46.26 192.41,46.26 190.37,44.22 186.67,44.22 185.72,45.17 156.04,45.17 153.78,47.43 153.78,52.76 v2(151.09,55.46)
  BOTTOM w0.102: v2(236.89,79.42) 237.29,79.82 246.11,79.82 246.57,79.36 250.04,79.36 250.42,78.98 SR8902.1 ; v1(151.54,55.91) v2(151.09,55.46) 150.68,55.86 R7482.1 151.11,57.51 D7402.3
+LX:
  vias: v1(285.05,97.59)
+NVVDD: length 2.6
  TOP w0.432: R8748.1 v2(130.97,153.93)
  IN2 w0.102: 147.22,101.99 147.22,100.57
  BOTTOM w0.254: U7000.BC49 149.74,109.34 v3(149.74,109.28)
  vias: v1(153.46,159.25) v3(140.08,115.41) v3(140.08,114.52) v3(140.08,113.63) v3(140.08,112.74) v3(140.08,111.85) v3(140.1,110.95) v3(140.09,110.06) v3(140.27,109.17) v3(140.97,115.41) v3(140.97,114.52) v3(140.97,113.63) v3(140.97,112.74) v3(140.97,111.85) v3(140.97,110.97) v3(140.97,110.08) v3(140.98,109.14) v3(141.85,115.42) v3(141.85,114.56) v3(141.85,113.63) v3(141.85,112.74) v3(141.85,111.85) v3(141.85,110.97) v3(141.85,110.08) v3(141.89,109.18) v3(142.74,113.63) v3(142.74,112.74) v3(142.74,111.85) v3(142.74,110.97) v3(142.74,110.08) v3(142.74,108.61) v3(142.77,109.18) v3(143.66,112.74) v3(143.66,111.85) v3(144.81,109.3) v3(145.5,109.99) v3(146.21,109.3) v3(146.89,107.2) v3(147.61,107.88) v3(147.6,90.39) v3(148.27,107.22) v3(149,107.89) v3(149,105.09) v3(149.03,103.69) v3(149.65,105.8) v3(149.69,107.17) v3(150.35,105.1) v3(151.05,105.8) v3(151.11,103) v3(151.21,101.66) v3(151.75,103.7) v3(151.8,107.91) v3(151.77,105.06) v3(151.77,93.91) v3(152,96.43) v3(152.3,105.95) v3(152.5,106.5) v3(153.19,105.09) v3(153.19,103.72) v3(153.9,99.5) v3(153.88,98.8) v3(153.88,97.4) v3(153.89,96.01) v3(153.89,91.79) v3(153.9,90.4) v3(153.9,89.01) v3(154.55,103.7) v3(154.62,98.1) v3(155.3,102.29) v3(155.3,101.61) v3(155.3,100.18) v3(155.28,98.8) v3(155.28,97.4) v3(155.3,95.99) v3(155.3,95.31) v3(155.3,93.91) v3(155.3,92.49) v3(155.3,91.8) v3(155.3,90.41) v3(155.3,89.01) v3(155.3,87.59) v3(155.3,86.19) v3(155.3,85.5) v3(156.7,98.81) v3(156.7,97.39) v3(156.7,95.99) v3(156.7,91.8) v3(156.7,90.41) v3(156.7,89.01) v3(158.1,102.3) v3(158.1,101.6) v3(158.1,100.21) v3(158.1,98.79) v3(158.09,97.4) v3(158.11,96) v3(158.1,95.31) v3(158.1,93.91) v3(158.1,92.49) v3(158.1,91.8) v3(158.1,90.41) v3(158.1,89.01) v3(158.1,87.61) v3(158.1,86.19) v3(158.1,85.5) v3(159.51,98.8) v3(159.49,97.39) v3(159.49,90.41) v3(159.49,89.01) v3(160.2,87.6) v3(160.9,102.3) v3(160.9,101.6) v3(160.89,100.21) v3(160.89,96) v3(160.89,95.3) v3(160.89,93.91) v3(160.89,92.51) v3(160.89,91.8) v3(162.32,102.3) v3(162.3,96) v3(162.31,95.3) v3(162.29,93.89) v3(162.31,92.49) v3(162.31,91.8) v3(162.31,87.6) v3(162.3,86.2) v3(162.3,85.5) v3(163,101.6) v3(163.7,98.8) v3(163.71,97.41) v3(163.7,95.99) v3(163.7,91.8) v3(163.71,91.09) v3(163.71,90.41) v3(163.71,89.69) v3(163.7,89) v3(163.71,88.29) v3(165.11,102.29) v3(165.11,101.61) v3(165.11,100.21) v3(165.11,98.81) v3(165.11,97.39) v3(165.11,95.99) v3(165.11,95.31) v3(165.11,93.91) v3(165.11,92.49) v3(165.11,91.8) v3(165.11,90.41) v3(165.11,89.01) v3(165.11,87.61) v3(165.11,86.19) v3(165.11,85.5) v3(166.5,98.8) v3(166.5,97.39) v3(166.5,96) v3(166.5,91.8) v3(166.51,90.41) v3(166.49,88.99) v3(167.91,102.3) v3(167.91,101.6) v3(167.91,100.2) v3(167.91,98.8) v3(167.91,97.4) v3(167.91,96) v3(167.91,95.3) v3(167.91,93.9) v3(167.91,92.5) v3(167.91,91.8) v3(167.92,90.4) v3(167.92,89) v3(167.91,87.6) v3(167.91,86.2) v3(167.91,85.5) v3(168.61,89.7) v3(169.31,98.8) v3(169.31,97.4) v3(169.31,96) v3(169.31,91.8) v3(169.32,91.1) v3(169.31,89.7) v3(170.71,97.4) v3(170.71,90.4) v4(131.48,147.25) v4(131.48,146.36) v4(131.48,145.5) v4(131.48,144.63) v4(131.46,143.76) v4(132.35,143.79) v4(132.35,147.27) v4(132.35,146.38) v4(132.35,145.52) v4(132.35,144.66) v4(133.23,147.29) v4(133.23,146.35) v4(133.23,145.46) v4(133.23,144.6) v4(133.23,143.74) v4(138.28,118.09) v4(138.3,117.19) v4(138.3,116.3) v4(138.3,115.41) v4(139.19,118.08) v4(139.19,117.19) v4(139.19,116.3) v4(139.19,115.41) v4(139.19,114.52) v4(139.19,113.63) v4(139.21,112.76) v4(139.21,111.81) v4(139.24,110.93) v4(140.08,118.08) v4(140.08,117.19) v4(140.08,116.3) v4(140.97,118.08) v4(140.97,117.19) v4(140.97,116.3) v4(141.85,117.15) v4(141.85,116.29) v4(142.98,159.49) v4(142.98,158.6) v4(142.98,157.72) v4(142.98,156.83) v4(143.87,159.49) v4(143.87,158.6) v4(143.87,157.72) v4(143.87,156.83) v4(144.76,159.49) v4(144.76,158.6) v4(144.76,157.72) v4(144.76,156.83) v4(145.65,159.49) v4(145.65,158.6) v4(145.65,157.72) v4(145.65,156.83) v4(146.54,159.49) v4(146.54,158.6) v4(146.54,157.72) v4(146.54,156.83) v4(146.95,150.32) v4(146.95,149.44) v4(146.95,148.55) v4(146.95,147.66) v4(146.95,146.77) v4(146.95,145.88) v4(147.43,159.49) v4(147.43,158.6) v4(147.43,157.72) v4(147.43,156.83) v4(147.81,150.32) v4(147.83,149.44) v4(147.83,148.55) v4(147.83,147.66) v4(147.83,146.77) v4(147.83,145.88) v4(148.32,159.49) v4(148.32,158.6) v4(148.32,157.72) v4(148.32,156.83) v4(148.7,150.35) v4(148.7,149.46) v4(148.7,148.57) v4(148.7,147.68) v4(148.7,146.79) v4(148.7,145.9) v4(149.26,159.49) v4(149.26,158.6) v4(149.26,157.72) v4(149.26,156.83) v4(149.59,150.35) v4(149.59,149.46) v4(149.59,148.57) v4(149.59,147.68) v4(149.59,146.79) v4(149.59,145.9) v4(150.29,160.64) v4(150.29,159.75) v4(150.29,158.86) v4(150.29,157.97) v4(150.3,157.06) v4(150.48,150.35) v4(150.48,149.46) v4(150.48,148.57) v4(150.48,147.68) v4(150.48,146.79) v4(150.48,145.9) v4(151.17,160.64) v4(151.17,159.75) v4(151.17,158.86) v4(151.17,157.97) v4(151.36,150.35) v4(151.36,149.46) v4(151.36,148.57) v4(151.36,147.68) v4(151.36,146.79) v4(151.36,145.9) v4(152.06,160.64) v4(152.06,159.75) v4(152.06,158.86) v4(152.06,157.97) v4(152.25,150.35) v4(152.25,149.46) v4(152.25,148.57) v4(152.25,147.68) v4(152.25,146.79) v4(152.25,145.9) v4(153.14,150.35) v4(153.14,149.46) v4(153.14,148.57) v4(153.14,147.68) v4(153.14,146.79) v4(153.14,145.9) v4(157.46,160.64) v4(157.46,159.75) v4(157.46,158.86) v4(157.46,157.97) v4(158.35,160.64) v4(158.35,159.75) v4(158.35,158.86) v4(158.35,157.97) v4(159.24,160.64) v4(159.24,159.75) v4(159.24,158.86) v4(159.24,157.97) v4(160.13,160.64) v4(160.13,159.75) v4(160.13,158.86) v4(160.13,157.97) v4(161.02,160.64) v4(161.02,159.75) v4(161.02,158.86) v4(161.02,157.97) v4(162.03,160.64) v4(162.03,159.75) v4(162.06,158.86) v4(162.06,157.97) v4(163.02,160.64) v4(163.02,159.75) v4(163.05,158.86) v4(163.05,157.97) v4(164.06,160.64) v4(164.06,159.75) v4(164.06,158.86) v4(164.06,157.97) v4(164.95,160.64) v4(164.95,159.75) v4(164.95,158.86) v4(164.95,157.97) v4(170.29,160.64) v4(170.29,159.75) v4(170.29,158.86) v4(170.29,157.97) v4(170.26,151.42) v4(170.8,146.16) v4(171.18,160.64) v4(171.18,159.75) v4(171.18,158.86) v4(171.18,157.97) v4(171.15,151.42) v4(171.43,146.79) v4(172.07,160.64) v4(172.07,159.75) v4(172.09,158.86) v4(172.07,157.97) v4(172.09,146.16) v4(172.93,151.42) v4(172.93,150.53) v4(172.95,160.64) v4(172.95,159.75) v4(172.95,158.86) v4(172.95,157.97) v4(172.95,148.83) v4(172.95,147.94) v4(172.95,147.05) v4(172.95,146.16) v4(173.84,160.64) v4(173.84,159.75) v4(173.84,158.86) v4(173.84,157.97) v4(173.82,151.42) v4(173.82,150.53) v4(173.84,148.83) v4(173.84,147.94) v4(173.84,147.05) v4(173.84,146.16) v4(174.73,160.64) v4(174.73,159.75) v4(174.73,158.86) v4(174.73,157.97) v4(174.71,151.42) v4(174.71,150.53) v4(174.73,148.83) v4(174.73,147.94) v4(174.73,147.05) v4(174.73,146.16) v4(175.6,151.42) v4(175.6,150.53) v4(175.62,148.83) v4(175.62,147.94) v4(175.62,147.05) v4(175.62,146.16) v4(175.88,160.64) v4(175.88,159.75) v4(175.88,158.86) v4(175.88,157.97) v4(176.46,151.42) v4(176.49,150.53) v4(176.51,148.8) v4(176.51,147.91) v4(176.51,147.02) v4(176.49,146.16) v4(176.76,160.64) v4(176.76,159.75) v4(176.76,158.86) v4(176.76,157.97) v4(177.35,151.39) v4(177.35,150.53) v4(177.37,148.83) v4(177.37,147.94) v4(177.37,147.05) v4(177.37,146.18) v4(178.21,151.37) v4(178.21,150.5) v4(178.24,148.8) v4(178.24,147.91) v4(178.24,147.02) v4(178.24,146.16) v4(182.29,160.64) v4(182.29,159.75) v4(182.29,158.86) v4(182.29,157.97) v4(183.18,160.64) v4(183.18,159.75) v4(183.18,158.86) v4(183.18,157.97) v4(184.07,160.64) v4(184.07,159.75) v4(184.07,158.86) v4(184.07,157.97)
+NVVDD_ADD: length 3.1
  TOP w0.229: R8742.1 126.35,154.05 v1(126.35,155.05) 126.16,155.23 U8700.26
+NVVDD_COMP: length 5.2
  TOP w0.229: 128.2,155.79 127.77,156.22 U8700.30
  TOP w0.254: v1(130.28,155.33) 130.32,155.29 C8717.1 C8718.1 129.24,154.45 129.24,155.45 128.91,155.79 128.2,155.79
+NVVDD_CSCOMP: length 80.1
  TOP w0.229: 124.96,155.07 U8700.23
  TOP w0.254: R8740.2 124.67,152.48 v2(124.67,151.24) 124.54,151.24 R8738.1 C8714.1 C8715.1 124.44,154.03 124.96,154.56 124.96,155.07
  IN4 w0.254: v2(185.83,162.26) 184.71,162.26 184.23,161.78 148.13,161.78 147.23,160.88 136.85,160.88 132.45,156.47 130.05,156.47 128.84,155.25 128.84,152.99 129.95,151.87 129.95,150.76 129.54,150.35 125.76,150.35 124.87,151.24 v2(124.67,151.24)
  BOTTOM w0.254: R8739.1 v2(185.83,162.26)
  BOTTOM w0.508: v1(125.43,150.38) 125.43,150.48 v2(124.67,151.24)
+NVVDD_CSN1: length 68.8
  TOP w0.254: v1(119.49,154.06) 119.49,153.35 R8730.2 120.12,153.63 v2(120.12,153.78)
  IN3 w0.203: v2(178.03,164.57) 176.73,164.57 174.24,162.08 149.1,162.08 147.79,160.77 135,160.77 133.54,162.24 131.08,162.24 128.06,159.21 126.6,159.21 126.37,159.44 125.83,159.44 120.17,153.78 v2(120.12,153.78)
  BOTTOM w0.229: JP8702.2 179.43,164.24 179.1,164.57 v2(178.03,164.57)
+NVVDD_CSN2: length 39.4
  TOP w0.254: R8729.2 118.7,154.9 119.23,155.43 v2(119.36,155.43)
  IN4 w0.254: v2(140.19,163.81) 140.06,163.94 136.12,163.94 133.31,166.76 128.89,166.76 128.28,167.37 119.79,167.37 118.73,166.31 118.73,156.19 119.36,155.56 v2(119.36,155.43)
  BOTTOM w0.229: JP8704.2 v2(140.19,163.81)
  BOTTOM w0.508: v1(117.22,155.61) 117.38,155.44 118.21,155.44 118.22,155.43 v2(119.36,155.43)
+NVVDD_CSN3: length 49
  TOP w0.254: v2(119.41,156.57) 119.41,156.57 118.62,155.79 R8728.2
  IN3 w0.203: v2(153.52,164.45) 153.37,164.6 149.89,164.6 147.28,161.99 135.51,161.99 133.46,164.04 126.32,164.04 124.77,162.49 121.47,162.49 118.85,159.87 118.85,156.92 119.2,156.57 v2(119.41,156.57)
  BOTTOM w0.229: v2(153.52,164.45) 154.54,164.45 154.69,164.29 JP8706.2
  BOTTOM w0.508: v2(119.41,156.57) 118.48,157.5 v1(117.35,157.5)
+NVVDD_CSN4: length 57.4
  TOP w0.254: R8727.2 118.93,157.72 v2(119.49,157.72)
  IN3 w0.203: v2(166.48,164.57) 165.78,163.88 165.78,163.37 165.11,162.69 148.85,162.69 147.53,161.38 135.26,161.38 133.43,163.2 127.92,163.2 125.81,161.09 124.17,161.09 120.29,157.21 119.96,157.21 119.49,157.68 v2(119.49,157.72)
  BOTTOM w0.229: JP8708.2 167.62,164.32 167.37,164.57 v2(166.48,164.57)
  BOTTOM w0.508: v1(119.41,158.43) 119.41,157.79 v2(119.49,157.72)
+NVVDD_CSP1: length 6.1
  TOP w0.229: R8724.1 122.15,154.41 122.59,154.85 123.07,154.85 123.55,155.33 123.68,155.33 v1(123.7,155.35) 123.7,156.37 123.62,156.45 U8700.20
  TOP w0.254: R8764.1 120.94,153.58 C8705.2 121.39,154.24 R8724.1
+NVVDD_CSP2: length 9.6
  TOP w0.229: v1(118.07,152.05) 118.27,152.25 R8765.1 C8706.2 118.42,154.13 118.73,154.13 119.51,154.92 121.01,154.92 121.57,155.48 R8723.1 122.84,155.51 123.1,155.76 123.1,157.14 123.29,157.34 U8700.19
+NVVDD_CSP3: length 7.3
  TOP w0.229: R8766.1 C8707.2 118.65,156.67 119.04,157.07 121.1,157.07 R8722.1 v1(122.49,156.6) 122.74,156.85 122.74,157.25 123.23,157.74 U8700.18
+NVVDD_CSP4: length 7
  TOP w0.229: R8767.1 C8708.2 118.73,159.21 v1(119.59,158.35) 119.78,158.16 121.1,158.16 R8721.1 122.71,157.69 123.16,158.14 U8700.17
+NVVDD_CSP5: length 7.4
  TOP w0.229: C8709.2 118.67,160.97 119.16,160.47 v1(119.16,160.08) 119.16,159.72 119.68,159.2 121.1,159.2 R8719.2 121.57,158.47 122.02,158.02 122.58,158.02 123.09,158.54 U8700.16
+NVVDD_CSP6: length 8.7
  TOP w0.229: U8700.15 123.61,158.93 122.76,158.93 v1(122.48,158.65) 122,159.13 122,159.6 R8720.2 121.09,159.54 119.94,159.54 119.65,159.83 119.65,160.45 118.55,161.55 118.04,161.55 117.58,162.01 C8710.2
+NVVDD_CSP7: length 7.5
  TOP w0.229: C8711.2 118.95,161.7 119.08,161.7 v2(119.31,161.47) 119.34,161.47 119.45,161.36 121.1,161.36 R8717.2 121.9,160.89 122.28,160.51 122.28,160.18 123.13,159.33 123.61,159.33 U8700.14
  BOTTOM w0.508: v2(119.31,161.47) 119.51,161.68 v1(119.51,162.36)
+NVVDD_CSP8: length 6.3
  TOP w0.229: C8712.2 119.86,161.69 120.92,161.69 R8718.2 122.18,161.47 v1(122.46,161.47) 122.66,161.27 122.66,160.28 123.21,159.73 123.61,159.73 U8700.13
+NVVDD_CSREF: length 24.6
  TOP w0.229: C8713.1 122.28,154.03 122.76,154.52 123.26,154.52 123.59,154.85 124.09,154.85 124.21,154.97 124.21,155.86 124.16,155.91 U8700.21
  TOP w0.254: R8767.2 C8709.1 117.41,161.09 116.78,161.72 116.78,162.4 117.41,163.02 C8710.1 C8711.1 C8712.1 ; R8767.2 C8708.1 R8727.1 R8766.2 C8707.1 R8728.1 R8729.1 C8706.1 R8765.2 117.41,151.92 117.79,151.54 118.29,151.54 119.06,152.31 R8730.1 R8764.2 120.99,152.31 C8705.1 121.42,152.71 C8713.1 ; R8767.2 v1(116.52,160.05)
+NVVDD_CSSUM: length 13.1
  TOP w0.229: R8737.2 C8714.2 v2(123.25,153.27) C8715.2 123.73,154.52 124.29,154.52 124.56,154.79 U8700.22
  BOTTOM w0.254: v1(122.82,154.95) 123.25,154.52 v2(123.25,153.27) 122.69,153.27 R8731.1 R8732.1 R8733.1 122.16,156.84 122.16,157.63 R8734.1
+NVVDD_DIFF: length 4.7
  TOP w0.229: 127.15,155.49 126.96,155.67 U8700.28
  TOP w0.254: 127.15,155.49 v1(128.25,154.39) 127.73,153.86 R8745.2 127.73,152.89 127.78,152.84 R8746.2
+NVVDD_DRON: length 81.2
  TOP w0.229: v1(120.25,165.51) 120.25,165.31 v2(120.63,164.93) 120.63,163.56 121.14,163.05 121.39,163.05 122.12,162.33 122.33,162.33 123.04,161.61 123.04,160.38 123.29,160.14 U8700.12
  TOP w0.279: U8703.3 v2(145.7,165.59) ; U8702.3 v2(185.14,164.82) ; U8704.3 v2(160.12,165.59) ; U8705.3 v2(173.08,165.59)
  IN4 w0.254: v2(120.63,164.93) 131.58,164.93 133.85,162.66 142.59,162.66 145.52,165.59 v2(145.7,165.59) 147.18,165.59 149.1,163.66 154.57,163.66 155.99,165.08 158.53,165.08 159.03,165.59 v2(160.12,165.59) 161.53,165.59 163.61,163.51 167.29,163.51 168.87,165.08 170.41,165.08 170.92,165.59 v2(173.08,165.59) 177.14,165.59 177.91,166.35 183.61,166.35 v2(185.14,164.82)
+NVVDD_FB: length 10.2
  TOP w0.229: U8700.29 127.36,155.81
  TOP w0.254: C8718.2 129.6,153.23 R8744.2 ; 127.36,155.81 127.74,155.43 128.66,155.43 128.76,155.33 128.76,153.57 R8745.1 128.67,153.32 C8719.1 R8744.2 ; R8744.2 129.62,152.43 129.93,152.13 129.93,150.76 129.64,150.48 129.06,150.48 v1(128.9,150.64)
+NVVDD_FSW: length 8.3
  TOP w0.229: R8743.1 126.85,153.58 127.23,153.2 127.23,150.82 126.76,150.35 125.76,150.35 v1(125.51,150.1) ; U8700.27 126.56,155.68
  TOP w0.254: 126.56,155.68 126.56,155.57 127.21,154.92 127.21,154.02 R8743.1
+NVVDD_ILIM: length 5.2
  TOP w0.229: v1(125.25,151.82) 125.38,151.94 125.38,153.42 125.23,153.58 R8740.1 124.9,153.98 125.37,154.45 U8700.24
+NVVDD_IOUT: length 4.8
  TOP w0.229: v2(125.84,154.36) 125.77,154.44 U8700.25
  BOTTOM w0.432: v2(125.84,154.36) C8716.1 R8741.1 v1(127.77,153.58)
+NVVDD_PGOOD: length 3.2
  TOP w0.102: U8700.38 128.75,159.74 128.94,159.93 129,159.93 v1(129.33,160.26) 130.12,161.05 130.12,161.15 SR8704.2
+NVVDD_PSI: length 5.2
  TOP w0.203: U8700.37 129.02,159.34
  TOP w0.432: R8704.2 R8703.2 131.41,159.71 v1(131.22,159.9) 130.91,159.58 SR8702.2 129.26,159.58 129.02,159.34
+NVVDD_PWM1: length 73
  TOP w0.229: U8700.11 123.62,161.5 122.41,162.71 122.24,162.71 v2(121.27,163.68) R8716.1
  TOP w0.279: U8702.2 185.02,164.32 v2(185.15,164.19)
  IN4 w0.254: v2(121.27,163.68) 122.26,162.69 127.84,162.69 128.43,162.11 130.72,162.11 131.6,161.23 147.03,161.23 147.96,162.16 183.97,162.16 185.15,163.33 v2(185.15,164.19)
  BOTTOM w0.508: v2(121.27,163.68) 120.94,164.01 v1(120.94,164.27)
+NVVDD_PWM2: length 31.3
  TOP w0.229: U8700.10 124.16,161.42 122.41,163.18 v2(122.41,163.3) 122.41,164.01 R8715.1
  TOP w0.279: v2(145.7,164.95) 145.57,165.09 U8703.2
  IN4 w0.254: v2(122.41,163.3) 122.41,163.56 123.17,164.32 131.69,164.32 133.7,162.3 143.04,162.3 v2(145.7,164.95)
  BOTTOM w0.508: v2(122.41,163.3) 122.21,163.1 v1(122.21,162.69)
+NVVDD_PWM3: length 44.9
  TOP w0.229: U8700.9 124.56,161.5 123.04,163.02 v2(123.04,163.3) R8714.1
  TOP w0.279: v2(160.13,164.95) 160,165.09 U8704.2
  IN4 w0.254: v2(123.04,163.3) 123.04,163.43 123.42,163.81 131.69,163.81 133.56,161.94 146.63,161.94 147.61,162.92 158.1,162.92 v2(160.13,164.95)
  BOTTOM w0.508: v2(123.04,163.3) 123.22,163.48 v1(123.22,164.12)
+NVVDD_PWM4: length 56.3
  TOP w0.229: U8700.8 124.96,161.57 124.19,162.35 v2(124.19,163.3) 124.19,164.01 R8713.1
  TOP w0.279: U8705.2 172.95,165.09 v2(173.08,164.95)
  IN4 w0.254: v2(124.19,163.3) 131.7,163.3 133.41,161.59 146.86,161.59 147.81,162.54 170.67,162.54 v2(173.08,164.95)
  BOTTOM w0.508: v1(124.47,162.54) 124.47,163.02 v2(124.19,163.3)
+NVVDD_PWM5: length 3.5
  TOP w0.229: R8712.2 124.82,162.71 v1(124.68,162.57) 125.37,161.88 U8700.7
+NVVDD_PWM6: length 4.9
  TOP w0.229: U8700.6 125.77,162.15 v2(125.8,162.19) 125.28,162.71 125.28,163.84 R8711.2
  BOTTOM w0.508: v1(125.99,163.43) 125.99,162.37 v2(125.8,162.19)
+NVVDD_PWM7: length 3.5
  TOP w0.229: R8763.2 126.24,163.91 v1(126.24,163.35) 126.37,163.22 126.37,161.75 126.16,161.54 U8700.5
+NVVDD_PWM8: length 4.1
  TOP w0.229: U8700.4 126.56,161.48 126.7,161.61 126.7,162.34 127.4,163.04 127.63,163.04 v1(127.97,163.38) 127.97,163.78 R8762.2
+NVVDD_PWM_VID: length 3.9
  TOP w0.229: U8700.39 128.31,160.13 128.66,160.13 128.84,160.31 128.84,161.2 v1(129.65,162.01) 129.83,162.19 130.15,162.19 SR8703.2
+NVVDD_REFADJ: length 2.7
  TOP w0.203: v2(128.31,161.27) 128.31,160.54 U8700.40
  BOTTOM w0.432: v1(127.34,161.07) 127.54,161.27 v2(128.31,161.27) 128.31,160.85 128.25,160.79 R8705.1
+NVVDD_REFIN: length 5
  TOP w0.229: v2(127.87,161.91) 127.77,161.8 U8700.1
  BOTTOM w0.254: 130.16,161.91 129.27,161.91 ; 129.27,161.91 v2(127.87,161.91) 127.87,162.59 T8700.1 ; 129.27,161.91 R8707.2
+NVVDD_SCL: length 5.8
  TOP w0.114: R8701.2 132.92,158.66 132.72,158.86 131.3,158.86 131.13,158.69 SR8706.2 130.28,158.35 v1(130.11,158.53) 130.1,158.54 U8700.35
+NVVDD_SDA: length 7
  TOP w0.121: v1(133.74,156.83) 133.79,156.88 133.79,157.51 R8702.2 133.51,157.79 131.25,157.79 131.13,157.68 SR8701.2 130.66,157.33 129.86,158.14 U8700.34
+NVVDD_SWN1: length 70.7
  TOP w0.254: R8724.2 v2(120.1,154.41)
  IN3 w0.203: v2(178.03,165.21) 177.78,164.95 176.68,164.95 174.11,162.39 148.98,162.39 147.66,161.07 135.13,161.07 133.66,162.54 130.96,162.54 127.93,159.52 126.73,159.52 126.5,159.75 125.71,159.75 120.38,154.41 v2(120.1,154.41)
  BOTTOM w0.229: JP8701.2 179.43,165.34 179.3,165.21 v2(178.03,165.21)
  BOTTOM w0.254: v1(122.15,152.89) 121.8,152.89 121.3,153.39 121.3,153.8 R8731.2 120.68,154.41 v2(120.1,154.41)
+NVVDD_SWN2: length 41.8
  TOP w0.254: R8723.2 120.22,155.51 v2(120.12,155.4) 119.77,155.76 v1(119.77,155.99)
  IN4 w0.254: v2(140.19,164.57) 139.93,164.32 136.28,164.32 133.46,167.14 129.06,167.14 128.48,167.72 119.64,167.72 118.34,166.43 118.34,155.71 119.11,154.95 119.67,154.95 v2(120.12,155.4)
  BOTTOM w0.229: JP8703.2 v2(140.19,164.57)
  BOTTOM w0.254: R8732.2 120.22,155.3 v2(120.12,155.4)
+NVVDD_SWN3: length 50.1
  TOP w0.254: R8722.2 v2(120.1,156.6)
  IN3 w0.203: v2(120.1,156.6) 119.56,156.06 119.28,156.06 118.54,156.8 118.54,160.01 121.33,162.8 124.57,162.8 126.12,164.35 133.58,164.35 135.63,162.3 147.09,162.3 149.74,164.95 153.42,164.95 v2(153.53,165.07)
  BOTTOM w0.229: JP8705.2 154.69,165.36 154.4,165.07 v2(153.53,165.07)
  BOTTOM w0.254: R8733.2 v2(120.1,156.6) 120.1,156.57 119.61,156.09 v1(118.95,156.09)
+NVVDD_SWN4: length 57.3
  TOP w0.254: R8721.2 v2(120.12,157.69)
  IN3 w0.203: v2(120.12,157.69) 120.34,157.69 124.05,161.4 125.69,161.4 127.79,163.51 127.82,163.51 127.87,163.56 133.51,163.56 135.38,161.68 147.41,161.68 148.72,163 164.9,163 165.46,163.56 165.46,164.27 166.4,165.21 v2(166.48,165.21)
  BOTTOM w0.229: v2(166.48,165.21) 167.37,165.21 167.62,165.46 JP8707.2
  BOTTOM w0.254: v1(121.37,159.01) 121.06,158.71 R8734.2 120.3,157.87 v2(120.12,157.69)
+NVVDD_VCC: length 4.9
  TOP w0.229: v2(129.52,157.59) 129.37,157.74 U8700.33
  BOTTOM w0.508: R8749.2 C8721.1 129.1,157.17 v2(129.52,157.59) v1(130.21,157.59)
+NVVDD_VREF: length 8.6
  TOP w0.229: U8700.2 127.36,162.07 127.68,162.38 128.06,162.38 128.41,162.03 128.96,162.03 130.16,163.23 C8703.1
  TOP w0.254: v1(132.39,163.35) 131.35,163.35 131.04,163.66 R8706.1 C8703.1
+NVVDD_VRMP: length 7.9
  TOP w0.102: v1(130.21,166.61) 129.7,166.1 129.7,164.7 R8710.2
  TOP w0.229: R8710.2 C8704.1 128.61,164.04 128.61,163.31 128.01,162.71 127.54,162.71 127.03,162.2 127.03,161.48 126.96,161.41 U8700.3
+NVVDD_VRON: length 9.7
  TOP w0.102: U8700.36 129.47,158.94 v2(129.52,158.99)
  BOTTOM w0.432: R8700.2 124.49,159.32 125.3,160.13 D8701.1
  BOTTOM w0.508: D8701.1 126.12,160.13 126.76,159.48 C8768.1 127.65,158.6 T8702.1 129.14,158.6 v2(129.52,158.99)
+NVVDD_VSN: length 6.2
  TOP w0.229: U8700.32 128.99,157.34 129.29,157.03
  TOP w0.254: 129.29,157.03 v1(129.43,156.89) 130.6,156.89 130.99,156.5 C8720.2 131.53,156.5 R8747.2 132.58,155.44 132.82,155.44 SR8707.1
+NVVDD_VSP: length 7.5
  TOP w0.229: U8700.31 128.57,156.94 129.57,155.94
  TOP w0.254: R8748.2 132.09,154.31 132.09,153.09 v1(132.01,153.02) ; R8748.2 SR8708.1 ; R8748.2 131.22,155.23 C8720.1 131.1,155.63 130.79,155.94 129.57,155.94
+NVVDDS: length 63.6
  TOP w0.432: v2(194.24,189.39) 194.75,189.9 R9720.2
  IN3 w0.508: 200.01,151.87 200.39,152.25 206.74,152.25 207.76,153.27 209.15,153.27 209.63,153.75 209.63,170.29 206.64,173.29 206.64,186.42 206.03,187.03 206.03,191.22 205.24,192.01 200.13,192.01 198.69,190.56 195.41,190.56 v2(194.24,189.39)
  vias: v3(153.19,103) v3(153.91,101.61) v3(153.9,95.3) v3(153.9,93.9) v3(153.9,92.5) v3(153.9,87.59) v3(153.9,86.19) v3(153.9,85.5) v3(156.7,102.29) v3(156.7,101.61) v3(156.7,100.21) v3(156.7,95.31) v3(156.7,93.89) v3(156.7,92.49) v3(156.7,87.59) v3(156.7,86.19) v3(156.7,85.5) v3(159.5,102.3) v3(159.49,101.61) v3(159.49,100.21) v3(159.49,95.99) v3(159.51,95.3) v3(159.5,93.9) v3(159.5,92.5) v3(159.49,91.8) v3(159.49,87.61) v3(159.49,86.19) v3(159.49,85.5) v3(161.58,102.3) v3(161.6,101.6) v3(161.6,100.2) v3(161.6,95.3) v3(161.6,92.49) v3(161.61,87.59) v3(161.61,86.21) v3(161.6,85.5) v3(163.7,102.3) v3(163.7,101.6) v3(163.7,100.2) v3(163.7,95.3) v3(163.7,93.9) v3(163.7,92.5) v3(163.7,87.6) v3(163.71,86.21) v3(163.7,85.5) v3(166.5,102.3) v3(166.51,101.61) v3(166.51,100.21) v3(166.5,95.3) v3(166.5,93.9) v3(166.5,92.5) v3(166.51,87.61) v3(166.5,86.2) v3(166.5,85.5) v3(169.31,102.3) v3(169.31,101.6) v3(169.31,100.2) v3(169.31,95.3) v3(169.31,93.9) v3(169.31,92.5) v3(169.31,87.6) v3(169.31,86.2) v3(169.31,85.5) v4(194.77,151.54) v4(194.77,150.65) v4(194.77,149.77) v4(194.77,148.88) v4(194.77,147.99) v4(194.77,147.1) v4(195.18,156.86) v4(195.18,155.98) v4(195.18,155.09) v4(195.18,154.2) v4(195.66,151.54) v4(195.66,150.65) v4(195.66,149.77) v4(195.66,148.88) v4(195.66,147.99) v4(195.66,147.1) v4(196.07,156.86) v4(196.07,155.98) v4(196.07,155.09) v4(196.07,154.2) v4(196.55,151.54) v4(196.55,150.65) v4(196.55,149.77) v4(196.55,148.88) v4(196.55,147.99) v4(196.55,147.1) v4(196.96,156.86) v4(196.96,155.98) v4(196.96,155.09) v4(196.96,154.2) v4(197.44,151.54) v4(197.44,150.65) v4(197.44,149.77) v4(197.44,148.88) v4(197.44,147.99) v4(197.44,147.1) v4(198.62,156.84) v4(198.62,155.95) v4(198.62,155.06) v4(198.62,154.17) v4(199.24,147.48) v4(199.51,156.84) v4(199.51,155.95) v4(199.51,155.06) v4(199.51,154.17) v4(200.13,147.48) v4(200.4,156.84) v4(200.4,155.95) v4(200.4,155.06) v4(200.4,154.17)
+NVVDDS_BOOT1:
  vias: v1(203.74,186.21)
+NVVDDS_BOOT1_R:
  vias: v1(203.79,184.26)
+NVVDDS_BOOT2: length 2.3
  TOP w0.203: SR9709.1 196.74,186.53 196.58,186.7 195.64,186.7 195.31,186.37 v1(194.98,186.37)
+NVVDDS_BOOT2_R: length 1.2
  TOP w0.508: v1(195.99,183.75) 195.91,183.84 C9704.1
+NVVDDS_LGATE1: length 24
  TOP w0.508: v1(203.71,172.07) 203.71,172.65 v4(203.54,172.83)
  TOP w0.762: 200.64,184.39 200.64,183.62 201.18,183.08 v4(204.58,183.08)
  IN4 w0.762: v4(209.4,172.78) 209.35,172.83 v4(203.54,172.83) 202.67,172.83 202.16,173.34 202.16,175.5 203.69,177.02 203.69,182.2 v4(204.58,183.08)
+NVVDDS_LGATE2: length 21.8
  TOP w0.508: v1(191.29,172.96) 191.29,173.11 v4(191.88,173.7)
  IN4 w0.762: v4(191.88,173.7) 192.92,172.65 v4(197.92,172.65) 198.81,172.65 199.37,173.21 v4(199.37,185.02)
  BOTTOM w0.508: Q9706.4 v4(191.88,173.7)
+NVVDDS_PHASE1: length 18.8
  IN1 w0.762: v4(201.78,185.4) 201.4,185.02 v4(201.4,166.73)
  vias: v4(199.62,166.73) v4(199.62,165.84) v4(199.62,164.95) v4(199.62,164.07) v4(200.51,166.73) v4(200.51,165.84) v4(200.51,164.95) v4(200.54,164.07) v4(201.4,165.84) v4(201.4,164.95) v4(201.43,164.07) v4(206.61,166.61) v4(206.64,165.72) v4(206.64,164.83) v4(206.61,163.94) v4(207.52,166.61) v4(207.52,165.72) v4(207.52,164.83) v4(207.5,163.94) v4(208.39,166.61) v4(208.39,165.72) v4(208.39,164.83) v4(208.39,163.94)
+NVVDDS_PHASE2: length 19.5
  IN1 w0.762: v4(198.1,185.02) 198.1,179.05 196.09,177.05 196.09,170.26 197.75,168.61 v4(197.75,166.99)
  vias: v4(195.08,166.99) v4(195.08,166.1) v4(195.08,165.21) v4(195.08,164.32) v4(195.21,163.43) v4(195.97,166.99) v4(195.97,166.1) v4(195.97,165.21) v4(195.97,164.32) v4(196.09,163.43) v4(196.86,166.99) v4(196.86,166.1) v4(196.86,165.21) v4(196.86,164.32) v4(196.98,163.43) v4(197.75,166.1) v4(197.75,165.21) v4(197.75,164.32) v4(197.87,163.43)
+NVVDDS_PSI_R: length 4.6
  TOP w0.229: v2(202.14,188.35) 202.01,188.21 U9700.4
  TOP w0.432: SR9710.2 R9724.2 R9725.1
  TOP w0.508: R9725.1 203.5,188.35 v2(202.14,188.35)
  BOTTOM w0.508: v2(202.14,188.35) 202.11,188.32 v1(202.11,187.71)
+NVVDDS_REFADJ: length 4
  TOP w0.203: R9723.1 202.61,191.28 v1(202.61,190.38) 202.61,190.37 201.45,189.21 U9700.6
+NVVDDS_REFIN: length 12.3
  TOP w0.203: U9700.7 200.41,189.61 200.64,189.85 201.28,189.85 v2(201.91,190.48)
  TOP w0.254: R9716.2 R9713.2 v2(207.52,191.68) 207.83,191.98 v1(208.13,191.98)
  IN1 w0.254: v2(201.91,190.48) 202.8,191.37 207.22,191.37 v2(207.52,191.68)
  BOTTOM w0.432: v2(201.91,190.48) 201.68,190.48 201.2,190 C9703.1
+NVVDDS_UGATE1:
  vias: v1(202.24,187.23)
+NVVDDS_UGATE1_R: length 16.1
  TOP w0.508: v4(203.59,173.97) 203.59,174 203.94,174.35 Q9701.4
  TOP w0.762: v4(204.83,184.89) 204.83,187.18
  IN4 w0.762: v4(204.83,184.89) 205.97,183.75 205.97,176.36 v4(203.59,173.97)
  vias: v1(204.35,173.74)
+NVVDDS_UGATE2:
  vias: v1(197.67,187.43)
+NVVDDS_UGATE2_R: length 16.8
  TOP w0.508: v1(198.56,173.21) 198.56,173.39 v4(197.97,173.97) Q9704.4
  IN4 w0.762: v4(195.05,187.31) 196.48,185.88 196.48,175.47 v4(197.97,173.97)
+NVVDDS_VCCP: length 3.7
  TOP w0.203: U9700.18 v2(200.01,185.53)
  BOTTOM w0.432: v2(200.01,185.53) 200.1,185.53 C9709.1 R9710.2
  BOTTOM w0.508: v1(199.4,185.86) 199.68,185.86 v2(200.01,185.53)
+NVVDDS_VREF: length 9.2
  TOP w0.203: R9721.1 206.1,192.44 202.39,192.44 v1(201.96,192.01) 201.83,191.88 R9728.2 200.21,191.02 C9721.1 200.21,190.3 200.01,190.1 U9700.8
+NVVDDS_VRON: length 11.6
  TOP w0.102: v1(209.48,186.98) 208.61,187.84 D9700.1 208.01,186.93 207.63,186.54 205.85,186.54 C9713.1 ; C9713.1 R9701.2 ; C9713.1 205.52,187.51 205.21,187.81 203.38,187.81 203.26,187.69 201.86,187.69 201.73,187.81 U9700.3
+RTC_POWER: length 36.8
  TOP w0.216: C8117.1 258.54,59.42 258.79,59.67 U8100.3
  TOP w0.457: T8107.1 256.84,58.82 257.65,58.82 257.79,58.96 257.79,59.11 C8117.1
  TOP w0.508: T8107.1 256.55,58.22 v2(256.55,57.7) 256.23,57.38 JP8106.1
  IN3 w0.508: v2(277.48,67.42) 275.44,67.42 273.62,65.59 273.62,63.79 270.15,60.33 270.15,59.58 265.85,55.28 263.12,55.28 259.85,58.55 258.98,58.55 258.44,59.1 257.42,59.1 256.55,58.23 v2(256.55,57.7)
  BOTTOM w0.508: v2(277.48,67.42) 277.48,66.66 D2801.1
+V_SM_VREF_R: length 3
  TOP w0.203: U8300.4 26.01,49.11 25.25,48.36 C8303.1 23.87,48.36 v1(23.73,48.22)
+VCORE: length 38.4
  TOP w0.254: R80112.1 58.98,186.21 v2(59.06,186.29)
  IN1 w0.102: 96.75,114.97 97.14,114.97
  IN3 w0.102: 106.69,120.67 107.04,120.67
  IN3 w0.254: v2(59.06,186.29) 59.82,185.53 63.68,185.53 69.12,180.09 79.09,180.09 83.19,176 83.19,174.07 85.02,172.24 v2(87.36,172.24)
  IN4 w0.102: 108.47,125.33 108.47,124.93
  BOTTOM w0.203: U0300.AF35 v3(97.06,128.38)
  vias: v1(87.43,169.7) v3(97.06,129.69) v3(97.06,129.03) v3(97.93,121.11) v3(97.93,120.55) v3(97.93,119.77) v3(97.93,119.21) v3(97.93,118.45) v3(97.93,117.89) v3(97.93,117.26) v3(97.93,116.7) v3(98.19,122.67) v3(98.19,121.9) v3(98.19,111.51) v3(98.63,129.03) v3(98.63,128.38) v3(98.63,127.73) v3(98.63,125.79) v3(98.63,125.14) v3(98.95,115.35) v3(98.95,114.59) v3(98.95,113.82) v3(98.95,113.19) v3(98.95,112.55) v3(99.06,111.52) v3(99.2,121.11) v3(99.2,120.55) v3(99.2,119.77) v3(99.2,119.21) v3(99.2,118.45) v3(99.2,117.89) v3(99.2,117.26) v3(99.2,116.7) v3(99.42,129.03) v3(99.42,128.38) v3(99.42,127.73) v3(99.42,125.79) v3(99.42,125.14) v3(99.46,123.55) v3(99.46,122.79) v3(99.46,122.03) v3(100.01,111.52) v3(100.91,111.54) v3(100.99,129.03) v3(100.99,128.38) v3(100.99,127.73) v3(100.99,125.78) v3(100.99,125.13) v3(101.78,129.03) v3(101.78,128.38) v3(101.78,127.73) v3(101.78,125.78) v3(101.78,125.13) v3(102.13,115.35) v3(102.13,114.59) v3(102.13,113.82) v3(102.13,113.19) v3(102.13,112.55) v3(102.75,111.52) v3(103.35,129.03) v3(103.35,128.38) v3(103.35,127.73) v3(103.35,125.78) v3(103.35,125.13) v3(103.78,123.55) v3(103.78,122.79) v3(103.78,122.03) v3(104.14,129.03) v3(104.14,128.38) v3(104.14,127.73) v3(104.14,125.78) v3(104.14,125.14) v3(104.06,121.11) v3(104.06,120.55) v3(104.06,119.77) v3(104.06,119.21) v3(104.06,118.57) v3(104.06,118.01) v3(104.06,117.38) v3(104.06,116.82) v3(104.57,111.52) v3(105.3,122.79) v3(105.3,122.03) v3(105.5,111.52) v3(105.55,121.11) v3(105.55,120.55) v3(105.55,119.77) v3(105.55,119.21) v3(105.55,118.57) v3(105.55,118.01) v3(105.55,117.38) v3(105.55,116.82) v3(105.55,115.35) v3(105.55,114.59) v3(105.55,113.82) v3(105.55,113.19) v3(105.55,112.55) v3(105.72,129.03) v3(105.72,128.38) v3(105.72,127.73) v3(105.72,125.78) v3(105.72,125.14) v3(106.41,111.52) v3(106.5,129.03) v3(106.5,128.38) v3(106.5,127.73) v3(106.5,125.78) v3(106.5,125.14) v3(108.7,114.39) v3(108.7,113.83) v3(108.7,113.27) v3(108.7,112.66) v4(83.29,168.13) v4(83.29,167.27) v4(83.29,166.4) v4(83.29,165.54) v4(83.55,161.07) v4(83.55,160.2) v4(83.55,159.34) v4(83.55,158.48) v4(83.55,153.27) v4(83.55,152.41) v4(84.18,168.13) v4(84.18,167.27) v4(84.18,166.4) v4(84.18,165.54) v4(84.44,161.07) v4(84.44,160.2) v4(84.44,159.34) v4(84.44,158.48) v4(84.44,153.27) v4(84.44,152.41) v4(85.07,168.13) v4(85.07,167.27) v4(85.07,166.4) v4(85.07,165.54) v4(85.32,161.07) v4(85.32,160.2) v4(85.32,159.34) v4(85.32,158.48) v4(85.32,153.27) v4(85.32,152.41) v4(85.58,164.57) v4(85.58,163.71) v4(85.58,162.85) v4(85.58,161.98) v4(85.63,157.64) v4(85.63,156.75) v4(85.63,155.86) v4(85.63,154.97) v4(85.63,154.08) v4(85.96,168.13) v4(85.96,167.27) v4(85.96,166.4) v4(85.96,165.54) v4(86.21,161.07) v4(86.21,160.2) v4(86.21,159.34) v4(86.21,158.48) v4(86.47,164.57) v4(86.47,163.71) v4(86.47,162.85) v4(86.47,161.98) v4(86.52,157.64) v4(86.52,156.75) v4(86.52,155.86) v4(86.85,168.13) v4(86.85,167.27) v4(86.85,166.4) v4(86.85,165.54) v4(87.1,161.07) v4(87.1,160.18) v4(87.36,164.57) v4(87.36,163.71) v4(87.36,162.85) v4(87.36,161.98) v4(87.74,168.13) v4(87.74,167.27) v4(87.74,166.4) v4(87.74,165.54) v4(91.75,136.3) v4(92.28,138.34) v4(92.28,137.45) v4(92.77,136.3) v4(93.3,138.34) v4(93.3,137.45) v4(93.73,136.58) v4(93.73,135.69) v4(93.73,134.8) v4(94.32,138.34) v4(94.32,137.45) v4(94.75,136.58) v4(94.75,135.69) v4(94.75,134.8) v4(95.18,133.71) v4(95.33,138.34) v4(95.33,137.45) v4(95.76,136.58) v4(95.76,135.69) v4(95.76,134.8) v4(96.2,133.71) v4(96.35,138.34) v4(96.35,137.45) v4(96.78,136.58) v4(96.78,135.69) v4(96.78,134.8) v4(97.26,133.97) v4(97.26,133.08) v4(97.26,132.19) v4(97.36,137.45) v4(97.8,136.58) v4(97.8,135.69) v4(97.8,134.8) v4(98.28,133.97) v4(98.28,133.08) v4(98.28,132.19) v4(98.81,136.58) v4(98.81,135.69) v4(98.81,134.8) v4(99.29,133.97) v4(99.29,133.08) v4(99.29,132.19) v4(99.83,136.58) v4(99.83,135.69) v4(99.83,134.8) v4(100.31,133.97) v4(100.31,133.08) v4(100.31,132.19) v4(101.33,135.87) v4(101.33,134.98) v4(101.33,133.97) v4(101.33,133.08) v4(101.33,132.19) v4(102.34,133.97) v4(102.34,133.08) v4(102.34,132.19)
+VTT_DDR: length 32.6
  TOP w0.305: CON1700.258 108.87,53.99 108.8,54.06 108.8,54.7 ; CON1600.258 108.87,66.1
  IN1 w0.762: v4(115.64,68.66) 116.54,67.76 v4(116.54,58.1)
  IN3 w0.762: 106.31,72.3 114,72.3 115.64,70.66 v4(115.64,68.66)
  IN4 w1.143: 35.67,45.19 37.06,43.8
  BOTTOM w0.305: CON1701.258 106.88,45.87 ; v2(108.97,55.34) 107.18,55.34 106.88,55.65 CON1601.258
  vias: v1(22.08,57.13) v2(105.64,72.91) v2(105.62,72.3) v2(105.8,68.66) v2(113.37,51.54) v2(113.37,50.93) v4(22.84,57) v4(23.73,57) v4(46.31,38.08) v4(47.2,38.08) v4(56.11,37.32) v4(57,37.32)
A_DVDD: length 3.1
  TOP w0.203: 5.21,25.46 5.52,25.76 5.7,25.76 6.54,26.61 U3600.1
  TOP w0.508: v1(3.28,21.65) 3.37,21.73 SR3601.2
AC_IN_OC: length 150.7
  TOP w0.102: U8800.5 275.77,34.61 275.39,34.98 275.03,34.98 274.25,35.76 R8808.2 R8806.1 273.41,37.88 R8815.1 272.32,37.45 271.25,37.45 270.34,36.53 267.07,36.53 266.46,37.14 265.36,37.14 264.47,38.03 263,38.03 262.38,38.03 260.96,36.61 259.48,36.61 v1(258.92,36.05) 258.92,35.07 258.57,34.72 v2(258.57,33.95) ; v2(161.3,20.9) 161.3,21.31 160.91,21.7 158.25,21.7 156.07,23.88 156.07,28.29 157.78,30 161.55,30 161.86,30.31 U3002.120
  IN3 w0.102: v2(161.3,20.9) 161.79,21.4 176.36,21.4 176.7,21.74 187.21,21.74 188.01,22.54 199.34,22.54 201.49,24.68 201.91,24.68 204.87,27.64 220.72,27.64 224.42,23.93 225.71,23.93 227.31,25.53 227.31,26.7 229.57,28.96 231.5,28.96 231.94,29.4 243.69,29.4 246.85,32.57 249.77,32.57 251.11,33.91 252.76,33.91 253.65,34.81 255.87,34.81 256.1,34.58 257.94,34.58 v2(258.57,33.95)
  BOTTOM w0.102: R3010.2 161.97,21.57 v2(161.3,20.9)
ACDRV: length 4.2
  TOP w0.229: U8800.4 276.17,35.33 v1(276.03,35.47) 276.21,35.64 R8803.1
  TOP w0.406: R8803.1 275.67,37.27 275.62,37.32 R8816.2
ACG: length 368.9
  TOP w0.406: R8803.2 v1(276.21,39.1) 276.69,39.1 v2(276.84,38.94)
  TOP w0.432: 11.18,81.49 12.78,81.49 13.47,82.18 v2(13.47,82.28)
  TOP w0.508: Q8802.4 v2(18.84,78.01)
  IN1 w0.508: v2(276.84,38.94) 276.84,37.88 276.94,37.78 276.94,34.39 276.47,33.92 276.47,31.81 272.57,27.91 262.53,27.91 261.03,29.41 249.31,29.41 243.63,23.73 230.36,23.73 229.47,22.84 229.47,20.43 228.71,19.67 227.95,19.67 224.77,22.84 216.52,22.84 215.75,22.08 215.75,20.17 215.32,19.74 213.77,19.74 213.47,20.05 210.29,20.05 205.09,14.84 168.54,14.84 167.8,15.58 164.14,15.58 162.11,13.55 152.86,13.55 144.91,5.6 119.06,5.6 107.65,17 66.73,17 64.97,18.75 61.37,18.75 60.43,17.81 54.61,17.81 54.43,17.99 41.89,17.99 41.23,17.33 32.29,17.33 31.63,17.99 24.85,17.99 23.68,19.16 23.68,20.38 24.11,20.81 24.11,34.02 23.86,34.27 23.86,40.11 24.87,41.13 24.87,43.29 14.18,53.98 14.18,59.32 11.64,61.86 11.64,75.75 13.63,77.74 14.73,77.74 15,78.01 v2(18.84,78.01)
  BOTTOM w0.508: v2(18.84,78.01) 16.48,80.37 14.51,80.37 13.47,81.41 v2(13.47,82.28)
ACPRESENT_EC: length 6.7
  TOP w0.102: v1(152.08,40.29) 152.56,40.29 153.55,39.3 153.55,38.18 153.69,38.03 SR3012.1 153.99,37.58 154.86,36.71 U3002.16
AD_IINP: length 148.2
  TOP w0.102: v2(145.17,17.18) v1(145.83,17.84) 148.22,17.84 148.86,18.49 U3002.66 ; v2(273.57,34) 272.96,34 SR8813.1
  IN1 w0.102: v2(273.57,34) 273.05,34 272.4,33.35 272.4,32.14 270.66,30.41 263.6,30.41 260.82,33.18 254.28,33.18 252.96,31.86 247.92,31.86 243.9,27.84 229.9,27.84 229.4,27.34 208.43,27.34 207.3,26.2 207.3,25.31 202.97,20.99 193.88,20.99 191.48,18.59 166.89,18.59 165.66,19.82 148.09,19.82 145.45,17.18 v2(145.17,17.18)
  BOTTOM w0.102: C8815.1 145.42,16.92 v2(145.17,17.18)
ADP_ID: length 311.6
  IN2 w0.102: v2(92.94,14.84) 92.94,17.47 88.33,22.08 63.41,22.08 59.92,18.6 49.86,18.6 49.5,18.24 39.83,18.24 37.23,15.64 25.1,15.64 22.28,18.46 22.28,27.06 21.88,27.46 v2(21.88,27.49)
  IN4 w0.102: v2(92.94,14.84) 94.6,16.49 99.55,16.49 100.95,15.09 115.68,15.09 116.31,14.46 118.85,14.46 119.61,15.22 122.38,15.22 124.53,13.06 179.05,13.06 181.34,10.78 233.15,10.78 236.07,13.7 v2(236.07,15.48) ; v2(22.49,61.2) 22.97,60.72 22.97,59.1 21.14,57.27 21.14,49.26 23.51,46.88 23.51,39.98 24.6,38.9 24.6,31.36 23.43,30.18 23.43,29.07 21.88,27.52 v2(21.88,27.49)
  BOTTOM w0.102: CON6004.1 13.13,79.8 13.52,80.19 14.08,80.19 14.31,79.97 16.31,79.97 18.45,77.83 18.45,76.49 19.06,75.88 19.06,70.29 21.05,68.3 R6009.2 21.05,62.64 v2(22.49,61.2) ; v2(236.07,15.48) 239.43,12.12 240.92,12.12 241.33,12.54 R8835.1 R8834.2 v1(242.4,13.82) 242.61,14.04 Q8810.1
ALERT#: length 3.2
  TOP w0.121: v2(56.75,187.36) 56.12,186.72 v1(55.68,186.72)
  BOTTOM w0.121: U8000.44 56.97,186.86 56.75,187.07 v2(56.75,187.36) 56.86,187.47 SR8008.2
ALL_SYSTEM_PWRGD: length 90.7
  TOP w0.102: D9202.2 185.91,38.97 T9203.1 187,38.59 v2(187,37.03) ; U9201.2 180.42,39.76 180.57,39.91 180.57,40.75 180.07,41.26 173.69,41.26 171.16,38.72 U9200.4 170.46,38.39 170.61,38.25 SR9204.1 171.12,37.55 171.63,37.03 v2(172.12,37.03) ; v2(143.24,17.18) 143.64,17.58 144.56,17.58 144.74,17.41 144.74,16.87 144.84,16.77 145.4,16.77 146.26,17.63 148.55,17.63 149.66,18.75 U3002.68
  IN2 w0.102: v2(143.24,17.18) 145.31,19.25 162.07,19.25 163.07,20.25 163.93,20.25 v2(164.31,20.63)
  IN3 w0.102: v2(172.12,37.03) 172.59,37.5 186.53,37.5 v2(187,37.03)
  BOTTOM w0.102: v2(172.12,37.03) 172.14,37 172.14,23.87 170.82,22.55 170.82,22.35 170.24,21.77 168.88,21.77 168.22,21.11 168.22,20.21 167.67,19.67 165.27,19.67 v2(164.31,20.63)
AMP_EN: length 175.1
  IN3 w0.102: v2(22.46,43.92) 24.08,43.92 26.05,41.95 26.05,36.93 25.53,36.41 25.53,31.1 25.05,30.61 25.05,30.16 25.53,29.67 25.53,24.48 26.98,23.04 26.98,20.61 28.69,18.9 31.19,18.9 33.92,16.17 40.28,16.17 41.15,15.3 47.01,15.3 47.54,15.82 47.55,15.82 48.77,17.05 61.06,17.05 62.86,18.85 80.42,18.85 80.93,18.35 109.05,18.35 112.19,21.48 116.07,21.48 116.14,21.56 116.14,21.81 116.41,22.07 116.87,22.07 120.35,25.55 134.39,25.55 135.07,24.87 145.7,24.87 146.01,24.57 154.26,24.57 v2(154.73,24.1)
  BOTTOM w0.102: v2(154.73,24.1) 154.73,24.73 R3022.2 R3023.1 v1(155,27.01) ; v2(22.46,43.92) 21.07,43.92 20.41,43.26 17.07,43.26 15.51,41.7 CON6700.15
AMP_G0: length 174.9
  TOP w0.102: U3002.94 160.06,20.69 v2(159.86,20.9) ; v1(23.43,43.59) v2(23.92,43.1)
  IN2 w0.102: v2(23.92,43.1) 25.85,41.17 25.85,31.44 25.1,30.69 25.1,25.47 28.26,22.31 33.86,22.31 34.37,21.8 38.33,21.8 39.41,22.88 60.65,22.88 62.62,24.85 112.59,24.85 119.31,18.13 142.18,18.13 145.52,21.47 147.48,21.47 148.67,20.28 159.23,20.28 v2(159.86,20.9)
  BOTTOM w0.102: v2(23.92,43.1) 23.69,43.1 22.54,41.95 17.53,41.95 15.78,40.2 CON6700.12
AMP_G1: length 175
  TOP w0.102: v2(160.47,20.9) U3002.95 ; v1(23.92,41.8) v2(23.92,42.46)
  IN2 w0.102: v2(160.47,20.9) 159.61,20.05 148.61,20.05 147.4,21.26 145.62,21.26 142.29,17.93 119.06,17.93 112.34,24.65 62.7,24.65 60.74,22.68 39.52,22.68 38.44,21.6 33.92,21.6 33.48,22.03 28.25,22.03 24.9,25.38 24.9,30.87 25.6,31.57 25.6,36.6 24.97,37.22 24.97,38.49 24.14,39.33 24.14,42.25 v2(23.92,42.46)
  BOTTOM w0.102: CON6700.11 15.57,39.7 17.56,41.69 20.73,41.69 20.79,41.74 22.69,41.74 23.41,42.46 v2(23.92,42.46)
AMP_SPK_LN: length 6.4
  BOTTOM w0.762: 11.68,23.39 14.93,23.39 v1(15.36,22.96) 15.78,22.54 C3620.1 15.78,20.64
AMP_SPK_LP: length 8
  BOTTOM w0.762: 16.87,20.73 C3619.1 16.41,23.43 15.49,24.35 v1(13.06,24.35) 11.98,24.35
AMP_SPK_RN: length 5.3
  BOTTOM w0.762: 11.64,22.4 12.18,22.4 v1(12.71,21.88) C3621.1 13.77,20.47 14.46,19.79 14.46,18.57
AMP_SPK_RP: length 3.7
  BOTTOM w0.762: 13.49,18.56 C3622.1 13.49,19.51 12.67,20.33 12.67,20.62 11.89,21.4 11.73,21.4
AMP_WOF_LN: length 4.7
  TOP w0.508: v1(232.82,22.41) 233,22.23 v2(233,21.19) 233,20.63 C3707.1 233.2,20.1 233.11,20 L3703.2
  BOTTOM w0.508: v2(233,21.19) 233,21.34 232.63,21.72 CON3700.3
AMP_WOF_LN_R: length 188.1
  TOP w0.762: v4(232.9,16.36) 232.9,16.71 233.11,16.92 L3703.1
  BOTTOM w0.254: U3700.2 67.25,14.91 68.09,15.74
  BOTTOM w0.762: v4(232.9,16.36) 232.49,16.77 230.29,16.77 229.4,15.88 228.73,15.88 227.82,14.97 227.82,12.69 225.24,10.12 209.66,10.12 208.69,11.08 201.2,11.08 200.46,10.34 182.39,10.34 180.31,12.43 158.27,12.43 157.28,11.44 155.89,11.44 141.34,11.44 138.13,8.24 138.13,6.31 135.66,3.84 95.85,3.84 95.42,4.27 90.91,4.27 87.74,7.45 87.74,12.07 v1(84.3,15.51) 82.4,17.41 69.75,17.41 68.09,15.74
AMP_WOF_LP: length 4.4
  TOP w0.508: L3704.2 233.99,19.82 C3708.1 233.99,20.89 v2(233.76,21.11) v1(234.45,21.8)
  BOTTOM w0.508: CON3700.4 233.88,21.23 v2(233.76,21.11)
AMP_WOF_LP_R: length 190.5
  TOP w0.762: L3704.1 234.17,17.98 234.17,16.62 v4(233.91,16.36)
  BOTTOM w0.254: U3700.1 66.82,15.36 67.19,15.73 67.19,16.24
  BOTTOM w0.762: v4(233.91,16.36) 233.91,16.75 232.92,17.74 229.89,17.74 229.03,16.87 228.35,16.87 226.8,15.32 226.8,13.04 224.84,11.08 210.09,11.08 209.12,12.05 200.77,12.05 200.03,11.31 182.79,11.31 180.71,13.39 157.87,13.39 156.88,12.41 140.85,12.41 137.17,8.72 137.17,6.71 135.26,4.81 96.25,4.81 95.82,5.24 91.31,5.24 88.75,7.8 88.75,12.55 v1(87.15,14.15) 82.94,18.37 69.32,18.37 67.19,16.24
AMP_WOF_RN: length 5.8
  TOP w0.508: v2(230.99,21.32) 230.36,21.95 229.77,21.95 v1(229.47,21.65) 229.39,21.57 229.39,20.89 229.65,20.63 C3705.1 229.65,19.97 229.6,19.92 L3701.2
  BOTTOM w0.508: v2(230.99,21.32) 231.37,21.7 CON3700.2
AMP_WOF_RN_R: length 186.2
  TOP w0.762: L3701.1 229.6,17.89 230.74,16.75 v4(230.74,15.35)
  BOTTOM w0.254: 68.5,14.5 67.56,13.56 U3700.5
  BOTTOM w0.762: v4(230.74,15.35) 230.74,11.79 230.08,11.13 228.1,11.13 225.82,8.85 180.8,8.85 178.64,11.01 161.07,11.01 152.63,2.57 89.31,2.57 89.03,2.85 89.03,4.34 86.11,7.27 86.11,11.59 82.22,15.48 v1(81.05,15.48) 69.48,15.48 68.5,14.5
AMP_WOF_RP: length 4.7
  TOP w0.508: v2(230.13,21.32) 230.13,21.17 230.69,20.61 C3706.1 230.69,19.57 L3702.2 230.98,19.29 v1(231.96,19.29)
  BOTTOM w0.508: CON3700.1 v2(230.13,21.32)
AMP_WOF_RP_R: length 187.4
  TOP w0.762: L3702.1 231.76,17.17 v1(231.76,16.24) v4(231.76,15.35)
  BOTTOM w0.254: U3700.6 68.55,13.11
  BOTTOM w0.762: v4(231.76,15.35) 231.76,11.44 230.49,10.17 228.5,10.17 226.22,7.88 180.4,7.88 178.24,10.04 161.47,10.04 153.04,1.61 88.91,1.61 88.07,2.45 88.07,3.94 85.12,6.89 85.12,11.11 81.77,14.46 69.9,14.46 68.55,13.11
ANALOG_INL: length 52.8
  TOP w0.254: C3648.2 12.68,8.29 13.32,7.65 50.07,7.65 50.62,8.2 50.62,10.7 52.32,12.4 v1(54.77,12.4) 56.95,12.4 57.26,12.71 57.74,12.71 v2(58.08,12.36)
  BOTTOM w0.254: v2(58.08,12.36) 58.27,12.55 58.27,13.75 R3704.1
ANALOG_INL_C: length 27.4
  TOP w0.203: U3600.24 11.86,31.77 12.17,32.09 v2(12.43,32.09)
  TOP w0.254: v2(12.63,11.11) 12.68,11.06 C3648.1 ; v2(12.43,32.09) 12.63,32.09 12.96,32.42 12.96,33.29 v1(12.36,33.89)
  IN1 w0.254: v2(12.43,32.09) 12.58,32.09 12.93,31.73 12.93,28.92 13.39,28.46 13.39,25.36 10.78,22.74 10.78,16.24 12.55,14.46 12.55,11.18 v2(12.63,11.11)
ANALOG_INL_CR: length 1.9
  BOTTOM w0.254: C3703.2 60.51,13.11 60.43,13.19 R3712.2 60.15,13.65 R3704.2
ANALOG_INL_CR_C: length 4.1
  BOTTOM w0.254: C3703.1 61.37,13.49 61.58,13.7 v1(61.58,14.59) 61.71,14.46 U3700.10
ANALOG_INR: length 52.4
  TOP w0.254: v2(57.46,12.17) 57.18,11.89 52.53,11.89 51.13,10.49 51.13,7.99 50.28,7.14 50.25,7.14 50.24,7.14 13.04,7.14 11.79,8.39 v1(11.79,8.57) C3649.2
  BOTTOM w0.254: R3700.1 58.55,11.87 57.77,11.87 v2(57.46,12.17)
ANALOG_INR_C: length 24.8
  TOP w0.203: U3600.23 12.35,31.37 v2(12.43,31.45)
  TOP w0.254: C3649.1 11.79,10.85 v2(12.02,11.08) 12.02,11.51 v1(12.3,11.79)
  IN1 w0.254: v2(12.02,11.08) 12.05,11.11 12.05,14.21 10.27,15.98 10.27,22.97 12.88,25.58 12.88,28.25 12.43,28.71 v2(12.43,31.45)
ANALOG_INR_CR: length 2.2
  BOTTOM w0.254: R3711.2 R3700.2 60.05,12.05 60.18,11.92 C3702.2
ANALOG_INR_CR_C: length 3.7
  BOTTOM w0.254: C3702.1 61.88,12.43 61.88,13.11 62.77,14.01 U3700.9
AR_PCIE_CLKREQ_N: length 24.3
  TOP w0.121: U1102.2 279.2,47.23 280.14,46.29 v2(280.14,45.78) 280.5,45.42 R1119.1 283.08,46.12 284.32,46.12 285.35,45.09 285.91,45.09 286.11,44.89 287.01,44.89 287.93,43.97 U1101.AC5
  IN1 w0.083: v2(280.14,45.78) 278.85,44.48 275.32,44.48 v2(272.78,47.02)
  BOTTOM w0.121: R1109.1 273.79,46.74 273.51,47.02 v2(272.78,47.02) 272.78,46.77 v1(273.13,46.41)
BAT: length 73.9
  TOP w0.508: R2803.2 249.08,66.07 248.75,65.74 Q2801.1 249.91,65.19 250.09,65.01 v2(250.96,65.01)
  IN1 w0.508: v2(271.96,63.74) 273.69,63.74 v2(274.53,62.9)
  IN3 w0.508: v2(250.96,65.01) 250.98,64.98 250.98,64.75 251.34,64.4 252.33,64.4 252.56,64.17 252.56,61.55 253.3,60.81 258.04,60.81 259.48,59.38 259.89,59.38 260.78,58.49 265.88,58.49 271.13,63.74 v2(271.96,63.74)
  BOTTOM w0.432: v2(274.53,62.9) 275.48,63.85 276.63,63.85 276.74,63.74 R2811.1 280.04,63.74 v1(280.49,63.29)
  BOTTOM w0.508: CON2800.1 297.77,47.63 297.77,61.35 296.78,62.34 296.78,63.18 296.14,63.81 282.92,63.81 282.4,63.29 v1(280.49,63.29)
BAT1_IN_OC#: length 6.1
  TOP w0.102: U3002.124 163.76,31.91 163.94,32.09 164.7,32.09 165.05,31.73 R3065.2 165.94,31.27 166.71,31.27 v1(167.27,31.83) 167.49,31.6 JP9000.1
BAT_IINP: length 151.6
  TOP w0.102: v1(143.77,16.8) 144.15,17.18 v2(144.33,17.18) 144.33,16.77 144.53,16.57 145.52,16.57 146.39,17.43 148.63,17.43 149.75,18.55 149.82,18.55 150.06,18.79 U3002.69 ; SR8814.1 272.92,33.7 v2(273.12,33.5)
  IN1 w0.102: v2(273.12,33.5) 272.6,32.98 272.6,32.06 270.75,30.2 263.51,30.2 260.95,32.76 256.51,32.76 256.29,32.98 254.41,32.98 253.09,31.66 248,31.66 243.2,26.85 239.51,26.85 239.23,27.13 208.51,27.13 207.5,26.12 207.5,23.96 206.56,23.02 205.7,23.02 203.46,20.78 194.06,20.78 191.66,18.38 166.81,18.38 165.57,19.62 148.19,19.62 145.34,16.77 144.74,16.77 v2(144.33,17.18)
  BOTTOM w0.102: v2(144.33,17.18) 144.38,17.18 C8839.1
BAT_LEARN: length 125.8
  TOP w0.102: U3002.85 156.47,20.5 156.46,20.51 v2(156.46,20.91) ; v2(257.95,33.95) 257.95,34.46 v1(257.58,34.83) 257.58,35.69 258.7,36.81 260.87,36.81 262.3,38.23 264.55,38.23 265.44,37.35 SR8807.2
  IN3 w0.102: v2(257.95,33.95) 257.53,34.37 256.01,34.37 255.78,34.6 254.75,34.6 252.52,32.37 246.94,32.37 243.77,29.2 232.03,29.2 231.59,28.76 230.58,28.76 228.45,26.63 228.45,26.11 226.05,23.71 224.33,23.71 220.59,27.44 204.95,27.44 201.99,24.48 201.57,24.48 199.43,22.33 188.1,22.33 187.28,21.52 176.77,21.52 176.44,21.2 162.17,21.2 161.46,20.49 156.87,20.49 v2(156.46,20.91)
BATDRV: length 33.9
  TOP w0.203: U8800.18 276.17,29.84 276.1,29.78
  TOP w0.508: v1(275.93,26.83) 275.77,26.98 v2(275.77,27.87) 276.1,28.2 276.1,29.78
  IN4 w0.508: v2(275.77,27.87) 276.26,27.39 276.26,24.21 278.59,21.88 283.83,21.88 290.61,15.09 296.22,15.09 v2(297.85,13.47)
BATG: length 6.4
  IN1 w0.508: v2(296.96,19.36) 295.71,18.12 v2(295.71,13.44)
  vias: v1(295.08,13.6)
BATSRC: length 36.8
  TOP w0.203: 275.49,29.73 275.41,29.81 275.41,29.84 275.77,30.2 U8800.17
  TOP w0.508: v1(274.2,27.16) 274.73,27.16 275.14,27.57 v2(275.14,28.56) 275.49,28.91 275.49,29.73
  IN4 w0.508: v2(299.42,13.57) 297.14,15.86 290.92,15.86 284.14,22.64 278.91,22.64 277.02,24.53 277.02,27.64 276.1,28.56 v2(275.14,28.56)
BATT_IN: length 75.3
  IN4 w0.102: v2(292.37,27.33) 292.4,27.3 298.71,27.3 298.91,27.5 306.36,27.5 310.6,31.74 310.6,32.39 310.22,32.77 310.22,35.14 310.69,35.61 310.69,38.7 308.04,41.34 308.04,46.64 307.49,47.19 307.49,53.04 306.73,53.8 306.73,59.81 304.68,61.87 304.68,64.44 305.2,64.95 v2(310.27,64.95)
  BOTTOM w0.102: v2(310.27,64.95) 308.36,66.86 v1(308.36,70.42) 308.36,72.47 308.23,72.6 Q6001.3
  BOTTOM w0.121: CON6000.4 292,26.96 v2(292.37,27.33)
BKLT_EN: length 10.5
  TOP w0.102: D4502.3 94.75,191.35 93.38,191.35 93.22,191.19 93.22,190.63 93.02,190.43 R4525.2 SR4505.1 92.4,189.63 92.21,189.44 91.45,189.44 91.29,189.59 D4503.1 89.99,190.77 89.9,190.86 v1(89.01,190.86) SR4507.2
BOOT_C:
  vias: v1(100.9,155.25)
BP_PWRGD_RST#: length 16.6
  BOTTOM w0.102: v1(60.28,123.27) 59.78,123.78 59.78,125.15 R4412.2 R4415.1 59.31,126.07 C4401.1 59.13,126.7 59.13,129.08 58.66,129.55 58.66,135.37 59.74,136.45 XDP4400.41
BPM_N2: length 1.6
  TOP w0.102: T0700.1 76.52,125.84 v3(76.66,125.98)
  BOTTOM w0.102: v3(76.66,125.98) 76.65,125.98 76.99,125.64 U0300.BM31
BPM_N3: length 2.7
  TOP w0.102: T0701.1 74.41,123.87 74.1,124.19 73.74,124.19 v3(73.51,124.42)
  BOTTOM w0.076: U0300.BT30 74.16,124.57 73.97,124.57 73.82,124.42 v3(73.51,124.42)
BT_DISABLE#: length 137.9
  TOP w0.102: v2(301.86,100.77) 301.48,100.39 301.48,100.12 R5300.2
  IN3 w0.102: v2(226.29,41.69) 226.3,41.69 226.78,42.17 226.78,42.53 227.49,43.24 239.83,43.24 240.59,44 248.76,44 250.95,46.18 252.13,46.18 253.13,47.19 253.13,59.83 250.88,62.08 250.04,62.08 249.41,62.72 249.41,65.64 251.44,67.67 253.47,67.67 254.34,68.54 254.34,70.48 252.96,71.86 252.96,73.44 257.18,77.65 258.1,77.65 259.59,79.15 259.59,81.55 260.36,82.31 260.36,83.56 261.11,84.32 261.75,84.96 269.7,84.96 271.36,86.62 276.53,86.62 283.34,93.43 287.41,93.43 288.28,94.3 v2(288.28,94.77)
  IN4 w0.102: v2(288.28,94.77) 288.44,94.62 289.01,94.62 289.54,95.16 289.54,95.99 290.13,96.58 295.43,96.58 296.91,98.05 299.14,98.05 v2(301.86,100.77)
  BOTTOM w0.089: U2000.AC43 228.05,48.98 228.05,48.63 228.06,48.62 228.06,48.39 227.92,48.25
  BOTTOM w0.102: CON5300.54 301,99.98 301.78,100.77 v2(301.86,100.77) ; v2(226.29,41.69) 226.29,41.41 C5347.1 225.89,41.54 225.88,41.55 225.88,43.35 R2141.1 226.29,44.2 v1(226.75,44.66) 226.82,44.73 226.82,45.53 227.29,46 227.29,47.6 227.84,48.16 227.84,48.18 227.92,48.25
BT_LED: length 3.2
  BOTTOM w0.102: CON5300.16 291.5,100.13 290.56,101.07 T5301.1
BUF_PLT_RST#_WIGIG: length 21.1
  TOP w0.102: D5308.1 300.34,97.23 C5349.1 300.89,97.14 300.92,97.16 R5355.1 301.02,97.42 R5354.1 302.88,97.59 v2(302.88,97.9) ; R5356.1 v1(294.09,92.18) 294.09,92.64 v2(294.34,92.89)
  IN4 w0.102: v2(294.34,92.89) 294.34,94.84 297.09,97.59 302.57,97.59 v2(302.88,97.9)
  BOTTOM w0.102: v2(302.88,97.9) 303.76,97.9 304,98.13 CON5300.66
BUF_PLT_RST#_WLAN: length 18.4
  TOP w0.102: R5341.1 R5319.1 297.36,91.85 297.54,91.68 299.32,91.68 299.57,91.93 D5303.1 299.57,92.87 299.14,93.3 298.88,93.3 298.63,93.56 298.63,94.09 v2(298.89,94.35) ; v2(300.39,100.36) 300.89,100.36 301.35,100.82 301.35,102.09 C5348.1 301.86,102.22 301.91,102.27 R5349.1
  BOTTOM w0.102: v1(300.21,101.84) 300.21,100.54 v2(300.39,100.36) 300.5,100.25 CON5300.52 300.5,97 298.89,95.39 v2(298.89,94.35)
