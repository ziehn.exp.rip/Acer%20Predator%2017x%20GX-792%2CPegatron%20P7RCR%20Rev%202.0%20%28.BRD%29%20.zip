# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R8716  10KOhm  [VX_R0402_SMALL]  121.27 164.7 90 top
R8717  2KOhm  [VX_R0402_SMALL]  121.14 160.89 0 top
R8718  2KOhm  [VX_R0402_SMALL]  121.01 162.21 0 top
R8719  2KOhm  [VX_R0402_SMALL]  121.14 158.73 0 top
R8720  2KOhm  [VX_R0402_SMALL]  121.14 160.03 0 top
R8721  5.49KOhm  [VX_R0402_SMALL]  121.14 157.69 180 top
R8722  5.49KOhm  [VX_R0402_SMALL]  121.14 156.6 180 top
R8723  5.49KOhm  [VX_R0402_SMALL]  121.14 155.51 180 top
R8724  5.49KOhm  [VX_R0402_SMALL]  121.14 154.41 180 top
R8727  10Ohm  [VX_R0402_SMALL]  117.84 158.38 0 top
R8728  10Ohm  [VX_R0402_SMALL]  117.84 155.79 0 top
R8729  10Ohm  [VX_R0402_SMALL]  117.84 154.9 0 top
R8730  10Ohm  [VX_R0402_SMALL]  119.67 152.74 90 top
R8731  127KOhm  [VX_R0402_SMALL]  121.49 154.03 180 bottom
R8732  127KOhm  [VX_R0402_SMALL]  121.49 155.3 180 bottom
R8733  127KOhm  [VX_R0402_SMALL]  121.49 156.6 180 bottom
R8734  127KOhm  [VX_R0402_SMALL]  121.49 157.87 180 bottom
R8737  165KOHM  [VX_R0402_SMALL]  123.25 151.24 90 top
R8738  75KOhm  [VX_R0402_SMALL]  124.11 151.24 270 top
R8739  100KOHM  [VX_R0402_H24_SMALL_T02XT01]  185.17 161.83 270 bottom
R8740  32.4KOhm  [VX_R0402_SMALL]  124.9 153.14 270 top
R8741  54.9KOHM  [VX_R0402_SMALL]  126.73 153.14 270 bottom
R8742  23.2KOhm  [VX_R0402_SMALL]  125.87 153.14 270 top
R8743  60.4KOhm  [VX_R0402_SMALL]  126.76 153.14 270 top
R8744  3.3KOhm  [VX_R0402_SMALL]  130.03 152.43 180 top
R8745  1KOhm  [VX_R0402_SMALL]  128.16 153.4 180 top
R8746  49.9Ohm  [VX_R0402_SMALL]  127.78 152 90 top
R8747  100Ohm  [VX_R0402_SMALL]  132.52 155.94 180 top
R8748  100Ohm  [VX_R0402_SMALL]  131.6 154.36 90 top
R8749  2Ohm  [VX_R0603_H24_SMALL]  127.49 155.81 0 bottom
R8750  2Ohm  [VX_R0603_H24_SMALL]  183.5 162.41 180 top
R8751  2.2Ohm  [VX_R0603_H28_SMALL]  186.8 179.69 90 bottom
R8752  2Ohm  [VX_R0603_H24_SMALL]  144.13 163.18 180 top
R8753  2.2Ohm  [VX_R0603_H28_SMALL]  147.43 175.9 90 bottom
R8754  2Ohm  [VX_R0603_H24_SMALL]  158.48 163.18 180 top
R8755  2.2Ohm  [VX_R0603_H28_SMALL]  148.7 175.88 90 bottom
R8756  2Ohm  [VX_R0603_H24_SMALL]  171.43 163.3 180 top
R8757  2.2Ohm  [VX_R0603_H28_SMALL]  161.78 175.88 90 bottom
R8762  10KOhm  [VX_R0402_SMALL]  127.49 164.7 270 top
R8763  10KOhm  [VX_R0402_SMALL]  126.6 164.7 270 top
R8764  100KOhm  [VX_R0402_SMALL]  120.53 152.74 270 top
R8765  100KOhm  [VX_R0402_SMALL]  117.84 153.07 180 top
R8766  100KOhm  [VX_R0402_SMALL]  117.84 157.51 180 top
R8767  100KOhm  [VX_R0402_SMALL]  117.84 160.05 180 top
R8800  5mohm  [VX_R2512_H35_YAGEO]  22.21 80.25 270 top
R8801  2.2ohm  [VX_R1206_H26]  7.58 74.89 180 top
R8802  10Ohm  [VX_R0603_H28_SMALL]  299.4 13.55 180 top
R8803  4.02KOhm  [VX_R0402_SMALL]  276.21 37.7 90 top
R8804  4.02KOhm  [VX_R0402_SMALL]  277.53 37.7 90 top
R8805  432KOhm  [VX_R0402_SMALL]  262.57 36.41 0 top
R8806  10KOhm  [VX_R0402_SMALL]  273.41 36.71 270 top
R8807  68KOhm  [VX_R0402_SMALL]  265.15 36.53 180 top
R8808  12.4KOHM  [VX_R0402_SMALL]  274.68 36.3 180 top
R8809  10mOhm  [VX_R1206_H31]  299.57 23.98 0 top
R8810  2.2Ohm  [VX_R0805_H24_SMALL]  281.16 21.57 270 top
R8811  560KOhm  [VX_R0402_SMALL]  279.63 28.86 90 top
R8812  22Ohm  [VX_R0805_H24_SMALL]  7.22 61.87 0 top
R8813  150KOhm  [VX_R0402_SMALL]  278.75 28.86 270 top
R8814  4.02KOhm  [VX_R0402_SMALL]  296.78 13.44 180 top
R8815  100KOhm  [VX_R0402_SMALL]  272.65 38.21 180 top
R8816  2MOHM  [VX_R0402_SMALL]  274.68 37.32 0 top
R8817  1MOhm  [VX_R0402_SMALL]  274.68 38.21 180 top
R8834  560KOhm  [VX_R0402_SMALL]  240.9 13.82 0 bottom
R8835  560KOhm  [VX_R0402_SMALL]  240.9 12.94 180 bottom
R8837  100KOhm  [VX_R0402_SMALL]  271.38 31.6 90 top
R8838  100KOhm  [VX_R0402_SMALL]  271.38 29.95 270 top
R8900  22.6KOhm  [VX_R0402_SMALL]  252.46 81.77 0 bottom
R8901  47KOhm  [VX_R0402_SMALL]  252.33 81.03 180 top
R8902  10KOhm  [VX_R0402_SMALL]  250.04 79.74 90 top
R8903  7.68KOhm  [VX_R0402_SMALL]  249.15 79.74 270 top
R8904  2.2Ohm  [VX_R0805_H24_SMALL]  221.6 97.26 90 top
R8905  2.2Ohm  [VX_R0402_SMALL]  244.46 80.88 180 bottom
R8907  499KOhm  [VX_R0402_SMALL]  253.54 83.04 0 top
R8909  100Ohm  [VX_R0402_SMALL]  252.01 86.7 0 top
R8910  91KOhm  [VX_R0402_SMALL]  251.95 83.4 90 top
R8911  124KOhm  [VX_R0402_SMALL]  249.05 86.72 270 top
R8912  2.2Ohm  [VX_R0402_SMALL]  249.56 89.19 180 top
R8917  2.2Ohm  [VX_R0805_H24_SMALL]  240.39 91.42 0 bottom
R9100  47KOhm  [VX_R0402_SMALL]  198.2 35.52 90 top
R9101  270KOhm  [VX_R0402_SMALL]  133.46 75.11 270 top
R9104  47KOhm  [VX_R0402_SMALL]  243.69 20.43 180 top
R9105  47KOhm  [VX_R0402_SMALL]  259.44 77.86 90 top
R9106  47KOhm  [VX_R0402_SMALL]  259.01 81.19 0 bottom
R9107  560KOhm  [VX_R0402_SMALL]  187.31 30.21 90 top
R9108  560KOhm  [VX_R0402_SMALL]  181.21 22.59 90 top
R9110  10KOhm  [VX_R0402_SMALL]  239.76 26.65 180 top
R9111  110KOHM  [VX_R0402_SMALL]  239.76 25.76 0 top
R9112  147KOhm  [VX_R0402_SMALL]  197.8 38.92 180 top
R9113  10KOhm  [VX_R0402_SMALL]  133.48 73.46 270 top
R9200  100KOhm  [VX_R0402_SMALL]  165.51 41.88 270 top
R9202  100KOhm  [VX_R0402_SMALL]  182 42.27 180 top
R9203  1.91KOhm  [VX_R0402_SMALL]  178.12 40.64 0 top
R9204  560KOhm  [VX_R0402_SMALL]  178.14 36.96 180 top
R9205  0Ohm  [VX_R0402_0OHM_SMALL]  178.14 36.08 0 top
R9206  0Ohm  [VX_R0402_0OHM_SMALL]  179.2 43.67 180 top
R9207  0Ohm  [VX_R0402_0OHM_SMALL]  166.1 40.11 90 top
R9208  0Ohm  [VX_R0402_0OHM_SMALL]  164.83 40.11 90 top
R9214  0Ohm  [VX_R0402_0OHM_SMALL]  177.65 38.46 90 top
R9215  0Ohm  [VX_R0402_0OHM_SMALL]  215.5 21.57 270 top
R9216  0Ohm  [VX_R0402_0OHM_SMALL]  214.23 21.57 270 top
R9400  4.7Ohm  [VX_R0603_H28_SMALL]  106.79 166.99 90 bottom
R9401  2.2Ohm  [VX_R0805_H24_SMALL]  106.91 169.78 270 bottom
R9403  10KOhm  [VX_R0402_SMALL]  101.2 163.3 0 bottom
R9404  100KOhm  [VX_R0402_SMALL]  105.39 165.06 270 bottom
R9405  47.5KOhm  [VX_R0402_SMALL]  103.87 162.8 0 bottom
R9406  80.6KOhm  [VX_R0402_SMALL]  103.87 163.81 180 bottom
R9407  499Ohm  [VX_R0402_SMALL]  105.77 162.8 180 bottom
R9408  0Ohm  [VX_R0402_0OHM_SMALL]  107.42 164.07 180 bottom
R9500  4.7Ohm  [VX_R0603_H28_SMALL]  92.74 8.92 180 top
R9501  2.2Ohm  [VX_R0805_H24_SMALL]  93.83 4.43 90 top
R9502  100KOhm  [VX_R0402_SMALL]  94.21 11.03 0 top
R9503  680KOhm  [VX_R0402_SMALL]  98.63 13.57 270 bottom
R9504  499Ohm  [VX_R0402_SMALL]  91.42 11.03 0 top
R9505  90.9KOhm  [VX_R0402_SMALL]  91.42 11.92 180 top
R9506  29.4KOhm  [VX_R0402_SMALL]  90.07 9.25 270 top
R9600  100KOhm  [VX_R0402_SMALL]  123.45 146.44 270 top
R9601  2.2Ohm  [VX_R0805_H24_SMALL]  121.57 146.44 0 top
R9602  40.2KOhm  [VX_R0402_SMALL]  113.65 142.48 90 bottom
R9603  4.7Ohm  [VX_R0603_H28_SMALL]  115.04 145.65 90 bottom
R9604  40.2KOhm  [VX_R0402_SMALL]  113.52 148.57 0 bottom
R9605  499Ohm  [VX_R0402_SMALL]  114.79 149.21 90 bottom
R9606  27KOhm  [VX_R0402_SMALL]  113.52 149.46 0 bottom
R9700  499KOhm  [VX_R0402_SMALL]  198.99 191.88 180 top
R9701  20KOhm  [VX_R0402_SMALL]  205.85 188.78 270 top
R9702  5mOhm  [VX_R0612_4P_H31]  98.36 168.31 270 top
R9703  10Ohm  [VX_R0402_SMALL]  97.01 177.15 180 top
R9704  10Ohm  [VX_R0402_SMALL]  91.7 177.93 180 bottom
R9705  2.2Ohm  [VX_R0603_H28_SMALL]  210.34 171.18 90 bottom
R9706  2.2Ohm  [VX_R0603_H28_SMALL]  185.53 168.38 90 bottom
R9707  10KOhm  [VX_R0402_SMALL]  89.26 180.45 180 top
R9709  10Ohm  [VX_R0402_SMALL]  95.36 177.15 0 top
R9710  2.2Ohm  [VX_R0402_SMALL]  200.34 183.88 0 bottom
R9712  10KOhm  [VX_R0402_SMALL]  88.68 183.27 270 top
R9713  16.5KOhm  [VX_R0402_SMALL]  207.96 190.99 180 top
R9714  10KOhm  [VX_R0402_SMALL]  90.79 177.05 180 top
R9715  5mOhm  [VX_R0612_4P_H31]  118.5 172.17 90 bottom
R9716  4.32KOhm  [VX_R0402_SMALL]  206.23 190.99 0 top
R9717  10KOhm  [VX_R0402_SMALL]  94.98 183.24 180 top
R9718  100Ohm  [VX_R0402_SMALL]  194.72 191.47 90 top
R9719  10KOhm  [VX_R0402_SMALL]  89.26 181.34 180 top
R9720  100Ohm  [VX_R0402_SMALL]  195.18 190.18 180 top
R9721  20.5KOhm  [VX_R0402_SMALL]  206.23 191.88 180 top
R9722  3.6KOHM  [VX_R0402_SMALL]  205.85 186.11 90 top
R9723  6.19KOhm  [VX_R0402_SMALL_T01]  203.64 191.88 0 top
R9724  10KOhm  [VX_R0402_SMALL]  203.94 189.21 180 top
R9725  10KOhm  [VX_R0402_SMALL]  203.94 188.34 0 top
R9727  110KOHM  [VX_R0402_SMALL]  198.69 189.16 0 bottom
R9728  43KOhm  [VX_R0402_SMALL]  200.64 191.88 0 top
R9729  80.6KOhm  [VX_R0402_SMALL]  196.5 191.88 0 top
R9731  10Ohm  [VX_R0402_SMALL]  91.7 177.1 180 bottom
R9732  5mOhm  [VX_R0612_4P_H31]  118.32 172.8 270 top
R9733  10Ohm  [VX_R0402_SMALL]  100.06 175.27 90 bottom
R9734  10Ohm  [VX_R0402_SMALL]  99.17 175.27 90 bottom
R9736  309Ohm  [VX_R0402_SMALL_T01]  207.96 190.1 0 top
R30101  10KOhm  [VX_R0402_SMALL]  169.65 30.31 0 top
R30102  10KOhm  [VX_R0402_SMALL]  149.71 13.82 0 top
R30103  10KOhm  [VX_R0402_SMALL]  155.48 14.08 0 bottom
R30104  10KOhm  [VX_R0402_SMALL]  152.36 14.08 180 bottom
R30105  10KOhm  [VX_R0402_SMALL]  144.1 14.23 90 top
R30106  10KOhm  [VX_R0402_SMALL]  141.47 14.42 0 top
R30107  10KOhm  [VX_R0402_SMALL]  138.42 14.78 0 top
R30108  10KOhm  [VX_R0402_SMALL]  134.85 15.11 0 top
R30109  10KOhm  [VX_R0402_SMALL]  166.15 18.12 180 top
R74100  0Ohm  [VX_R0402_0OHM_SMALL]  131.04 58.53 90 bottom
R74101  0Ohm  [VX_R0402_0OHM_SMALL]  131.93 58.53 90 bottom
R74102  0Ohm  [VX_R0402_0OHM_SMALL]  187.46 163.99 90 top
R74103  10KOhm  [VX_R0402_SMALL]  188.35 163.99 90 top
R74104  30KOhm  [VX_R0402_SMALL]  186.8 172.78 180 top
R74105  10KOhm  [VX_R0402_SMALL]  186.8 171.89 0 top
R74107  2KOhm  [VX_R0402_SMALL]  147.05 79.99 180 top
R74108  2KOhm  [VX_R0402_SMALL]  148.95 79.99 270 top
R74109  0Ohm  [VX_R0402_0OHM_SMALL]  142.09 57.51 0 top
R74110  0Ohm  [VX_R0402_0OHM_SMALL]  143.49 55.73 270 top
R80100  4.64KOHM  [VX_R0402_SMALL]  57.33 180.62 0 top
R80101  2.61KOhm  [VX_R0402_SMALL]  51.42 178.46 270 bottom
R80102  1KOhm  [VX_R0402_SMALL]  56.11 176.48 180 bottom
R80103  0Ohm  [VX_R0402_0OHM_SMALL]  67.5 179.35 180 bottom
R80112  100Ohm  [VX_R0402_SMALL]  57.13 186.21 180 top
R80125  100KOhm  [VX_R0402_SMALL]  56.11 174.81 0 bottom
R80130  100KOhm  [VX_R0402_SMALL]  52.56 176.43 180 bottom
R80135  100KOhm  [VX_R0402_SMALL]  52.13 175.16 270 bottom
R80140  100KOhm  [VX_R0402_SMALL]  64.37 179.73 270 bottom
R80145  100KOhm  [VX_R0402_SMALL]  69.78 183.67 0 bottom
R80147  100Ohm  [VX_R0402_SMALL]  72.19 125.18 0 top
R80148  110Ohm  [VX_R0402_SMALL]  72.19 126.35 0 top
R80149  45.3Ohm  [VX_R0402_SMALL]  72.19 127.54 0 top
R80150  75Ohm  [VX_R0402_SMALL]  70.18 127.06 0 bottom
RN1201  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  307.02 42.27 180 bottom
RN1202  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  304.45 38.08 180 bottom
RN3400  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  304.65 144.63 90 bottom
RN3401  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  304.65 147.05 90 bottom
RN3402  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  304.65 149.84 90 bottom
RN3403  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  304.65 153.02 90 bottom
RN4500  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  104.88 182.1 180 bottom
RN4501  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  124.69 184.89 180 bottom
RN4502  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  121.39 184.89 180 bottom
RN4503  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  119.11 184.89 180 bottom
RN4504  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  116.82 184.89 180 bottom
RN4505  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  114.41 184.89 180 bottom
RN4800  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  307.19 94.64 90 top
RN4801  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  306.83 103.28 90 top
RN4802  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  306.84 106.07 90 top
RN4803  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  307.05 91.72 90 top
RN5301  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  290.56 88.63 90 bottom
RN5500  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  306.69 54.46 270 top
RN5501  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  308.21 50.27 0 bottom
RN5502  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  306.69 52.18 270 top
RN5503  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  303.76 78.98 270 top
RN5504  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  305.42 79.48 90 bottom
RN5505  0Ohm  [VX_2R4P1234_CHOKE_4P_COLAY]  303.76 76.56 270 top
SP2601  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  251.19 52.56 270 top
SR0701  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  149.08 23.6 270 bottom
SR0702  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  146.92 21.95 180 bottom
SR0703  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  116.43 80.12 180 bottom
SR1001  0Ohm  [VX_R0402_SMALL_SHORT]  121.62 102.95 0 bottom
SR1002  0Ohm  [VX_R0402_SMALL_SHORT]  75.51 106.46 90 top
SR1101  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  283.24 53.75 90 bottom
SR1102  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  282.89 55.35 90 bottom
SR1103  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  286.62 49.38 180 top
SR1104  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  282.95 54.41 180 top
SR1105  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  284.71 61.58 270 bottom
SR1201  0Ohm  [VX_R0402_SMALL_SHORT]  302.9 58.25 180 top
SR1202  0Ohm  [VX_R0402_SMALL_SHORT]  302.44 60.25 180 top
SR1203  0Ohm  [VX_R0402_SMALL_SHORT]  289.16 52.69 0 top
SR1204  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  301.53 57.72 270 top
SR1205  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  300.64 57.72 270 top
SR1206  0Ohm  [VX_R0603_SMALL_SHORT]  286.11 53.7 270 bottom
SR1301  0Ohm  [VX_R0402_SMALL_SHORT]  276.26 88.96 0 top
SR1501  0Ohm  [VX_R0603_SMALL_SHORT]  23.93 11.79 180 top
SR1601  0Ohm  [VX_R0402_SMALL_SHORT]  87.73 70.95 0 bottom
SR1602  0Ohm  [VX_R0402_SMALL_SHORT]  85.39 70.95 180 bottom
SR1701  0Ohm  [VX_R0402_SMALL_SHORT]  61.72 102.72 0 top
SR1702  0Ohm  [VX_R0402_SMALL_SHORT]  61.72 101.84 0 top
SR2001  0Ohm  [VX_R0402_SMALL_SHORT]  223.94 76.03 0 bottom
SR2101  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  249.79 62.19 180 top
SR2201  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  245.89 68.1 0 top
SR2202  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  243.23 59.92 180 top
SR2203  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  246.07 60.63 180 top
SR2204  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  243.23 62.13 180 top
SR2205  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  243.23 62.67 180 bottom
SR2206  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  246.07 63.35 180 bottom
SR2207  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  245.89 64.57 180 top
SR2208  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  245.89 65.41 180 top
SR2209  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  248.75 62.75 180 bottom
SR2210  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  248.66 53.83 180 bottom
SR2211  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  247.48 54.67 180 bottom
SR2212  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  245.85 55.33 180 bottom
SR2213  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  243.87 54.21 180 bottom
SR2214  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  249.08 55.14 180 bottom
SR2215  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  248.56 56.01 180 bottom
SR2301  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  235.44 74.35 90 top
SR2302  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  237.17 74.35 90 bottom
SR2303  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  234.58 74.35 90 bottom
SR2304  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  235.44 74.35 90 bottom
SR2305  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  236.3 74.35 90 bottom
SR2401  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  233.53 74.35 270 top
SR2402  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  248.64 64.65 180 bottom
SR2403  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  244.2 69.88 270 top
SR2404  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  241.66 69.4 270 top
SR2405  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  245.85 58.04 180 top
SR2406  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  231.04 74.35 270 bottom
SR2407  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  246.23 71.01 270 top
SR2408  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  242.55 77.25 90 top
SR2409  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  240.39 73.56 270 top
SR2410  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  250.81 56.16 0 top
SR2501  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  213.04 72.78 0 bottom
SR2502  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  213.04 73.62 0 bottom
SR2503  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  225.38 71.43 90 top
SR2504  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  213.04 71.94 0 bottom
SR2505  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  224.52 71.43 90 top
SR2506  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  213.04 71.1 0 bottom
SR2507  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  223.68 71.43 90 top
SR2508  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  217.76 74.12 0 bottom
SR2509  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  217.76 75.01 0 bottom
SR2510  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  226.27 71.43 90 top
SR2511  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  215.1 74.1 0 bottom
SR2512  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  215.1 74.99 0 bottom
SR2513  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  220.58 64.18 180 top
SR2514  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  220.58 65.06 180 top
SR2515  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  220.94 74.86 90 bottom
SR2516  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  220.05 74.86 90 bottom
SR2517  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  222.71 74.86 90 bottom
SR2518  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  221.82 74.86 90 bottom
SR2519  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  221.93 72.9 90 top
SR2520  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  222.82 72.9 90 top
SR2601  0Ohm  [VX_R0603_SMALL_SHORT]  244.07 46.21 180 bottom
SR2602  0Ohm  [VX_R0603_SMALL_SHORT]  219.94 73.82 0 top
SR2603  0Ohm  [VX_R0603_SMALL_SHORT]  243.57 73.31 90 top
SR2604  0Ohm  [VX_R0603_SMALL_SHORT]  210.55 49.38 270 bottom
SR2605  0Ohm  [VX_R0603_SMALL_SHORT]  248.27 68.94 0 top
SR2606  0Ohm  [VX_R0603_SMALL_SHORT]  240.14 47.84 270 top
SR2607  0Ohm  [VX_R0603_SMALL_SHORT]  229.09 71.61 90 top
SR2701  0Ohm  [VX_R0402_SMALL_SHORT]  227.01 65.26 180 top
SR2702  0Ohm  [VX_R0402_SMALL_SHORT]  226.83 68.75 270 top
SR3001  0Ohm  [VX_R0603_SMALL_SHORT]  145.01 37.07 0 top
SR3002  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  166.22 16.87 0 top
SR3003  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  165.26 29.27 90 bottom
SR3004  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  164.34 29.27 90 bottom
SR3005  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  159.52 40.11 270 top
SR3006  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  158.64 40.11 270 top
SR3007  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  157.82 40.11 270 top
SR3008  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  161.28 40.11 270 top
SR3009  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  160.37 40.11 270 top
SR3010  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  165.79 25.24 180 top
SR3011  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  165.79 26.09 180 top
SR3012  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  153.99 38.45 90 top
SR3013  0Ohm  [VX_R0603_SMALL_SHORT]  149.97 15.86 0 top
SR3014  0Ohm  [VX_R0603_SMALL_SHORT]  151.82 16.11 90 top
SR3015  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  154.83 38.45 270 top
SR3016  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  143.19 30.97 180 top
SR3017  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  150.46 38.41 270 top
SR3018  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  168.68 19.88 0 top
SR3019  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  141.46 13.55 180 top
SR3020  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  146.03 14.31 180 top
SR3021  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  134.84 14.26 180 top
SR3022  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  138.41 13.93 180 top
SR3023  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  152.84 15.88 90 top
SR3024  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  153.68 15.88 90 top
SR3025  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  153.02 13.95 0 top
SR3026  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  166.16 18.96 0 top
SR3101  0Ohm  [VX_R0603_SMALL_SHORT]  181.36 25 90 top
SR3102  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  181.84 14.14 0 top
SR3103  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  181.84 13.19 0 top
SR3104  0Ohm  [VX_R0603_SMALL_SHORT]  182.15 12.13 0 top
SR3105  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  210.42 22.04 90 top
SR3106  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  209.53 22.04 90 top
SR3107  0Ohm  [VX_R0402_SMALL_SHORT]  206.61 21.57 180 top
SR3108  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  273.79 58.15 0 bottom
SR3109  0Ohm  [VX_R0603_SMALL_SHORT]  276.05 59.42 180 bottom
SR3110  0Ohm  [VX_R0603_SMALL_SHORT]  277.35 52.43 0 bottom
SR3301  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  288.27 96.3 90 top
SR3302  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  289.16 96.3 90 top
SR3303  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  274.43 100.44 180 top
SR3304  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  286.37 93.53 90 top
SR3305  0Ohm  [VX_R0603_SMALL_SHORT]  275.44 99.4 0 bottom
SR3601  0Ohm  [VX_R0603_SMALL_SHORT]  4.43 21.06 90 top
SR3602  0Ohm  [VX_R0603_SMALL_SHORT]  11.59 18.45 180 top
SR3603  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  8.29 22.18 270 top
SR3604  0Ohm  [VX_R0603_SMALL_SHORT]  13.19 17.58 90 bottom
SR3605  0Ohm  [VX_R0603_SMALL_SHORT]  14.46 17.58 90 bottom
SR3606  0Ohm  [VX_R0603_SMALL_SHORT]  15.6 19.79 90 bottom
SR3607  0Ohm  [VX_R0603_SMALL_SHORT]  16.87 19.79 90 bottom
SR3701  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  66.15 11.92 180 bottom
SR3702  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  66.66 15.22 0 top
SR3703  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  66.66 16.06 0 top
SR4401  0Ohm  [VX_R0603_SMALL_SHORT]  56.24 134.47 90 top
SR4402  0Ohm  [VX_R0603_SMALL_SHORT]  54.72 134.47 90 top
SR4403  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  63.86 131.43 0 bottom
SR4404  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  63.99 143.49 0 bottom
SR4405  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  63.4 141.33 270 bottom
SR4406  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  55.83 125.1 270 bottom
SR4407  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  55.83 126.73 270 bottom
SR4408  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  63.86 133.95 180 bottom
SR4409  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  63.86 132.7 180 bottom
SR4410  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  54.1 126.74 90 bottom
SR4501  0Ohm  [VX_R0402_SMALL_SHORT]  107.41 187.56 180 bottom
SR4502  0Ohm  [VX_R0603_SMALL_SHORT]  100.64 185.78 90 bottom
SR4503  0Ohm  [VX_R0402_SMALL_SHORT]  109.51 190.1 90 bottom
SR4504  0Ohm  [VX_R0603_SMALL_SHORT]  101.2 191.04 0 bottom
SR4505  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  92.69 189.21 270 top
SR4506  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  110.6 182.75 90 bottom
SR4507  0Ohm  [VX_R0603_SMALL_SHORT]  87.23 190.86 0 top
SR4601  0Ohm  [VX_R0603_SMALL_SHORT]  304.76 109.05 90 top
SR5001  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  127.25 28.56 0 top
SR5101  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  25.51 31.6 270 top
SR5102  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  35.62 29.88 180 top
SR5103  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  35.06 26.11 0 top
SR5104  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  34.63 28.81 0 top
SR5105  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  35.29 37.32 0 top
SR5106  0Ohm  [VX_R0603_SMALL_SHORT]  35.31 32.01 0 top
SR5107  0Ohm  [VX_R0603_SMALL_SHORT]  30.46 25 90 top
SR5108  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  49.64 17.25 180 bottom
SR5109  0Ohm  [VX_R0603_SMALL_SHORT]  60.69 14.84 180 top
SR5201  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  294.46 66.94 0 top
SR5202  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  294.43 66.07 0 top
SR5203  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  284.89 65.67 0 top
SR5301  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  307.46 101.45 180 top
SR5302  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  301.53 105.65 270 top
SR5701  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  203.82 135.19 90 top
SR5702  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  137.78 34.14 90 bottom
SR5703  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  21.57 59.42 90 top
SR5704  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  274.1 68.97 270 bottom
SR5705  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  204.96 133.84 0 top
SR5706  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  238.99 27.92 270 bottom
SR5707  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  234.07 27.69 90 bottom
SR6001  0Ohm  [VX_R0603_SMALL_SHORT]  295.05 29.18 180 bottom
SR6002  0Ohm  [VX_R0603_SMALL_SHORT]  295.05 30.45 180 bottom
SR6201  0Ohm  [VX_R0603_SMALL_SHORT]  241.26 36.99 0 top
SR6202  0Ohm  [VX_R0603_SMALL_SHORT]  228.83 31.86 0 top
SR6701  0Ohm  [VX_R0603_SMALL_SHORT]  13.16 84.08 270 top
SR6702  0Ohm  [VX_R0603_SMALL_SHORT]  8.71 55.86 180 top
SR6703  0Ohm  [VX_R0603_SMALL_SHORT]  6.12 49.64 0 top
SR7001  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  129.39 88.48 90 bottom
SR7002  0Ohm  [VX_R0603_SMALL_SHORT]  135.92 94.83 270 top
SR7101  0Ohm  [VX_R0603_SMALL_SHORT]  151.87 59.8 0 top
SR7102  0Ohm  [VX_R0603_SMALL_SHORT]  151.87 58.53 180 top
SR7201  0Ohm  [VX_R0603_SMALL_SHORT]  140.32 81.33 270 top
SR7202  0Ohm  [VX_R0603_SMALL_SHORT]  143.24 79.36 0 top
SR7203  0Ohm  [VX_R0603_SMALL_SHORT]  137.33 81.26 270 top
SR7204  0Ohm  [VX_R0603_SMALL_SHORT]  142.98 82.68 0 top
SR7205  0Ohm  [VX_R0603_SMALL_SHORT]  143.14 83.93 0 top
SR7206  0Ohm  [VX_R0603_SMALL_SHORT]  143.14 86.04 0 top
SR7207  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  291.93 122.16 90 top
SR7208  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  292.82 122.16 90 top
SR7209  0Ohm  [VX_R0603_SMALL_SHORT]  143 90.28 0 top
SR7210  0Ohm  [VX_R0603_SMALL_SHORT]  143 88.75 0 top
SR7211  0Ohm  [VX_R0603_SMALL_SHORT]  143 87.36 0 top
SR7401  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  133.56 71.25 90 bottom
SR7402  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  134.39 71.25 90 bottom
SR7403  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  146.67 71.36 270 top
SR7404  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  139.48 60.84 0 bottom
SR7405  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  145.27 71.36 90 bottom
SR7406  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  142.12 69.2 270 bottom
SR7407  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  138.74 77.78 270 bottom
SR7408  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  137.92 77.78 270 bottom
SR7409  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  146.72 69.25 270 bottom
SR7410  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  141.23 69.2 270 bottom
SR7411  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  144.51 71.36 90 top
SR7412  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  152.85 66.01 0 bottom
SR7413  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  150.22 64.88 270 bottom
SR7414  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  137.34 59.18 90 bottom
SR7415  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  144 69.2 270 bottom
SR7416  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  137.73 51.92 180 bottom
SR7417  0Ohm  [VX_R0402_SMALL_SHORT]  144 52.81 180 bottom
SR7418  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  145.39 72.62 0 top
SR7501  0Ohm  [VX_R0402_SMALL_SHORT]  211.74 99.37 90 bottom
SR7502  0Ohm  [VX_R0402_SMALL_SHORT]  213.12 100.6 180 bottom
SR7503  0Ohm  [VX_R0402_SMALL_SHORT]  213.12 99.73 0 bottom
SR7504  0Ohm  [VX_R0402_SMALL_SHORT]  211.75 100.98 270 bottom
SR8000  R0402  [NB_R0402_SHORT_5MIL_SMALL]  54.67 189.16 180 bottom
SR8001  R0402  [NB_R0402_SHORT_5MIL_SMALL]  55.48 190.28 90 top
SR8002  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  101.2 161.27 90 top
SR8003  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  65.89 173.84 90 top
SR8004  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  55.72 164.45 0 top
SR8005  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  66.4 145.4 90 bottom
SR8006  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  76.82 182.99 90 bottom
SR8007  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  67.29 164.32 90 bottom
SR8008  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  56.86 188.54 270 bottom
SR8009  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  58.68 188.93 270 bottom
SR8010  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  59.52 188.54 270 bottom
SR8011  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  58.12 188.55 270 top
SR8012  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  55.18 181.75 270 top
SR8013  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  53.4 182.38 270 top
SR8014  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  48.51 182.94 0 top
SR8015  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  99.55 154.92 180 top
SR8016  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  52.05 188.83 0 top
SR8017  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  71.86 183.3 270 bottom
SR8018  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  48.75 177.44 270 bottom
SR8019  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  50.31 188.83 0 top
SR8100  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  261.35 63.74 90 top
SR8101  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  261.98 55.61 90 top
SR8102  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  256.77 64.62 180 top
SR8103  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  264.89 66.53 0 top
SR8104  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  261.98 76.99 90 top
SR8200  R0402  [NB_R0402_SHORT_5MIL_SMALL]  225.77 18.4 180 top
SR8201  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  224.54 10.78 180 top
SR8300  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  27.46 55.48 270 top
SR8301  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  29.37 54.08 180 top
SR8302  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  33.18 49.13 270 top
SR8303  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  30.76 47.99 270 top
SR8400  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  224.52 27.54 270 top
SR8701  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  131.55 157.33 180 top
SR8702  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  130.28 160 270 top
SR8703  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  131.04 162.67 180 top
SR8704  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  131.04 161.65 180 top
SR8706  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  131.55 158.35 180 top
SR8707  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  133.46 154.39 270 top
SR8708  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  132.62 154.38 270 top
SR8801  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  261.42 33.26 270 top
SR8802  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  260.56 33.26 270 top
SR8803  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  281.29 31.99 180 top
SR8804  R0603  [NB_R0603_SHORT_32MIL_SMALL]  282.56 28.56 180 top
SR8805  R0603  [NB_R0603_SHORT_32MIL_SMALL]  282.56 27.29 180 top
SR8806  NB_R0603_32MIL_SMALL  [NB_R0603_SHORT_32MIL_SMALL]  281.29 36.94 270 top
SR8807  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  267.85 37.35 180 top
SR8809  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  273.72 28.79 90 top
SR8810  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  263.53 34.2 90 top
SR8811  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  262.64 34.2 90 top
SR8812  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  241.66 19.41 0 bottom
SR8813  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  271.89 35.49 90 top
SR8814  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  272.47 33.28 270 top
SR8900  R0402  [NB_R0402_SHORT_5MIL_SMALL]  252.91 78.98 0 bottom
SR8901  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  246.61 80.37 180 top
SR8902  R0402  [NB_R0402_SHORT_5MIL_SMALL]  251.26 78.98 0 bottom
SR8903  R0402  [NB_R0402_SHORT_5MIL_SMALL]  254.34 79.61 90 bottom
SR8904  R0402  [NB_R0402_SHORT_5MIL_SMALL]  250.93 79.74 90 top
SR8906  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  253.21 83.95 0 top
SR8908  R0402  [NB_R0402_SHORT_5MIL_SMALL]  250.07 85.99 270 bottom
SR8909  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  248.14 79.74 270 top
SR8910  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  246.74 85.58 180 top
SR8911  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  247.38 87.1 180 top
SR8912  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  253.22 86.09 270 top
SR8913  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  253.21 84.82 0 top
SR8914  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  250.81 87.12 270 top
SR9101  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  183.88 34.14 270 top
SR9103  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  177.01 22.08 90 top
SR9104  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  241.53 29.06 0 top
SR9105  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  131.9 70.34 180 top
SR9204  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  170.19 37.55 180 top
SR9206  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  178.14 39.76 0 top
SR9207  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  163.05 40.11 0 top
SR9208  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  163.84 41.87 270 top
SR9209  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  164.67 41.87 270 top
SR9210  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  166.35 41.86 270 top
SR9400  R0402  [NB_R0402_SHORT_5MIL_SMALL]  103.26 171.57 270 bottom
SR9401  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  102.6 163.81 90 bottom
SR9500  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  99.93 13.19 180 bottom
SR9700  R0402  [NB_R0402_SHORT_5MIL_SMALL]  196.32 188.27 180 top
SR9703  NB_R0402_5MIL_SMALL  [NB_R0402_SHORT_5MIL_SMALL]  203.94 190.99 180 top
SR9705  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  193.83 190.9 270 top
SR9706  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  203.56 187.18 0 top
SR9707  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  202.8 185.91 270 top
SR9708  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  196.32 187.31 180 top
SR9709  NB_R0402_20MIL_SMALL  [NB_R0402_SHORT_20MIL_SMALL]  196.32 186.16 180 top
SR9710  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  203.93 190.12 180 top
SR9711  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  193.43 188.25 90 top
SR9712  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  194.29 188.25 90 top
SR9713  R0402_20mil  [NB_R0402_SHORT_20MIL_SMALL]  91.16 183.27 0 top
T0301  TPC26T  [NB_TPC26T_68]  118.04 126.75 180 bottom
T0700  TPC26T  [NB_TPC26T_68]  75.67 125.84 0 top
T0701  TPC26T  [NB_TPC26T_68]  74.93 123.87 0 top
T0702  TPC26T  [NB_TPC26T_68]  124.29 96.55 180 bottom
T0703  TPC26T  [NB_TPC26T_68]  75.81 127.77 0 top
T0704  TPC26T  [NB_TPC26T_68]  121.09 99.07 0 top
T0706  TPC26T  [NB_TPC26T_68]  120.24 102.91 180 bottom
T0707  TPC26T  [NB_TPC26T_68]  80.92 112.05 0 top
T0708  TPC26T  [NB_TPC26T_68]  77.92 112.4 0 top
T0709  TPC26T  [NB_TPC26T_68]  73.97 102.34 0 top
T0710  TPC26T  [NB_TPC26T_68]  75.06 104.3 0 top
T0714  TPC26T  [NB_TPC26T_68]  77.44 126.98 0 top
T0717  TPC26T  [NB_TPC26T_68]  78.82 115.73 0 top
T0719  TPC26T  [NB_TPC26T_68]  78.83 113.95 0 top
T0722  TPC26T  [NB_TPC26T_68]  81.16 118.68 0 top
T0724  TPC26T  [NB_TPC26T_68]  79.51 119.31 0 top
T0729  TPC26T  [NB_TPC26T_68]  72.62 113.65 0 top
T0730  TPC26T  [NB_TPC26T_68]  72.62 111.87 0 top
T0732  TPC26T  [NB_TPC26T_68]  79.1 128.61 0 top
T0734  TPC26T  [NB_TPC26T_68]  78.42 130.21 0 top
T0745  TPC26T  [NB_TPC26T_68]  77.34 125.18 0 top
T1000  TPC26T  [NB_TPC26T_68]  89.5 112.02 0 top
T1001  TPC26T  [NB_TPC26T_68]  87.57 112.1 0 top
T1002  TPC26T  [NB_TPC26T_68]  110.06 114.66 0 top
T1003  TPC26T  [NB_TPC26T_68]  110.52 112.53 0 top
T1101  TPC28T  [NB_TPC28T_68]  285.02 46.46 0 bottom
T1102  TPC28T  [NB_TPC28T_68]  281.46 46.16 0 bottom
T1103  TPC28T  [NB_TPC28T_68]  281.21 48.67 0 bottom
T1104  TPC28T  [NB_TPC28T_68]  280.12 47.28 0 bottom
T1105  TPC26T  [NB_TPC26T_68]  289.87 33.38 180 bottom
T1106  TPC26T  [NB_TPC26T_68]  289.41 35.41 180 bottom
T1107  TPC26T  [NB_TPC26T_68]  288.45 32.14 90 top
T1108  TPC26T  [NB_TPC26T_68]  288.96 33.97 90 top
T1109  TPC26T  [NB_TPC26T_68]  303.54 33.6 90 top
T1110  TPC26T  [NB_TPC26T_68]  301.99 34.42 90 top
T1111  TPC26T  [NB_TPC26T_68]  298.97 37.97 180 bottom
T1112  TPC26T  [NB_TPC26T_68]  291.18 34.55 180 bottom
T1205  TPC26T  [NB_TPC26T_68]  279.99 61.53 180 bottom
T1206  TPC26T  [NB_TPC26T_68]  280.75 59.82 180 bottom
T1207  TPC26T  [NB_TPC26T_68]  284.71 63.13 180 bottom
T1208  TPC26T  [NB_TPC26T_68]  281.74 61.25 180 bottom
T1209  TPC26T  [NB_TPC26T_68]  284.99 59.09 180 bottom
T1210  TPC26T  [NB_TPC26T_68]  282.73 59.82 180 bottom
T1600  TPC26T  [NB_TPC26T_68]  129.39 41.66 180 bottom
T1601  TPC26T  [NB_TPC26T_68]  125.56 43.47 180 bottom
T1602  TPC26T  [NB_TPC26T_68]  125.56 45.24 180 bottom
T1603  TPC26T  [NB_TPC26T_68]  129.39 43.44 180 bottom
T1700  TPC26T  [NB_TPC26T_68]  124.62 46.84 0 top
T1701  TPC26T  [NB_TPC26T_68]  124.42 44.53 0 top
T1702  TPC26T  [NB_TPC26T_68]  117.15 50.91 180 bottom
T1703  TPC26T  [NB_TPC26T_68]  117.15 49.05 180 bottom
T2201  TPC26T  [NB_TPC26T_68]  232.59 55.61 0 top
T2202  TPC26T  [NB_TPC26T_68]  234.8 52.08 0 top
T2203  TPC26T  [NB_TPC26T_68]  238.92 62.31 0 top
T2204  TPC26T  [NB_TPC26T_68]  233.34 71.36 0 top
T2205  TPC26T  [NB_TPC26T_68]  242.35 60.99 0 top
T2400  TPC26T  [NB_TPC26T_68]  233.15 57.74 0 top
T2401  TPC26T  [NB_TPC26T_68]  242.91 64.73 180 bottom
T2402  TPC26T  [NB_TPC26T_68]  235.24 61.91 0 top
T2403  TPC26T  [NB_TPC26T_68]  241.57 70.96 270 top
T2404  TPC26T  [NB_TPC26T_68]  252.53 62.87 270 top
T2405  TPC26T  [NB_TPC26T_68]  243.8 68.51 270 top
T2406  TPC26T  [NB_TPC26T_68]  247.26 64.73 180 bottom
T2407  TPC26T  [NB_TPC26T_68]  234.38 69.89 0 top
T2408  TPC26T  [NB_TPC26T_68]  240.82 57.16 0 top
T2409  TPC26T  [NB_TPC26T_68]  233.18 68.6 0 top
T2410  TPC26T  [NB_TPC26T_68]  250.15 64.78 180 bottom
T2411  TPC26T  [NB_TPC26T_68]  232.57 73.01 0 top
T2500  TPC26T  [NB_TPC26T_68]  237.01 70.37 0 top
T2501  TPC26T  [NB_TPC26T_68]  237.72 72.47 0 top
T2502  TPC26T  [NB_TPC26T_68]  217.53 69.83 0 top
T2503  TPC26T  [NB_TPC26T_68]  217.53 71.61 0 top
T3300  TPC28T  [NB_TPC28T_68]  275.92 100.46 0 top
T3301  TPC28T  [NB_TPC28T_68]  281.59 96.78 0 top
T3302  TPC28T  [NB_TPC28T_68]  281.65 95.04 0 top
T3303  TPC28T  [NB_TPC28T_68]  271.4 98.84 0 top
T3602  TPC28T  [NB_TPC28T_68]  12.93 28.18 90 bottom
T4401  TPC26T  [NB_TPC26T_68]  209.78 56.24 0 top
T4504  TPC28T  [NB_TPC28T_68]  112.53 188.91 180 bottom
T4505  TPC28T  [NB_TPC28T_68]  118.75 191.68 180 bottom
T4506  TPC28T  [NB_TPC28T_68]  103.74 190.35 180 bottom
T4507  TPC28T  [NB_TPC28T_68]  108.24 191.83 180 bottom
T4508  TPC28T  [NB_TPC28T_68]  107.52 190.08 180 bottom
T4509  TPC28T  [NB_TPC28T_68]  100.69 187.81 180 bottom
T4510  TPC28T  [NB_TPC28T_68]  112.63 183.88 180 bottom
T5102  TPC26T  [NB_TPC26T_68]  22.54 38.39 0 top
T5103  TPC28T  [NB_TPC28T_68]  17.86 21.95 270 bottom
T5104  TPC26T  [NB_TPC26T_68]  52.81 16.87 180 bottom
T5105  TPC28T  [NB_TPC28T_68]  34.5 10.47 0 top
T5201  TPC26T  [NB_TPC26T_68]  158.6 31.45 180 bottom
T5301  TPC26T  [NB_TPC26T_68]  290.56 101.96 180 bottom
T5302  TPC26T  [NB_TPC26T_68]  303.94 88.88 180 bottom
T5303  TPC26T  [NB_TPC26T_68]  288.78 101.96 180 bottom
T5304  TPC26T  [NB_TPC26T_68]  292.33 101.96 180 bottom
T5305  TPC26T  [NB_TPC26T_68]  292.33 103.74 180 bottom
T5306  TPC26T  [NB_TPC26T_68]  300.21 105.39 180 bottom
T5307  TPC26T  [NB_TPC26T_68]  305.54 101.96 180 bottom
T5308  TPC26T  [NB_TPC26T_68]  300.21 103.61 180 bottom
T5309  TPC26T  [NB_TPC26T_68]  301.99 103.61 180 bottom
T5310  TPC26T  [NB_TPC26T_68]  303.76 101.96 180 bottom
T5801  TPC26T  [NB_TPC26T_68]  302.11 137.9 0 top
T5802  TPC26T  [NB_TPC26T_68]  306.76 137.27 0 top
T6001  TPC26T  [NB_TPC26T_68]  287.92 25.92 180 bottom
T6002  TPC26T  [NB_TPC26T_68]  309.23 13.7 0 top
T7401  TPC28T  [NB_TPC28T_68]  147 84.08 0 top
T7402  TPC28T  [NB_TPC28T_68]  150.48 77.83 180 top
T7406  TPC28T  [NB_TPC28T_68]  139.12 91.87 180 bottom
T7407  TPC28T  [NB_TPC28T_68]  141.33 90.08 180 bottom
T7408  TPC28T  [NB_TPC28T_68]  139.58 90.15 180 bottom
T7409  TPC28T  [NB_TPC28T_68]  136.94 90.66 180 bottom
T7410  TPC28T  [NB_TPC28T_68]  135.46 89.21 180 bottom
T7501  TPC28T  [NB_TPC28T_68]  171.18 111.49 0 top
T8050  TPC28T  [NB_TPC28T_68]  76.05 149.59 180 bottom
T8051  TPC28T  [NB_TPC28T_68]  75.42 176.31 180 bottom
T8052  TPC28T  [NB_TPC28T_68]  74.33 162.67 180 bottom
T8053  TPC28T  [NB_TPC28T_68]  96.27 155.91 90 top
T8054  TPC28T  [NB_TPC28T_68]  49.13 167.88 0 top
T8055  TPC28T  [NB_TPC28T_68]  67.82 167.22 0 top
T8100  TPC26T  [NB_TPC26T_68]  265.03 59.54 90 top
T8101  TPC26T  [NB_TPC26T_68]  273.28 15.09 180 bottom
T8102  TPC26T  [NB_TPC26T_68]  268.97 69.96 270 top
T8103  TPC26T  [NB_TPC26T_68]  270.74 24.24 0 top
T8104  TPC26T  [NB_TPC26T_68]  261.32 73.64 270 bottom
T8105  TPC26T  [NB_TPC26T_68]  258.88 56.92 180 bottom
T8106  TPC26T  [NB_TPC26T_68]  262.03 68.61 270 top
T8107  TPC26T  [NB_TPC26T_68]  256.39 58.38 90 top
T8108  TPC26T  [NB_TPC26T_68]  280.42 77.48 180 top
T8109  TPC26T  [NB_TPC26T_68]  284.41 77.6 270 top
T8110  TPC26T  [NB_TPC26T_68]  275.82 14.84 180 bottom
T8111  TPC26T  [NB_TPC26T_68]  287.28 80.53 180 bottom
T8112  TPC26T  [NB_TPC26T_68]  246.31 33.03 0 top
T8113  TPC26T  [NB_TPC26T_68]  247.81 35.92 0 top
T8114  TPC26T  [NB_TPC26T_68]  268.33 59.93 90 top
T8115  TPC26T  [NB_TPC26T_68]  273.21 18.63 0 top
T8116  TPC26T  [NB_TPC26T_68]  277.86 14.69 180 bottom
T8117  TPC26T  [NB_TPC26T_68]  284.05 70.7 270 top
T8118  TPC26T  [NB_TPC26T_68]  276.79 70.29 180 top
T8119  TPC26T  [NB_TPC26T_68]  258.86 62.64 180 top
T8120  TPC26T  [NB_TPC26T_68]  257.38 75.72 180 top
T8121  TPC26T  [NB_TPC26T_68]  254.94 64.65 90 top
T8122  TPC26T  [NB_TPC26T_68]  263.81 61.35 180 bottom
T8123  TPC26T  [NB_TPC26T_68]  265.33 59.98 270 bottom
T8124  TPC26T  [NB_TPC26T_68]  248.88 26.22 0 top
T8125  TPC26T  [NB_TPC26T_68]  256.9 24.87 0 top
T8126  TPC26T  [NB_TPC26T_68]  252.94 73.77 90 top
T8127  TPC26T  [NB_TPC26T_68]  131.48 37.65 0 top
T8200  TPC28T  [NB_TPC28T_68]  219.36 18.02 0 top
T8201  TPC28T  [NB_TPC28T_68]  204.45 13.7 90 top
T8202  TPC28T  [NB_TPC28T_68]  208.01 58.02 0 top
T8203  TPC28T  [NB_TPC28T_68]  228.71 16.62 0 top
T8204  TPC28T  [NB_TPC28T_68]  208.01 56.24 0 top
T8205  TPC28T  [NB_TPC28T_68]  230.61 12.05 0 top
T8300  TPC28T  [NB_TPC28T_68]  28.17 48.11 0 bottom
T8301  TPC28T  [NB_TPC28T_68]  27.36 72.91 180 top
T8302  TPC28T  [NB_TPC28T_68]  38.08 102.95 180 top
T8303  TPC28T  [NB_TPC28T_68]  38.18 97.01 270 top
T8304  TPC28T  [NB_TPC28T_68]  38.08 99.73 270 top
T8305  TPC28T  [NB_TPC28T_68]  21.75 50.5 0 top
T8306  TPC28T  [NB_TPC28T_68]  224.14 98.15 0 top
T8307  TPC28T  [NB_TPC28T_68]  134.78 148.57 0 top
T8308  TPC28T  [NB_TPC28T_68]  20.81 53.7 270 top
T8309  TPC28T  [NB_TPC28T_68]  22.59 53.7 270 top
T8310  TPC28T  [NB_TPC28T_68]  24.36 53.7 270 top
T8311  TPC28T  [NB_TPC28T_68]  273.18 16.87 0 top
T8312  TPC28T  [NB_TPC28T_68]  29.85 65.95 180 top
T8313  TPC28T  [NB_TPC28T_68]  118.22 11.03 0 top
T8400  TPC26T  [NB_TPC26T_68]  216.97 26.6 0 top
T8601  TPC28T  [NB_TPC28T_68]  135.26 155.1 0 top
T8602  TPC28T  [NB_TPC28T_68]  120 79.61 0 top
T8603  TPC28T  [NB_TPC28T_68]  132.87 90.48 0 top
T8604  TPC28T  [NB_TPC28T_68]  124.34 74.61 0 top
T8605  TPC28T  [NB_TPC28T_68]  120.48 81.44 0 top
T8606  TPC28T  [NB_TPC28T_68]  125.96 64.7 0 top
T8607  TPC28T  [NB_TPC28T_68]  121.7 80.12 0 top
T8608  TPC28T  [NB_TPC28T_68]  129.85 83.04 0 top
T8609  TPC28T  [NB_TPC28T_68]  127.87 76.33 0 top
T8610  TPC28T  [NB_TPC28T_68]  125.43 76.54 0 top
T8611  TPC28T  [NB_TPC28T_68]  133.18 118.45 0 top
T8612  TPC28T  [NB_TPC28T_68]  132.21 120.15 0 top
T8613  TPC28T  [NB_TPC28T_68]  124.26 51.95 0 top
T8700  TPC28T  [NB_TPC28T_68]  127.67 162.8 180 bottom
T8702  TPC28T  [NB_TPC28T_68]  128.25 158.6 90 bottom
T8715  TPC28T  [NB_TPC28T_68]  89.77 182.35 0 top
T8800  TPC28T  [NB_TPC28T_68]  283.06 25.89 180 bottom
T8801  TPC28T  [NB_TPC28T_68]  279.89 31.48 180 bottom
T8802  TPC28T  [NB_TPC28T_68]  310.37 26.19 0 top
T8803  TPC28T  [NB_TPC28T_68]  310.42 14.99 0 top
T8804  TPC28T  [NB_TPC28T_68]  303.74 23.78 0 top
T8805  TPC28T  [NB_TPC28T_68]  302.72 18.42 0 top
T8806  TPC28T  [NB_TPC28T_68]  283.44 16.49 0 top
T8807  TPC28T  [NB_TPC28T_68]  285.22 16.49 0 top
T8808  TPC28T  [NB_TPC28T_68]  3.79 74.86 0 top
T8809  TPC28T  [NB_TPC28T_68]  5.77 72.32 0 top
T8810  TPC28T  [NB_TPC28T_68]  279 14.46 270 top
T8811  TPC28T  [NB_TPC28T_68]  276.97 14.46 270 top
T8813  TPC28T  [NB_TPC28T_68]  274.78 29.32 0 top
T8900  TPC28T  [NB_TPC28T_68]  223.12 96.37 270 top
T8901  TPC28T  [NB_TPC28T_68]  213.72 76.54 90 top
T8902  TPC28T  [NB_TPC28T_68]  215.17 80.04 90 top
T8904  TPC28T  [NB_TPC28T_68]  205.24 178.34 270 bottom
T8905  TPC28T  [NB_TPC28T_68]  186.7 174.17 0 top
T8906  TPC28T  [NB_TPC28T_68]  208.41 147.58 90 top
T8907  TPC28T  [NB_TPC28T_68]  211.92 101.38 90 top
T8908  TPC28T  [NB_TPC28T_68]  211.79 99.63 0 top
T9100  TPC26T  [NB_TPC26T_68]  192.44 33.74 270 top
T9102  TPC26T  [NB_TPC26T_68]  192.72 40.24 270 top
T9104  TPC26T  [NB_TPC26T_68]  185.53 14.31 0 top
T9105  TPC26T  [NB_TPC26T_68]  257.31 83.39 180 top
T9106  TPC26T  [NB_TPC26T_68]  261.9 84.22 90 top
T9107  TPC26T  [NB_TPC26T_68]  186.62 28.14 0 top
T9108  TPC26T  [NB_TPC26T_68]  224.52 25.89 0 top
T9110  TPC26T  [NB_TPC26T_68]  181.21 22.08 180 bottom
T9111  TPC26T  [NB_TPC26T_68]  176.56 23.48 0 top
T9113  TPC28T  [NB_TPC28T_68]  238.11 26.19 0 top
T9114  TPC28T  [NB_TPC28T_68]  234.55 25.51 0 top
T9115  TPC28T  [NB_TPC28T_68]  148.82 55.3 180 bottom
T9116  TPC28T  [NB_TPC28T_68]  134.52 75.14 0 top
T9200  TPC28T  [NB_TPC28T_68]  162.67 41.13 0 top
T9202  TPC28T  [NB_TPC28T_68]  162.67 42.91 0 top
T9203  TPC28T  [NB_TPC28T_68]  186.27 39.33 0 top
T9204  TPC28T  [NB_TPC28T_68]  171.89 40.52 0 top
T9205  TPC28T  [NB_TPC28T_68]  259.29 58.83 180 bottom
T9206  TPC28T  [NB_TPC28T_68]  172.4 38.39 0 top
T9207  TPC28T  [NB_TPC28T_68]  186.08 33.33 0 top
T9208  TPC28T  [NB_TPC28T_68]  166.6 38.08 0 top
T9209  TPC28T  [NB_TPC28T_68]  105.44 164.98 0 top
T9210  TPC28T  [NB_TPC28T_68]  185.96 43.62 0 top
T9211  TPC28T  [NB_TPC28T_68]  164.83 38.72 0 top
T9212  TPC28T  [NB_TPC28T_68]  196.5 188.22 180 bottom
T9213  TPC28T  [NB_TPC28T_68]  214.74 22.97 0 top
T9300  TPC28T  [NB_TPC28T_68]  59.87 190.86 0 top
T9301  TPC28T  [NB_TPC28T_68]  255.61 79.81 270 top
T9302  TPC28T  [NB_TPC28T_68]  253.12 77.17 270 top
T9303  TPC28T  [NB_TPC28T_68]  269.73 62.57 0 top
T9400  TPC28T  [NB_TPC28T_68]  109.51 173.03 180 bottom
T9401  TPC28T  [NB_TPC28T_68]  109.96 155.05 90 bottom
T9402  TPC28T  [NB_TPC28T_68]  108.18 155.05 90 bottom
T9403  TPC28T  [NB_TPC28T_68]  98.91 170.16 180 bottom
T9404  TPC28T  [NB_TPC28T_68]  97.14 170.16 0 bottom
T9500  TPC28T  [NB_TPC28T_68]  98.36 3.89 0 top
T9501  TPC28T  [NB_TPC28T_68]  114.41 11.03 270 top
T9502  TPC28T  [NB_TPC28T_68]  114.41 9.25 270 top
T9503  TPC28T  [NB_TPC28T_68]  106.79 10.01 270 top
T9504  TPC28T  [NB_TPC28T_68]  116.44 11.03 0 top
T9505  TPC28T  [NB_TPC28T_68]  109.84 5.7 0 top
T9600  TPC26T  [NB_TPC26T_68]  132.65 122 0 top
T9601  TPC26T  [NB_TPC26T_68]  138.28 182.1 180 bottom
T9602  TPC26T  [NB_TPC26T_68]  123.55 133.33 180 bottom
T9603  TPC26T  [NB_TPC26T_68]  123.58 145.98 180 bottom
T9607  TPC26T  [NB_TPC26T_68]  244.79 16.34 180 bottom
T9700  TPC28T  [NB_TPC28T_68]  196.25 152.89 0 top
T9701  TPC28T  [NB_TPC28T_68]  187.28 179.31 0 top
T9702  TPC28T  [NB_TPC28T_68]  207.5 174.38 0 top
T9703  TPC28T  [NB_TPC28T_68]  201.66 156.32 0 top
T9704  TPC28T  [NB_TPC28T_68]  210.24 175.17 0 top
T9705  TPC28T  [NB_TPC28T_68]  193.91 152.99 0 top
T9706  TPC28T  [NB_TPC28T_68]  192.97 144.81 0 top
T9707  TPC28T  [NB_TPC28T_68]  195.08 145.07 0 top
T9708  TPC28T  [NB_TPC28T_68]  197.01 144.79 0 top
T9709  TPC28T  [NB_TPC28T_68]  201.4 171.56 0 top
T9712  TPC28T  [NB_TPC28T_68]  195.43 171.56 0 top
T9713  TPC26T  [NB_TPC26T_68]  290.91 76.18 0 top
U0300  CL8066202194730  [VX_BGA_1440P_1102X1654_NH62]  94.7 116.7 270 bottom
U0701  74AUP1G07GW  [VX_SOT353_PHILIPS]  67.71 105.31 0 bottom
U0702  74AUP1G07GW  [VX_SOT353_PHILIPS]  119.23 80.12 90 bottom
U0703  Vcc=2~5.5  [VX_SC70_S5_TI]  147.05 24.49 270 bottom
U1101  DSL6340  [VX_BGA_337P_425X425]  294.45 40.75 90 top
U1102  SN74AUP1G17DBVR  [VX_SOT23_S5_2D4_T02_H57]  279.84 47.23 270 top
U1103  W25Q80DVSSIG  [VX_SOIC_8P_50_211X311_H85]  277.22 56.37 0 top
U1104  SN74AUP1G17DBVR  [VX_SOT23_S5_2D4_T02_H57]  280.5 55.15 90 bottom
U1105  SN74AUP1G17DBVR  [VX_SOT23_S5_2D4_T02_H57]  273.62 49.41 270 bottom
U1201  TPS65982ABZQZR  [VX_BGA_96P_20_236X236_TI]  293.99 58.2 0 top
U1202  TPS2544RTER  [VX_QFN_16P_20_S118_P_SIG_2V]  294.24 73.44 180 top
U1207  PUSB3F96  [VX_DFN_10P_20_98X39_NXP]  309.14 36.46 270 bottom
U1208  PUSB3F96  [VX_DFN_10P_20_98X39_NXP]  309.14 33.33 90 bottom
U1301  SN65DP159RSBR  [VX_QFN_40P_16_203X203_P_9V]  297 83.7 270 top
U1302  M5938CTB1U  [VX_SOT23_S6_FITI_H57]  278.24 86.09 270 top
U1401  PS8330BQFN48GTR-A0  [VX_QFN_48P_20_S276_PAD_PARA]  264.27 46.89 0 top
U1501  PS8527BTQFN20GTR2-A2  [VX_QFN_20P_20_S157_PAD_M_2V]  42.53 13.67 90 top
U2000  SKYLAKE_PCH  [VX_BGA_837P_906X906_INT]  228.2 58.96 180 bottom
U2301  UM6K1NG1DTN  [VX_SC70_S6]  233.82 46.94 180 top
U2302  UM6K1NG1DTN  [VX_SC70_S6]  241.28 42.27 0 bottom
U2401  Vcc=2~5.5  [VX_SC70_S5_TI]  228.15 29.6 0 top
U2402  Vcc=2~5.5  [VX_SC70_S5_TI]  251.84 74.24 270 bottom
U2403  Vcc=2~5.5  [VX_SC70_S5_TI]  248.77 74.32 270 bottom
U2404  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  254.18 45.3 180 bottom
U3002  IT8987E/BX  [VX_QFP_128P_16_630X630]  154.66 27.31 180 top
U3101  W25Q128FVSIQ  [VX_SOIC_8P_50_213X311]  173.46 29.87 180 top
U3102  TLC59116IPWR  [VX_SOIC_28P_26_386X252]  175.75 15.45 180 top
U3103  G5244T11U  [VX_SOT23_S5_H57]  275.44 55.42 270 bottom
