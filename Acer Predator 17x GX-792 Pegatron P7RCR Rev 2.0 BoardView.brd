# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQS7#: length 87.9
  TOP w0.146: v2(104.93,48.6) 105.37,48.6 105.5,48.73 105.5,49.86 104.88,50.48 104.88,51.44 104.71,51.61 104.5,51.61 104.37,51.73 CON1700.240
  IN4 w0.076: v3(108.25,108.92) 108.68,108.92 108.74,108.86 108.74,108.69 108.56,108.51 108.56,107.35 108.79,107.12 109.1,107.12 109.81,106.41 109.81,106.06
  IN4 w0.127: 109.81,106.06 109.81,105.18 113.21,101.78 116.2,101.78 120.39,97.6 120.39,95.5 121.42,94.46 121.42,86.11 120.28,84.97 118.54,84.97 117.5,83.93 117.5,77.38 112.44,72.32 112.44,59.76 110.87,58.18 110.87,55.13 110.66,54.93 110.66,53.6 109,51.94 107.74,51.94 105.49,49.69 105.49,48.9 105.19,48.6 v2(104.93,48.6)
  BOTTOM w0.076: U0300.M9 108.11,108.92 v3(108.25,108.92)
  BOTTOM w0.146: v2(104.93,48.6) 104.76,48.42 104.5,48.42 102.47,46.39 102.47,45.73 102.38,45.64 CON1701.240
M_CHB_MAA0: length 90.1
  TOP w0.229: v2(79.59,49.84) 79.36,49.61 79.18,49.61 78.76,49.19 78.39,49.19 78.22,49.37 78.22,50.4 78.43,50.61 79.51,50.61 79.68,50.78 79.68,51.15 79.48,51.35 78.61,51.35 78.37,51.58 CON1700.144
  IN4 w0.076: v3(94.55,108.26) 94.89,107.92 94.89,107.01 95.3,106.6 95.3,104.69 95.17,104.55 95.17,100.06 95.04,99.94 95.04,99.63
  IN4 w0.159: 95.04,99.63 95.04,96.08 95.37,95.75 95.37,91.69 81.46,77.79 81.46,76.92 81.3,76.76 80.76,76.76 80.6,76.61 80.6,76.29 80.77,76.12 81.68,76.12 81.85,75.95 81.85,75.63 81.7,75.48 80.75,75.48 80.6,75.34 80.6,75.02 80.77,74.85 81.68,74.85 81.85,74.68 81.85,74.36 81.7,74.21 80.75,74.21 80.6,74.07 80.6,73.75 80.77,73.58 81.68,73.58 81.85,73.41 81.85,73.09 81.7,72.94 80.75,72.94 80.6,72.8 80.6,72.48 80.77,72.31 81.5,72.31 81.66,72.14 81.66,71.86 81.14,71.34 81.14,70.91 81.46,70.58 81.46,69.35 81.06,68.94 80.85,68.73 80.85,62.82 80.48,62.45 80.48,61.18 80.56,61.11 80.56,59.28 80.19,58.91 80.19,57.41 78.83,56.05 78.83,53.43 79.24,53.02 79.24,50.18 v2(79.59,49.84)
  BOTTOM w0.076: v3(94.55,108.26) 94.4,108.26 U0300.AJ9
  BOTTOM w0.229: CON1701.144 76.38,45.39 76.66,45.67 77.7,45.67 77.98,45.96 77.98,46.74 80.06,48.81 80.06,49.39 79.62,49.84 v2(79.59,49.84)
M_CHB_MAA1: length 88.9
  TOP w0.229: CON1700.133 75.62,46.11 74.85,46.88 74.85,47.04 75.04,47.23 75.29,47.23 75.61,46.91 76.17,46.91 76.51,47.25 77.22,47.25 77.43,47.45 77.43,48.9 77.56,49.03 77.94,49.03 v2(78.21,48.76)
  IN4 w0.076: v3(94.75,106.31) 94.39,105.95 94.39,103.66 94.14,103.41 94.14,100.29 94.51,99.92 94.51,99.68
  IN4 w0.159: v2(78.21,48.76) 78.22,48.77 78.22,52.62 77.82,53.02 77.82,56.47 79.19,57.83 79.19,63.45 78.81,63.83 78.81,66.3 78.97,66.46 79.65,66.46 79.81,66.62 79.81,66.94 79.65,67.09 78.97,67.09 78.81,67.25 78.81,67.57 78.97,67.73 79.65,67.73 79.81,67.89 79.81,68.21 79.65,68.36 78.97,68.36 78.81,68.52 78.81,68.84 78.97,69 79.65,69 79.81,69.16 79.81,69.48 79.65,69.63 78.97,69.63 78.81,69.79 78.81,70.11 78.97,70.27 79.65,70.27 79.81,70.43 79.81,70.75 79.65,70.9 78.97,70.9 78.81,71.06 78.81,71.56 79.57,72.33 79.57,77.31 94.37,92.11 94.37,93.55 94.51,93.7 94.51,99.68
  BOTTOM w0.076: v3(94.75,106.31) 93.83,106.31 U0300.AK6
  BOTTOM w0.229: CON1701.133 73.63,50.67 74.51,49.79 77.18,49.79 v2(78.21,48.76)
M_CHB_MAA2: length 86.3
  TOP w0.229: v2(74.41,47.51) 74.69,47.79 74.69,51.45 74.94,51.7 75.24,51.7 75.37,51.83 CON1700.132
  IN4 w0.076: 94.27,99.8 94.27,99.93 93.96,100.24 93.96,104.31 v3(93.92,104.35)
  IN4 w0.159: v2(74.41,47.51) 74.41,45.44 74.89,44.97 77.63,44.97 77.84,45.17 77.84,47.77 77.72,47.88 77.72,52.41 77.32,52.81 77.32,55.92 77.04,56.2 77.04,56.53 78.32,57.8 78.32,63.69 78.31,63.7 78.31,71.77 79.07,72.53 79.07,77.52 93.86,92.32 93.86,93.48 94.27,93.89 94.27,99.8
  BOTTOM w0.076: U0300.AK5 93.79,105.99 93.87,105.9 93.87,104.41 v3(93.92,104.35)
  BOTTOM w0.229: v2(74.41,47.51) 74.96,48.06 75.14,48.06 75.34,47.86 75.34,47.17 74.48,46.32 73.66,46.32 73.38,46.03 CON1701.132
M_CHB_MAA3: length 85.3
  TOP w0.229: CON1700.131 75.12,45.99 73.74,47.38 73.74,47.94 73.95,48.14 74.15,48.14 v2(74.17,48.11)
  IN4 w0.076: 91.41,99.63 91.41,103.18 92.07,103.84 92.07,105.43 v3(92.3,105.66)
  IN4 w0.159: v2(74.17,48.11) 74,48.29 74,49.38 72.27,51.1 72.27,53.41 72.14,53.54 72.14,58.41 73.03,59.3 73.03,59.8 72.59,60.23 72.59,60.51 73.24,61.16 73.24,61.72 72.37,62.59 72.37,70.97 72.22,71.13 71.6,71.13 71.43,71.3 71.43,71.62 71.58,71.77 72.22,71.77 72.37,71.92 72.37,72.24 72.22,72.4 71.6,72.4 71.43,72.57 71.43,72.89 71.58,73.04 72.22,73.04 72.37,73.19 72.37,73.51 72.22,73.67 71.6,73.67 71.43,73.84 71.43,74.16 71.58,74.31 72.22,74.31 72.37,74.46 72.37,74.78 72.22,74.94 71.6,74.94 71.43,75.1 71.43,75.42 71.59,75.58 72.22,75.58 72.37,75.73 72.37,76.51 88.76,92.9 88.76,94.39 89.54,95.17 90.98,95.17 91.41,95.6 91.41,99.63
  BOTTOM w0.076: v3(92.3,105.66) 92.62,105.99 U0300.AL5
  BOTTOM w0.229: v2(74.17,48.11) 74.3,48.24 74.3,48.72 72.68,50.35 72.68,50.98 73.13,51.43 CON1701.131
M_CHB_MAA4: length 83.1
  TOP w0.229: CON1700.128 74.37,51.93 73.97,51.53 73.97,49.21 v2(73.46,48.7)
  IN4 w0.076: v3(92.3,106.28) 92.29,106.28 92.28,106.27 92.23,106.27 91.87,105.91 91.87,103.87 91.24,103.24 91.24,100.16 91.04,99.96 91.04,99.63
  IN4 w0.159: 91.04,99.63 91.04,97.35 88.26,94.57 88.26,93.11 70.93,75.78 70.93,71.09 71.87,70.15 71.87,68.3 71.71,68.14 71.09,68.14 70.93,67.98 70.93,67.66 71.09,67.5 71.71,67.5 71.87,67.34 71.87,65.7 71.71,65.55 71.1,65.55 70.93,65.38 70.93,65.06 71.08,64.91 71.71,64.91 71.87,64.75 71.87,64.43 71.71,64.28 71.1,64.28 70.93,64.11 70.93,63.79 71.08,63.64 71.71,63.64 71.87,63.48 71.87,63.16 71.51,62.8 71.51,61.96 71.84,61.63 71.84,60.28 72.42,59.7 72.42,59.4 71.64,58.62 71.64,56.14 71.1,55.6 71.1,53.87 71.77,53.2 71.77,50.9 73.49,49.17 73.49,48.73 v2(73.46,48.7)
  BOTTOM w0.076: v3(92.3,106.28) 92.65,106.64 U0300.AL6
  BOTTOM w0.229: v2(73.46,48.7) 73.62,48.55 73.62,46.97 72.38,45.73 CON1701.128
M_CHB_MAA5: length 84.4
  TOP w0.229: CON1700.126 73.87,51.93 73.39,51.45 73.39,49.97 72.55,49.13 v2(72.55,47.66)
  IN4 w0.076: 90.47,99.63 90.47,99.97 90.91,100.41 90.91,104.47 91.25,104.81 91.46,104.81 91.54,104.88 91.54,105.15 91.42,105.26 91.24,105.26 91.16,105.34 91.16,105.49 91.27,105.59 91.46,105.59 91.54,105.67 91.54,106.16 v3(91.38,106.31)
  IN4 w0.159: v2(72.55,47.66) 72.49,47.71 72.49,48.75 70.76,50.48 70.76,52.79 70.1,53.45 70.1,56.02 70.63,56.55 70.63,57.09 70.45,57.27 69.81,57.27 69.66,57.42 69.66,57.74 69.83,57.91 70.25,57.91 70.63,58.29 70.63,59.04 70.87,59.27 70.87,59.77 70.41,60.22 70.41,61.63 69.93,62.12 69.93,63.26 69.77,63.42 69.66,63.42 69.51,63.58 69.51,63.9 69.66,64.06 69.77,64.06 69.93,64.22 69.93,64.53 69.77,64.69 69.66,64.69 69.51,64.85 69.51,65.17 69.66,65.33 69.77,65.33 69.93,65.49 69.93,69.6 69.77,69.75 69.66,69.75 69.51,69.91 69.51,70.23 69.66,70.39 69.77,70.39 69.93,70.55 69.93,70.87 69.77,71.02 69.66,71.02 69.51,71.18 69.51,71.5 69.66,71.66 69.77,71.66 69.93,71.82 69.93,72.14 69.77,72.29 69.66,72.29 69.51,72.45 69.51,72.77 69.66,72.93 69.77,72.93 69.93,73.09 69.93,73.41 69.77,73.56 69.66,73.56 69.51,73.72 69.51,74.04 69.66,74.2 69.77,74.2 69.93,74.36 69.93,74.68 69.77,74.83 69.66,74.83 69.51,74.99 69.51,75.31 69.66,75.47 69.77,75.47 69.93,75.63 69.93,76.2 86.8,93.07 86.8,94.54 90.47,98.21 90.47,99.63
  BOTTOM w0.076: U0300.AM6 91.71,106.64 v3(91.38,106.31)
  BOTTOM w0.229: v2(72.55,47.66) 71.88,46.98 CON1701.126
M_CHB_MAA6: length 85.8
  TOP w0.229: CON1700.127 74.12,46.14 73.14,47.12 v2(73.03,47.12)
  IN4 w0.076: 90.76,99.97 91.08,100.29 91.08,103.31 91.7,103.94 91.7,105.99 91.89,106.18 91.89,107 91.78,107.11 v3(91.78,107.63)
  IN4 w0.159: 90.76,99.97 90.76,97.8 87.89,94.94 87.89,93.45 70.43,75.99 70.43,62.33 71.33,61.43 71.33,60.03 71.37,59.99 71.37,59.06 71.14,58.83 71.14,56.35 70.6,55.81 70.6,53.66 71.27,52.99 71.27,50.69 72.99,48.96 72.99,48.28 73.84,47.43 73.84,45.38 73.62,45.16 73.25,45.16 73.03,45.38 v2(73.03,47.12)
  BOTTOM w0.076: v3(91.78,107.63) 91.65,107.63 U0300.AN7
  BOTTOM w0.229: CON1701.127 72.13,51.3 71.94,51.12 71.94,49.87 72.8,49 72.8,48.37 73.03,48.14 v2(73.03,47.12)
M_CHB_MAA7: length 87.1
  TOP w0.229: v2(71.18,47.91) 71.28,48.02 71.28,48.86 72.81,50.38 72.81,51.44 72.87,51.51 CON1700.122
  IN4 w0.076: v3(91.78,109.57) 91.41,109.2 91.41,108.13 91.22,107.94 91.22,107.17 90.82,106.77 90.82,104.85 90.52,104.54 90.52,100.55
  IN4 w0.159: v2(71.18,47.91) 71.18,46.16 71.35,45.98 71.7,45.98 71.89,46.17 71.89,47.94 69.66,50.17 69.66,50.58 68.5,51.74 68.5,58 68.98,58.47 68.98,61.21 68.5,61.69 68.5,76.26 86,93.76 86,95.36 89.97,99.33 89.97,100.01 90.52,100.55
  BOTTOM w0.076: U0300.AN10 91.65,109.57 v3(91.78,109.57)
  BOTTOM w0.229: CON1701.122 70.88,47.61 v2(71.18,47.91)
M_CHB_MAA8: length 85.1
  TOP w0.229: CON1700.125 73.62,46.09 73.14,46.57 72.72,46.57 71.67,47.61 71.67,48.26 v2(71.98,48.56)
  IN4 w0.076: 90.22,99.67 90.22,99.96 90.73,100.47 90.73,104.52 90.99,104.78 90.99,106.7 91.39,107.1 91.39,107.87 91.78,108.26 v3(91.78,108.27)
  IN4 w0.159: v2(71.98,48.56) 70.26,50.27 70.26,52.54 70.07,52.73 69.8,52.73 69.65,52.58 69.65,51.95 69.44,51.74 69.21,51.74 69,51.95 69,55.64 69.7,56.34 69.7,56.68 69.16,57.22 69.16,57.95 69.73,58.51 69.73,58.83 70.24,59.35 70.24,59.65 69.91,59.98 69.91,61.43 69,62.33 69,65.75 69.43,66.18 69.43,68.29 69,68.71 69,75.98 86.25,93.23 86.25,95.25 90.22,99.23 90.22,99.67
  BOTTOM w0.076: v3(91.78,108.27) 91.65,108.27 U0300.AN8
  BOTTOM w0.229: CON1701.125 71.63,51.61 71.37,51.35 71.37,48.74 71.55,48.56 v2(71.98,48.56)
M_CHB_MAA9: length 85.2
  TOP w0.229: v2(69.58,48.65) 69.72,48.65 72.62,45.74 CON1700.121
  IN4 w0.076: v3(89.95,110.22) 90.36,109.81 90.48,109.69 90.48,108.12 90.65,107.96 90.65,107.06 90.49,106.9 90.49,104.99 90.17,104.67 90.17,102.9 89.54,102.27 89.54,99.98 89.19,99.63
  IN4 w0.159: v2(69.58,48.65) 68.66,49.57 68.66,50.17 67.5,51.32 67.5,58.42 67.97,58.89 67.97,60.8 67.5,61.27 67.5,71.19 67.34,71.35 67.23,71.35 67.07,71.5 67.07,71.82 67.23,71.98 67.34,71.98 67.5,72.14 67.5,72.46 67.34,72.62 67.23,72.62 67.07,72.77 67.07,73.09 67.23,73.25 67.34,73.25 67.5,73.41 67.5,73.73 67.34,73.89 67.23,73.89 67.07,74.04 67.07,74.36 67.23,74.52 67.34,74.52 67.5,74.68 67.5,76.68 85.45,94.63 85.45,95.89 89.19,99.63
  BOTTOM w0.076: U0300.AR11 89.82,110.22 v3(89.95,110.22)
  BOTTOM w0.229: CON1701.121 70.63,51.71 70.8,51.54 70.8,49.38 70.06,48.65 v2(69.58,48.65)
M_CHB_MAA10: length 86.3
  TOP w0.229: CON1700.146 80.87,51.69 80.28,51.1 v2(80.28,47.85)
  IN4 w0.076: v3(95.44,107.62) 95.63,107.43 95.63,103.8
  IN4 w0.159: v2(80.28,47.85) 80.28,44.61 80.12,44.44 79.29,44.44 79.07,44.66 79.07,45.37 79.53,45.83 79.53,48.16 80.53,49.15 80.53,50.32 80.24,50.6 80.24,56.05 82.13,57.93 82.13,59.6 81.56,60.17 81.56,61.5 81.49,61.58 81.49,62.04 81.85,62.4 81.85,68.32 82.85,69.32 82.85,76.39 90.4,83.94 90.4,85.3 96.37,91.27 96.37,95.64 95.54,96.48 95.54,99.75 95.63,99.85 95.63,103.8
  BOTTOM w0.076: v3(95.44,107.62) 95.3,107.62 U0300.AH7
  BOTTOM w0.229: CON1701.146 78.88,45.37 78.36,45.88 78.36,46.42 79.79,47.85 v2(80.28,47.85)
M_CHB_MAA11: length 89.1
  TOP w0.229: CON1700.120 72.37,51.85 72.24,51.72 72.24,50.62 70.72,49.1 v2(70.72,48.37)
  IN4 w0.076: v3(91.78,110.22) 91.25,109.69 91.25,108.19 91.04,107.99 91.04,107.22 90.66,106.84 90.66,104.92 90.34,104.6 90.34,102.81 89.72,102.19 89.72,99.63
  IN4 w0.159: v2(70.72,48.37) 70.51,48.16 70.51,45.62 70.3,45.41 70.01,45.41 69.83,45.59 69.83,48.22 70.08,48.47 70.08,49.03 69.16,49.96 69.16,50.38 68,51.53 68,58.21 68.48,58.68 68.48,61.01 68,61.48 68,76.47 85.75,94.22 85.75,95.56 89.72,99.53 89.72,99.63
  BOTTOM w0.076: v3(91.78,110.22) 91.65,110.22 U0300.AN11
  BOTTOM w0.229: CON1701.120 70.38,47.95 70.72,48.29 v2(70.72,48.37)
M_CHB_MAA12: length 85.3
  TOP w0.229: v2(68.15,49.26) 68.15,48.19 68.56,47.78 69.83,47.78 72.12,45.49 CON1700.119
  IN4 w0.076: v3(89.95,109.57) 90.32,109.2 90.32,108.05 90.48,107.89 90.48,107.13 90.33,106.97 90.33,105.05 90.01,104.74 90.01,102.99 89.34,102.32 89.34,100.41 89.31,100.39
  IN4 w0.159: 89.31,100.39 85.12,96.2 85.12,95.01 66.53,76.42 66.53,75.92 66.69,75.76 66.84,75.76 67,75.6 67,75.28 66.84,75.12 66.69,75.12 66.53,74.97 66.53,71.28 67,70.81 67,51.12 68.15,49.96 v2(68.15,49.26)
  BOTTOM w0.076: v3(89.95,109.57) 89.82,109.57 U0300.AR10
  BOTTOM w0.229: CON1701.119 70.13,51.66 69.78,51.32 69.78,50.78 70.11,50.45 70.11,49.59 69.83,49.31 69.42,49.31 68.99,49.74 68.64,49.74 v2(68.15,49.26)
M_CHB_MAA13: length 89
  TOP w0.229: v2(82.3,46.82) 82.65,47.16 82.65,49.22 83.37,49.94 83.37,50.8 83.87,51.3 CON1700.158
  IN4 w0.076: 97.04,106.24 97.04,106.38 96.75,106.67 96.75,107.79 v3(97.25,108.29)
  IN4 w0.159: v2(82.3,46.82) 81.75,46.82 81.28,47.29 81.28,47.67 82.03,48.42 82.03,49.23 83.01,50.21 83.01,55.97 84.53,57.49 84.53,59.12 85.04,59.64 85.04,60.39 84.69,60.75 84.69,62.33 84.84,62.49 85.4,62.49 85.56,62.65 85.56,62.96 85.4,63.12 84.84,63.12 84.69,63.28 84.69,63.6 84.84,63.76 85.4,63.76 85.56,63.92 85.56,64.23 85.4,64.39 84.84,64.39 84.69,64.55 84.69,64.87 84.84,65.03 85.4,65.03 85.56,65.19 85.56,65.5 85.4,65.66 84.84,65.66 84.69,65.82 84.69,67.46 85.04,67.81 85.04,68.67 86.19,69.81 86.19,73.11 86.03,73.27 85.15,73.27 84.98,73.44 84.98,73.76 85.13,73.91 86.03,73.91 86.19,74.07 86.19,74.66 85.47,75.37 85.47,76.17 86.02,76.72 86.25,76.72 86.61,76.36 86.84,76.36 87.06,76.58 87.06,76.81 86.7,77.17 86.7,77.4 98.38,89.08 98.38,95.36 96.96,96.78 96.96,97.64 97.28,97.97 97.28,103.12 97.04,103.36 97.04,106.24
  BOTTOM w0.076: U0300.AF9 97.12,108.29 v3(97.25,108.29)
  BOTTOM w0.229: CON1701.158 81.88,45.77 82.06,45.95 82.5,45.95 82.72,46.17 82.72,46.4 v2(82.3,46.82)
M_CHB_MAA14: length 82.7
  TOP w0.229: CON1700.151 82.12,46.22 81.44,46.9 81.44,47.84 81.91,48.3 81.91,49.73 v2(82.28,50.1)
  IN4 w0.076: 96.37,99.78 96.37,103.82 96.77,104.22 96.77,106.41 96.14,107.05 96.14,107.91 95.97,108.08 95.97,109.69 v3(95.44,110.22)
  IN4 w0.159: 96.37,99.78 96.37,96.94 97.88,95.43 97.88,89.29 84.36,75.77 84.36,75.27 84.51,75.11 85.03,75.11 85.23,74.9 85.23,74.58 85.12,74.47 84.51,74.47 84.36,74.31 84.36,73.36 85.39,72.32 85.39,69.73 84.13,68.47 84.13,63.38 83.98,63.23 83.5,63.23 83.36,63.09 83.36,62.69 83.46,62.59 83.95,62.59 84.18,62.36 84.18,60.54 84.54,60.19 84.54,59.84 84.02,59.33 84.02,57.7 82.51,56.18 82.51,51.5 82.03,51.02 82.03,50.34 v2(82.28,50.1)
  BOTTOM w0.076: v3(95.44,110.22) 95.3,110.22 U0300.AH11
  BOTTOM w0.229: CON1701.151 80.13,51.46 81.49,50.1 v2(82.28,50.1)
M_CHB_MAA15: length 90
  TOP w0.229: v2(82.18,47.45) 82.32,47.59 82.32,49.37 82.81,49.87 82.81,51.04 83.37,51.6 CON1700.156
  IN4 w0.076: v3(97.27,107.63) 96.91,107.28 96.91,106.81 97.29,106.43 97.29,103.43 97.53,103.19 97.53,99.63
  IN4 w0.159: v2(82.18,47.45) 82.53,47.81 82.53,49.03 83.63,50.13 83.63,55.89 85.03,57.28 85.03,58.53 86.06,59.57 86.06,68.92 87.26,70.11 87.26,71 86.89,71.37 86.89,74.87 87.2,75.19 87.2,76.01 87.98,76.79 87.98,77.01 87.61,77.38 87.61,77.6 87.84,77.83 88.06,77.83 88.43,77.46 88.65,77.46 88.88,77.69 88.88,77.91 88.51,78.28 88.51,78.5 88.74,78.73 88.96,78.73 89.33,78.36 89.55,78.36 89.78,78.59 89.78,78.81 89.41,79.18 89.41,79.4 89.63,79.63 89.86,79.63 90.23,79.26 90.45,79.26 90.67,79.48 90.67,79.71 90.31,80.07 90.31,80.3 90.53,80.52 90.76,80.52 91.12,80.16 91.35,80.16 91.57,80.38 91.57,80.61 91.21,80.97 91.21,81.2 91.43,81.42 91.65,81.42 92.02,81.05 92.25,81.05 92.47,81.28 92.47,81.5 92.1,81.87 92.1,82.1 92.33,82.32 92.55,82.32 92.92,81.95 93.14,81.95 93.37,82.18 93.37,82.4 93,82.77 93,82.99 93.23,83.22 93.45,83.22 93.82,82.85 94.04,82.85 94.27,83.08 94.27,83.3 93.9,83.67 93.9,83.89 94.12,84.12 94.35,84.12 94.72,83.75 94.94,83.75 95.17,83.97 95.17,84.2 94.8,84.57 94.8,84.79 95.02,85.01 95.25,85.01 95.61,84.65 95.84,84.65 96.16,84.97 96.16,86.15 98.88,88.87 98.88,95.7 97.53,97.05 97.53,99.63
  BOTTOM w0.076: U0300.AF8 97.12,107.63 v3(97.27,107.63)
  BOTTOM w0.229: CON1701.156 81.37,47.21 81.62,47.45 v2(82.18,47.45)
M_CHB_MAA16: length 85
  TOP w0.229: v2(81.41,48.62) 81.41,50.59 82.38,51.56 82.38,52.8 CON1700.152
  IN4 w0.076: v3(95.44,109.57) 95.81,109.2 95.81,108.01 95.97,107.84 95.97,104.14 96.1,104.02 96.1,99.63
  IN4 w0.159: 96.1,99.63 96.1,96.78 97.38,95.5 97.38,89.5 83.85,75.97 83.85,72.6 84.08,72.37 84.63,72.37 84.89,72.11 84.89,71.76 84.56,71.43 84.56,71.13 84.89,70.8 84.89,69.94 82.85,67.9 82.85,65.84 83.01,65.69 83.47,65.69 83.63,65.53 83.63,65.21 83.47,65.05 83.01,65.05 82.85,64.89 82.85,64.57 83.01,64.42 83.47,64.42 83.63,64.26 83.63,63.94 83.47,63.78 83.01,63.78 82.85,63.62 82.85,62.49 83.68,61.66 83.68,60.24 83.52,60.08 83.52,57.91 81.25,55.63 81.25,53.61 81.41,53.45 81.85,53.45 82.01,53.29 82.01,52.97 81.85,52.81 81.41,52.81 81.25,52.66 81.25,52.34 81.41,52.18 81.85,52.18 82.01,52.02 82.01,51.7 81.85,51.54 81.41,51.54 81.25,51.39 81.25,51.02 81.53,50.73 81.53,48.74 v2(81.41,48.62)
  BOTTOM w0.076: v3(95.44,109.57) 95.3,109.57 U0300.AH10
  BOTTOM w0.229: v2(81.41,48.62) 81.41,47.81 80.37,46.77 CON1701.152
M_CHB_ODT0: length 80.5
  TOP w0.184: CON1700.155 83.12,45.71 82.95,45.88 82.95,48.69 83.29,49.02 v2(83.42,49.02)
  IN4 w0.076: 97.76,99.63 97.76,103.23 97.48,103.52 97.48,106.84 v3(97.28,107.03)
  IN4 w0.127: 97.76,99.63 97.76,97.5 99.66,95.6 99.66,88.56 96.94,85.83 96.94,84.64 89.38,77.09 89.38,76.91 89.72,76.57 89.72,76.39 89.54,76.21 89.37,76.21 89.02,76.55 88.84,76.55 88.66,76.37 88.66,76.19 89.01,75.85 89.01,75.67 88.83,75.49 88.65,75.49 88.3,75.83 88.12,75.83 87.99,75.7 87.99,74.84 87.67,74.51 87.67,74.19 87.79,74.06 88.13,74.06 88.26,73.94 88.26,73.68 88.13,73.56 87.79,73.56 87.67,73.43 87.67,73.17 87.79,73.05 88.13,73.05 88.26,72.92 88.26,72.67 88.13,72.54 87.79,72.54 87.67,72.41 87.67,71.69 88.15,71.21 88.15,69.79 87.24,68.88 87.24,68.45 87.12,68.32 86.97,68.32 86.84,68.2 86.84,67.94 86.97,67.82 87.12,67.82 87.24,67.69 87.24,67.44 87.12,67.31 86.97,67.31 86.84,67.18 86.84,66.93 86.97,66.8 87.12,66.8 87.24,66.67 87.24,66.42 87.12,66.29 86.97,66.29 86.84,66.17 86.84,65.91 86.97,65.78 87.12,65.78 87.24,65.66 87.24,65.4 87.12,65.28 86.97,65.28 86.84,65.15 86.84,64.9 86.97,64.77 87.12,64.77 87.24,64.64 87.24,64.39 87.12,64.26 86.97,64.26 86.84,64.13 86.84,63.88 86.97,63.75 87.12,63.75 87.24,63.63 87.24,63.37 87.12,63.24 86.97,63.24 86.84,63.12 86.84,62.86 86.97,62.74 87.12,62.74 87.24,62.61 87.24,62.36 87.12,62.23 86.97,62.23 86.84,62.1 86.84,61.85 86.97,61.72 87.12,61.72 87.24,61.59 87.24,59.65 86.84,59.25 86.84,59.08 87.24,58.68 87.24,58.4 87.11,58.26 86.49,58.26 86.21,57.98 86.21,57.36 84.45,55.61 84.45,55.17 84.82,54.8 84.82,54.44 84.41,54.03 84.41,49.4 84.04,49.02 v2(83.42,49.02)
  BOTTOM w0.076: U0300.AF7 97.03,107.3 97.28,107.05 v3(97.28,107.03)
M_CHB_ODT1: length 81.2
  TOP w0.184: CON1700.161 84.62,45.76 85.48,46.62 85.48,48.56 85.17,48.86 85.17,49.3 v2(85.74,49.86)
  IN4 w0.076: v3(98.18,108.27) 98.54,107.91 98.54,106.91 98.18,106.55 98.18,103.97 98.55,103.6 98.55,99.76 98.57,99.73 98.57,99.72 98.63,99.67
  IN4 w0.127: v2(85.74,49.86) 86.14,50.26 86.14,53.31 86.99,54.16 86.99,55.7 89.43,58.14 89.43,62.87 89.09,63.21 89.09,63.6 89.4,63.92 89.78,63.92 90.14,64.28 90.14,64.91 89.78,65.28 89.78,65.57 90.14,65.93 90.14,67.03 89.55,67.61 89.55,68.75 89.99,69.18 89.99,74.21 99.78,84 99.78,84.18 98.86,85.11 98.86,85.28 99.04,85.46 99.22,85.46 100.14,84.54 100.32,84.54 100.5,84.72 100.5,84.9 99.58,85.82 99.58,86 99.76,86.18 99.94,86.18 100.86,85.26 101.04,85.26 101.39,85.61 101.39,86.34 101.26,86.46 100.78,86.46 100.65,86.59 100.65,86.85 100.78,86.97 101.26,86.97 101.39,87.1 101.39,95.34 98.63,98.11 98.63,99.67
  BOTTOM w0.076: v3(98.18,108.27) 98.05,108.27 U0300.AE8
M_CHB_ODT2: length 82
  IN4 w0.076: 98.85,99.63 98.85,99.72 98.71,99.85 98.71,103.67 98.34,104.04 98.34,106.48 98.7,106.84 98.7,108.27 98.18,108.79 v3(98.18,108.92)
  IN4 w0.127: v2(84.98,48.15) 85.27,48.15 86.57,49.45 86.57,53.13 87.42,53.99 87.42,55.52 89.86,57.96 89.86,63.39 90.7,64.23 90.7,67.43 90.51,67.62 90.15,67.62 89.99,67.79 89.99,68.57 90.45,69.04 90.9,69.04 91.03,69.17 91.03,69.42 90.9,69.55 90.55,69.55 90.42,69.67 90.42,69.93 90.55,70.05 90.9,70.05 91.03,70.18 91.03,70.44 90.9,70.56 90.55,70.56 90.42,70.69 90.42,72.83 90.55,72.96 90.9,72.96 91.03,73.09 91.03,73.34 90.9,73.47 90.55,73.47 90.42,73.6 90.42,74.03 90.94,74.55 91.12,74.55 91.31,74.37 91.49,74.37 91.67,74.55 91.67,74.73 91.48,74.91 91.48,75.09 91.66,75.27 91.84,75.27 92.03,75.09 92.21,75.09 92.39,75.27 92.39,75.45 92.2,75.63 92.2,75.81 101.82,85.43 101.82,95.22 98.85,98.19 98.85,99.63
  BOTTOM w0.076: v3(98.18,108.92) 98.05,108.92 U0300.AE9
  BOTTOM w0.184: v2(84.98,48.15) 82.45,50.68 81.77,50.68 81.13,51.32 CON1701.155
M_CHB_ODT3: length 83.9
  IN4 w0.076: 99.64,99.63 99.04,100.22 99.04,103.27 99.51,103.74 99.51,104.6 99.3,104.81 99.3,106.58 99.03,106.84 99.03,108.5 98.71,108.83 98.71,109.69 v3(98.18,110.22)
  IN4 w0.127: 99.64,99.63 99.64,98.01 102.69,94.96 102.69,85.07 97.23,79.61 97.23,78.89 91.89,73.55 91.89,67.98 91.56,67.65 91.56,63.55 91.41,63.39 91.41,61.64 91.61,61.43 91.61,58.49 88.69,55.57 88.69,54.03 87.43,52.77 87.43,49.1 86.18,47.84 86.18,46.13 85.92,45.87 85.25,45.87 84.98,46.15 v2(84.98,46.89)
  BOTTOM w0.076: v3(98.18,110.22) 97.86,109.9 U0300.AE11
  BOTTOM w0.184: CON1701.161 82.63,51.66 85.86,48.43 85.86,47.43 85.32,46.89 v2(84.98,46.89)
M_CHB_PAR: length 87.3
  TOP w0.229: CON1700.143 78.12,45.6 77.87,45.85 77.87,47.21 77.98,47.33 78.24,47.33 78.54,47.02 78.82,47.02 79.01,47.21 79.01,47.78 78.72,48.06 v2(78.24,48.06)
  IN4 w0.076: 94.79,99.92 95,100.13 95,104.62 95.14,104.76 95.14,106.44 94.52,107.05 v3(94.52,107.62)
  IN4 w0.159: 94.79,99.92 94.79,95.72 94.87,95.65 94.87,91.9 80.07,77.1 80.07,71.27 80.96,70.37 80.96,69.56 80.35,68.94 80.35,65.96 80.19,65.8 79.48,65.8 79.31,65.63 79.31,65.31 79.46,65.16 80.19,65.16 80.35,65 80.35,64.69 80.19,64.53 79.48,64.53 79.31,64.36 79.31,64.04 79.46,63.89 80.19,63.89 80.35,63.73 80.35,63.03 80.2,62.88 79.83,62.88 79.69,62.73 79.69,57.62 78.33,56.26 78.33,53.23 78.74,52.81 78.74,48.44 79.03,48.15 79.03,46.7 78.84,46.51 78.63,46.51 78.49,46.64 78.49,47.81 v2(78.24,48.06)
  BOTTOM w0.076: U0300.AJ7 94.39,107.62 v3(94.52,107.62)
  BOTTOM w0.229: CON1701.143 76.13,51.93 78.77,49.28 78.77,48.6 v2(78.24,48.06)
MB_ID0: length 15.2
  TOP w0.102: v2(225.8,51.9) 225.39,51.49 225.39,49.65 v1(224.97,49.23) 224.75,49 224.75,47.31 223.06,45.63 222.56,45.63 220.24,43.3 220.24,41.57 R6118.1 R6117.2
  BOTTOM w0.102: v2(225.8,51.9) 225.56,52.14 225.52,52.14 U2000.U36
MB_ID1: length 14
  BOTTOM w0.089: U2000.P44 223.5,48.39 223.37,48.24 223.37,48.11
  BOTTOM w0.102: R6119.2 215.37,41.46 v1(215.65,41.74) 215.79,41.88 215.79,43.35 R6120.1 215.37,43.79 217.16,45.57 220.09,45.57 220.73,46.21 221.75,46.21 223.37,47.84 223.37,48.11
MB_ID2: length 14.5
  BOTTOM w0.102: U2000.T45 224.82,48.08 224.82,46.94 223.64,45.77 223.12,45.77 222.52,45.17 221.29,45.17 220.13,44.01 220.06,44.01 R6102.1 219.4,43.35 219.4,42.11 219.69,41.82 R6101.2 220.1,40.31 220.1,39.4 219.49,38.79 v1(218.27,38.79)
MB_ID3: length 13.1
  BOTTOM w0.102: U2000.T44 224.74,48.51 224.74,48.42 224.64,48.26 224.61,48.24 224.61,47.03 223.55,45.97 223.02,45.97 222.42,45.37 221.16,45.37 220.55,44.76 219.64,44.76 219.41,44.53 219.41,44.25 R6104.1 218.9,43.77 218.66,43.53 218.66,43.38 218.47,43.19 218.47,41.82 218.6,41.69 v1(219.16,41.69) 218.85,41.38 218.85,41.28 R6103.2
MB_ID4: length 13.4
  BOTTOM w0.102: U2000.R44 224.21,48.51 224.21,47.2 223.39,46.37 222.79,46.37 222.19,45.78 220.94,45.78 220.32,45.17 218.27,45.17 217.15,44.05 R6122.1 217.58,43.34 217.58,41.84 v1(217.4,41.66) 217.15,41.41 R6121.2
MB_ID5: length 14.5
  BOTTOM w0.102: R6123.2 216.72,41.3 216.72,43.31 R6124.1 216.26,43.9 v1(217.28,44.91) 217.73,45.37 220.2,45.37 220.83,46.01 222.08,46.01 222.65,46.58 223.3,46.58 224,47.28 224,48.81 U2000.R43
MB_ID6: length 10.8
  BOTTOM w0.102: v1(224.75,39.25) 224.75,40.62 R2145.1 224.26,41.1 224.72,41.56 224.72,42.48 225.41,43.16 225.41,44.69 226.88,46.17 226.88,48.23 226.91,48.26 226.99,48.42 226.99,48.49 U2000.AA44
MCK_BUTTON1#: length 321.5
  TOP w0.102: v2(157.23,27.96) 157.23,26.45 160.18,23.5 160.69,23.5 161.22,24.04 161.22,25.08 161.65,25.51 U3002.108
  IN2 w0.102: v2(157.23,27.96) 157.23,28.28 156.73,28.78 136.5,28.78 128.57,36.71 122.78,36.71 121.31,35.24 114.1,35.24 113.04,34.17 109.05,34.17 108.53,33.65 103.21,33.65 101.13,31.57 55.47,31.57 52.53,34.51 44.74,34.51 41.64,37.62 41.64,40.77 36.3,46.11 36.3,70.22 44.63,78.55 44.63,101.45 46.18,103 46.7,103 51.58,107.89 55.14,107.89 60.98,113.73 60.98,117.22 61.83,118.07 61.83,123.3 62.13,123.6 62.13,124.11 62.87,124.85 62.87,127.92 62.29,128.51 62.29,133.87 62.11,134.05 62.11,145.22 63.18,146.29 65.07,146.29 68.9,150.11 68.9,153.57 70.38,155.05 70.38,169.28 71.63,170.54 71.63,176 72.14,176.5 72.14,177.32 73.21,178.39 75.59,178.39 80.22,183.02 80.22,184.16 81.38,185.31 85.18,185.31 87.74,187.87 87.74,188.27 v2(88.14,188.68)
  BOTTOM w0.102: v2(157.23,27.96) 157.23,28.38 v1(157.49,28.63) ; v2(88.14,188.68) 87.74,188.27 87.74,185.56 88.25,185.05 CON5602.14
MCK_BUTTON2#: length 324.5
  TOP w0.102: v2(158.05,27.96) 158.05,25.92 160.26,23.71 160.6,23.71 161.02,24.12 161.02,25.28 161.65,25.91 U3002.109
  IN2 w0.102: v2(158.05,27.96) 158.05,27.67 157.73,27.35 155.21,27.35 154.39,28.17 135.16,28.17 130.46,32.87 130.46,33.91 128.71,35.67 124.57,35.67 123.53,34.63 114.36,34.63 113.29,33.56 109.3,33.56 108.78,33.04 103.47,33.04 101.37,30.94 55.23,30.94 52.28,33.9 44.45,33.9 40.98,37.37 40.98,40.42 35.67,45.73 35.67,70.88 43.06,78.27 43.06,86.67 42.6,87.13 42.6,88.68 42.4,88.88 42.4,101.29 45.52,104.41 46.11,104.41 51,109.29 54.56,109.29 58.89,113.62 58.89,117.2 60.99,119.31 60.99,124.36 61.62,124.99 61.65,125.06 61.65,133.64 61.26,134.03 61.26,145.23 62.93,146.9 64.82,146.9 68.29,150.36 68.29,153.82 69.77,155.3 69.77,169.54 71.02,170.79 71.02,176.25 71.53,176.76 71.53,179.07 78.54,186.07 85.36,186.07 86.9,187.61 86.9,188.22 v2(87.33,188.65)
  BOTTOM w0.102: v1(157.49,26.83) 158.05,27.39 v2(158.05,27.96) ; v2(87.33,188.65) 86.91,188.24 86.91,185.68 87.25,185.35 CON5602.12
MCK_BUTTON3#: length 314.4
  TOP w0.102: U3002.35 147.68,32.71 147.83,32.56 147.83,30.31 147.86,30.28 147.86,30.17 148.22,29.81 148.33,29.81 149.97,28.18 v2(149.97,27.5)
  IN2 w0.102: v2(86.49,188.39) 86.09,187.98 86.09,187.46 85.1,186.48 78.37,186.48 73.07,181.18 71.68,181.18 68.09,177.59 68.09,172.52 68.94,171.67 68.94,170.7 69.37,170.28 69.37,155.47 67.88,153.99 67.88,150.53 64.65,147.3 62.76,147.3 60.86,145.4 60.86,133.86 61.25,133.48 61.25,125.97 59.9,124.62 59.9,123.4 60.59,122.71 60.59,119.47 58.48,117.37 58.48,113.79 54.39,109.7 50.81,109.7 50.3,109.19 48.57,109.19 41.99,102.61 41.99,88.64 42.2,88.44 42.2,78.24 35.46,71.51 35.46,45.57 40.77,40.27 40.77,37.29 44.36,33.7 52.19,33.7 55.15,30.74 101.45,30.74 103.26,32.54 114.04,32.54 115.16,33.66 126.86,33.66 128.87,31.66 129.83,31.66 134.38,27.11 149.58,27.11 v2(149.97,27.5)
  BOTTOM w0.102: CON5602.10 86.25,185.39 86.06,185.58 86.06,187.96 v2(86.49,188.39) ; v2(149.97,27.5) 149.97,26.42 v1(150.22,26.17)
MCK_BUTTON4#: length 332.1
  TOP w0.102: U3002.20 153.26,33.81 151.42,31.96 151.42,30.24 151.24,30.06 151.24,24.49 v2(151.67,24.06) ; v1(85.25,186.85) v2(85.25,187.48)
  IN2 w0.102: v2(85.25,187.48) 84.96,187.77 84.27,187.77 83.67,187.18 78.21,187.18 72.82,181.79 71.43,181.79 67.48,177.85 67.48,172.26 68.23,171.51 68.23,170.84 67.71,170.32 67.64,170.25 67.29,169.9 67.29,166.69 64.94,164.34 58.45,164.34 58.01,163.91 58.01,153.35 56.94,152.28 56.94,148.33 56.67,148.06 56.67,138.74 57.73,137.69 57.73,135.08 59.04,133.78 59.04,126.09 57.26,124.31 57.26,114 53.98,110.73 48.64,110.73 40.18,102.26 40.18,87.14 40.47,86.85 40.47,77.77 32.09,69.39 32.09,64.62 32.82,63.89 32.82,48.62 30.82,46.62 30.82,34.89 32.83,32.87 34.26,32.87 34.97,32.16 39.91,32.16 45.3,26.78 109,26.78 109.78,25.99 130.54,25.99 132.87,23.65 151.26,23.65 v2(151.67,24.06)
  BOTTOM w0.102: CON5602.8 85.25,184.3 v2(85.25,187.48)
MCK_BUTTON5#: length 329.8
  TOP w0.102: v1(83.55,187.43) 83.64,187.43 v2(84.47,188.27) ; v2(153.42,24.11) 153.83,24.11 156.86,21.08 U3002.86
  IN2 w0.102: v2(84.47,188.27) 83.59,187.38 78.12,187.38 72.73,181.99 71.34,181.99 67.28,177.93 67.28,172.18 68.03,171.43 68.03,170.92 67.57,170.47 67.49,170.39 67.09,169.99 67.09,166.78 64.86,164.55 58.37,164.55 57.81,163.99 57.81,153.44 56.74,152.36 56.74,148.42 56.47,148.15 56.47,138.66 57.51,137.62 57.51,135.02 58.83,133.69 58.83,126.17 57.05,124.39 57.05,114.09 53.9,110.93 48.56,110.93 39.86,102.23 39.86,87.1 40.27,86.7 40.27,77.86 31.86,69.45 31.86,64.57 32.62,63.8 32.62,48.71 30.62,46.71 30.62,34.8 32.75,32.67 34.18,32.67 34.89,31.96 39.83,31.96 45.21,26.58 108.91,26.58 109.7,25.79 130.4,25.79 132.74,23.45 151.35,23.45 151.55,23.65 152.97,23.65 v2(153.42,24.11)
  BOTTOM w0.102: CON5602.6 84.25,185.18 84.16,185.27 84.16,187.96 v2(84.47,188.27)
MCK_BUTTON6#: length 361.9
  TOP w0.102: U3002.88 157.66,21.42 156.42,22.66 v2(156.42,22.8) ; v1(81.16,188.86) 81.08,188.78 v2(81.08,188.22)
  IN2 w0.102: v2(156.42,22.8) 155.97,23.25 153.42,23.25 153.22,23.04 151.8,23.04 151.6,22.84 119.11,22.84 116.77,25.18 62.66,25.18 60.57,23.08 39.29,23.08 38.9,22.69 28.16,22.69 25.65,25.21 25.65,29.79 26.09,30.24 26.09,41.56 23.15,44.51 23.15,46.18 19.87,49.45 19.87,57.25 26.2,63.59 28.47,63.59 29.93,65.05 29.93,68.16 39.83,78.06 39.83,82.18 39.2,82.8 39.2,102.44 48.3,111.54 53.65,111.54 55.63,113.52 55.63,123.85 58.22,126.45 58.22,133.26 55.84,135.64 55.84,146.33 54.61,147.55 54.61,152.68 52.66,154.64 49.98,154.64 47.29,157.33 47.29,164.01 48.44,165.16 64.6,165.16 66.46,167.02 66.46,171.16 66.67,171.37 66.67,178.18 72.25,183.76 73.5,183.76 77.96,188.22 v2(81.08,188.22)
  BOTTOM w0.102: CON5602.2 82.25,187.05 v2(81.08,188.22)
MCK_LED1: length 307.7
  TOP w0.102: SR3021.2 R30108.1 133.57,15.11 v1(133.41,15.27) 133.33,15.35 v2(129.92,15.35) ; v2(53.07,38.21) 52.66,37.8 52.66,36.4 56.52,32.54 56.52,29.67 58.38,27.81 58.38,23.84 55.61,21.07 55.61,20.05 56.37,19.29 58.54,19.29 58.93,19.68 58.93,20.23 v2(58.53,20.63)
  IN2 w0.102: v2(45.37,88.35) 45.19,88.53 45.19,101.72 46.27,102.8 46.78,102.8 51.66,107.68 55.22,107.68 61.18,113.64 61.18,117.14 62.11,118.07 62.11,123.29 62.44,123.62 62.44,124.13 63.07,124.76 63.07,128.01 62.49,128.59 62.49,133.96 62.31,134.13 62.31,140.28 63.18,141.14 63.18,144.1 69.1,150.02 69.1,153.48 70.59,154.97 70.59,169.2 71.84,170.45 71.84,175.91 72.35,176.42 72.35,177.24 73.29,178.19 75.67,178.19 80.42,182.94 80.42,184.07 81.32,184.97 85.48,184.97 88.17,187.66 v2(88.17,188.07)
  IN4 w0.102: v2(129.92,15.35) 129.92,14.47 129.39,13.95 124.95,13.95 123.36,15.54 122.54,16.36 102.15,16.36 100.31,18.2 68.48,18.2 65.36,21.32 58.99,21.32 58.53,20.86 v2(58.53,20.63) ; v2(53.07,38.21) 53.09,38.23 53.09,38.79 48.09,43.8 39.86,43.8 35.72,47.94 35.72,50.88 33.56,53.04 33.56,64.23 37.37,68.04 37.37,82.46 40.54,85.63 40.54,88.08 41.4,88.93 44.79,88.93 v2(45.37,88.35)
  BOTTOM w0.102: CON5602.15 88.75,185.28 88.17,185.86 v2(88.17,188.07)
MCK_LED1_EC: length 17.8
  TOP w0.102: U3002.70 150.47,18.74 150.27,18.55 150.14,18.55 148.77,17.18 146.46,17.18 145.65,16.36 141.79,16.36 141.36,15.93 v1(138.59,15.93) 137.52,15.93 135.85,14.26 SR3021.1
MCK_LED2: length 307.1
  TOP w0.102: v2(129.28,15.35) 129.71,14.92 132.69,14.92 134.12,13.49 136.58,13.49 v1(137.01,13.93) 137.01,14.44 137.36,14.78 R30107.1 SR3022.2 ; v2(54.72,37.19) 54.72,36.94 59.92,31.73 59.92,24.24 57.05,21.37 57.05,20.43 v2(56.65,20.02)
  IN2 w0.102: v2(43.03,87.43) 43.03,88.53 42.6,88.97 42.6,101.21 45.6,104.2 46.2,104.2 51.08,109.09 54.64,109.09 59.09,113.54 59.09,117.12 61.19,119.22 61.19,124.25 61.86,124.91 61.86,133.73 61.7,133.88 61.7,145.38 63.01,146.69 64.91,146.69 68.49,150.28 68.49,153.74 69.98,155.22 69.98,169.45 71.23,170.7 71.23,176.17 71.74,176.67 71.74,178.74 75.38,182.38 76.02,182.38 76.56,182.92 76.56,183.56 78.87,185.87 85.44,185.87 87.33,187.76 v2(87.33,188.04)
  IN4 w0.102: v2(56.65,20.02) 57.16,20.53 57.16,21.27 58.12,22.23 65.74,22.23 67.9,20.07 104.37,20.07 107.32,17.13 122.82,17.13 124.59,15.35 v2(129.28,15.35) ; v2(54.72,37.19) 54.29,37.62 54.29,38.51 48.24,44.56 40.24,44.56 36.33,48.47 36.33,51.13 34.17,53.29 34.17,63.97 37.98,67.78 37.98,81.1 43.19,86.31 43.19,87.28 v2(43.03,87.43)
  BOTTOM w0.102: v2(87.33,188.04) 87.33,185.68 87.75,185.26 CON5602.13
MCK_LED2_EC: length 14.7
  TOP w0.102: SR3022.1 v1(139.78,13.93) 141.99,16.14 145.73,16.14 146.5,16.91 148.82,16.91 150.25,18.34 150.42,18.34 150.86,18.79 U3002.71
MCK_LED3: length 310.3
  TOP w0.102: SR3019.2 R30106.1 139.91,13.29 134.04,13.29 132.84,14.49 v1(130.54,14.49) 129.5,14.49 v2(129.27,14.71) ; v2(57.59,20.63) 57.59,21.52 60.15,24.09 60.15,31.88 55.12,36.91 55.12,38.06 54.95,38.23 54.29,38.23 v2(53.88,37.83)
  IN2 w0.102: v2(42.65,86.47) 42.4,86.72 42.4,88.52 42.2,88.73 42.2,102.52 48.66,108.98 50.38,108.98 50.9,109.49 54.47,109.49 58.69,113.71 58.69,117.29 60.79,119.39 60.79,124.44 61.45,125.1 61.45,133.56 61.06,133.95 61.06,145.32 62.84,147.1 64.74,147.1 68.08,150.45 68.08,153.9 69.57,155.39 69.57,170.36 69.15,170.79 69.15,171.75 68.3,172.6 68.3,177.51 71.67,180.88 73.06,180.88 78.45,186.28 85.19,186.28 86.49,187.58 v2(86.49,187.78)
  IN4 w0.102: v2(53.88,37.83) 53.88,38.58 48.16,44.3 40.11,44.3 36.13,48.29 36.13,51.05 33.97,53.21 33.97,64.06 37.78,67.87 37.78,81.59 v2(42.65,86.47) ; v2(57.59,20.63) 57.59,21.22 58.3,21.93 65.67,21.93 67.9,19.69 103.99,19.69 106.81,16.87 122.74,16.87 124.47,15.15 128.84,15.15 v2(129.27,14.71)
  BOTTOM w0.102: CON5602.11 86.75,185.45 86.49,185.71 v2(86.49,187.78)
MCK_LED3_EC: length 13.3
  TOP w0.102: SR3019.1 v1(142.83,13.55) 142.83,15.07 143.67,15.91 145.8,15.91 146.56,16.67 148.88,16.67 150.35,18.14 150.5,18.14 150.76,18.4 151.11,18.4 151.26,18.55 U3002.72
MCK_LED4: length 318.3
  TOP w0.102: v2(57.59,20.02) 58.1,20.53 58.1,21.65 60.38,23.93 60.38,32.04 55.35,37.07 55.35,38.18 55.07,38.46 53.83,38.46 53.47,38.11 53.47,37.6 v2(53.88,37.19) ; v2(128.63,14.71) 129.37,13.98 v1(132.21,13.98) 133.06,13.98 133.95,13.09 143.39,13.09 R30105.1 144.61,14.31 SR3020.2
  IN2 w0.102: v2(41.79,88.27) 41.79,102.69 48.49,109.39 50.22,109.39 50.73,109.9 54.31,109.9 58.28,113.88 58.28,117.49 60.38,119.59 60.38,122.63 59.7,123.32 59.7,124.7 61.04,126.05 61.04,133.39 60.66,133.78 60.66,145.49 62.67,147.5 64.57,147.5 67.68,150.61 67.68,154.07 69.16,155.56 69.16,170.2 68.74,170.62 68.74,171.58 67.89,172.43 67.89,177.68 71.6,181.38 72.98,181.38 78.28,186.68 85.02,186.68 85.75,187.41 v2(85.75,188.27)
  IN4 w0.102: v2(53.88,37.19) 53.47,37.6 53.47,38.7 48.12,44.05 39.99,44.05 35.92,48.11 35.92,50.96 33.76,53.12 33.76,64.14 37.57,67.95 37.57,82.28 41.79,86.49 v2(41.79,88.27) ; v2(128.63,14.71) 124.54,14.71 122.69,16.57 102.23,16.57 100.4,18.4 68.83,18.4 65.61,21.62 58.64,21.62 58.1,21.08 58.1,20.53 v2(57.59,20.02)
  BOTTOM w0.102: CON5602.9 v2(85.75,188.27)
MCK_LED4_EC: length 9.1
  TOP w0.102: SR3020.1 146.84,14.7 146.84,15.48 v1(146.46,15.86) 147.07,16.47 148.98,16.47 150.45,17.94 150.59,17.94 150.84,18.19 151.29,18.19 151.66,18.57 U3002.73
MCK_LED5: length 340.6
  TOP w0.102: SR3026.2 R30109.1 168.31,18.12 169.04,18.85 169.04,19.09 170.52,20.56 170.52,23.08 170.79,23.35 171.31,23.35 171.81,23.85 171.81,24.24 170.85,25.21 170.85,27.43 v2(170.69,27.58)
  IN2 w0.102: v2(84.59,187.34) 84.13,186.88 78.2,186.88 72.9,181.59 71.51,181.59 67.69,177.76 67.69,172.35 68.54,171.5 68.54,170.47 68.92,170.09 68.92,155.6 67.47,154.16 67.47,150.8 64.39,147.71 62.59,147.71 60.45,145.57 60.45,133.54 60.75,133.25 60.75,126.04 59.47,124.77 59.47,118.97 58.08,117.57 58.08,113.96 54.22,110.1 50.64,110.1 50.15,109.61 48.42,109.61 41.59,102.77 41.59,88.64 41.26,88.31 41.26,77.6 34.17,70.52 34.17,49.16 35.26,48.06 35.26,45.47 40.57,40.16 40.57,37.2 46.9,30.87 51.63,30.87 52.7,29.8 59.42,29.8 60.15,30.54 101.54,30.54 103.34,32.34 114.13,32.34 115.25,33.46 126.78,33.46 128.78,31.45 129.75,31.45 134.55,26.65 156.37,26.65 157.02,26 161.03,26 162.21,27.18 165.21,27.18 166.06,28.02 167.52,28.02 168.42,27.12 170.23,27.12 v2(170.69,27.58)
  BOTTOM w0.102: v1(170.69,26.88) v2(170.69,27.58) ; CON5602.7 84.75,187.18 v2(84.59,187.34)
MCK_LED5_EC: length 5.3
  TOP w0.102: SR3026.1 v1(164.67,18.96) 163.66,19.97 163.66,21.47 163.22,21.91 U3002.99
MCK_LED_B: length 337.9
  TOP w0.102: v2(152.13,14.72) 152.13,14.42 SR3025.1 v1(151.64,13.95) 151.01,13.32 149.46,13.32 149.28,13.49 R30102.1 ; v2(52.18,37.57) 52.18,36.59 56.32,32.45 56.32,29.58 58.17,27.73 58.17,23.93 55.35,21.11 55.35,19.92 56.24,19.03 58.91,19.03 59.37,19.49 v2(59.37,20.02)
  IN2 w0.102: v2(82.52,188.25) 82.52,188.26 81.96,188.83 80.4,188.83 80.2,188.63 77.72,188.63 73.35,184.26 72.17,184.26 66.26,178.35 66.26,171.54 66.05,171.32 66.05,167.22 64.39,165.56 48.27,165.56 46.89,164.18 46.89,157.16 49.82,154.23 52.49,154.23 54.21,152.52 54.21,147.38 55.43,146.16 55.43,131.91 53.45,129.93 53.45,126.8 52.81,126.16 52.81,123.43 46.54,117.15 46.54,113.64 43.64,110.74 43.64,107.57 38.77,102.69 38.77,87.13 v2(38,86.37)
  IN4 w0.102: v2(38,86.37) 38,86.33 36.76,85.09 36.76,68.29 32.95,64.48 32.95,52.79 35.06,50.68 35.06,47.5 40.28,42.27 48.62,42.27 51.77,39.12 51.77,37.98 v2(52.18,37.57) ; v2(152.13,14.72) 150.67,13.27 124.62,13.27 122.41,15.48 101.08,15.48 99.73,16.82 67.95,16.82 64.75,20.02 v2(59.37,20.02)
  BOTTOM w0.102: CON5602.3 82.75,188.02 v2(82.52,188.25)
MCK_LED_B_EC: length 8
  TOP w0.102: U3002.78 153.66,18.61 153.45,18.4 153.45,17.94 153.65,17.74 154.26,17.74 154.41,17.58 154.41,16.61 154.19,16.38 154.19,14.7 SR3025.2 153.44,13.05 v1(153.17,12.78)
MCK_LED_G: length 343.1
  TOP w0.102: v2(58.53,20.02) 58.05,19.54 56.5,19.54 55.86,20.17 55.86,20.94 58.61,23.69 58.61,27.86 56.72,29.75 56.72,32.62 53.07,36.28 v2(53.07,37.57) ; v2(153.42,14.72) 153.68,14.98 SR3024.1
  IN2 w0.102: v2(83.25,188.25) 82.84,187.84 82.36,187.84 82.11,188.08 82.11,188.39 81.87,188.63 80.91,188.63 80.71,188.42 77.87,188.42 73.47,184.02 72.22,184.02 66.47,178.27 66.47,171.46 66.26,171.25 66.26,167.14 64.48,165.36 48.35,165.36 47.09,164.1 47.09,157.25 49.9,154.44 52.57,154.44 54.41,152.6 54.41,147.46 55.63,146.24 55.63,135.47 58.02,133.08 58.02,126.54 55.42,123.94 55.42,113.61 53.56,111.74 48.22,111.74 38.97,102.5 38.97,86.04 v2(38,85.07)
  IN4 w0.102: v2(53.07,37.57) 52.7,37.57 52.58,37.69 52.58,39 48.8,42.78 40.49,42.78 35.52,47.76 35.52,50.79 33.36,52.95 33.36,64.31 37.17,68.12 37.17,84.23 v2(38,85.07) ; v2(153.42,14.72) 152.81,15.34 150.23,15.34 148.57,13.67 124.92,13.67 122.49,16.11 101.58,16.11 100.18,17.51 68.33,17.51 64.8,21.04 59.14,21.04 58.93,20.84 58.93,20.43 v2(58.53,20.02)
  BOTTOM w0.102: CON5602.4 v2(83.25,188.25) ; R30103.1 v1(154.03,14.08) 153.57,14.08 153.42,14.23 v2(153.42,14.72)
MCK_LED_G_EC: length 3.4
  TOP w0.102: U3002.77 153.26,18.52 153.22,18.47 153.22,17.74 v1(153.75,17.2) 153.75,16.75 153.68,16.67 SR3024.2
MCK_LED_R: length 330.8
  TOP w0.102: v2(52.18,38.21) 51.77,37.8 51.77,36.71 56.11,32.37 56.11,29.5 57.97,27.64 57.97,24.01 55.1,21.14 55.1,19.79 56.11,18.78 59.29,18.78 59.86,19.35 59.86,20.14 v2(59.37,20.63) ; v2(152.75,14.72) 152.84,14.81 SR3023.1
  IN2 w0.102: v2(83.86,188.25) 83.2,187.59 77.95,187.59 73.69,183.32 72.38,183.32 67.08,178.01 67.08,172.09 67.82,171.35 67.82,171.01 67.43,170.61 67.35,170.53 66.88,170.07 66.88,166.86 64.77,164.75 58.27,164.75 57.59,164.07 57.59,153.5 56.54,152.45 56.54,148.5 56.27,148.23 56.27,135.97 58.63,133.61 58.63,126.25 56.85,124.48 56.85,114.17 53.81,111.14 48.47,111.14 39.66,102.32 39.66,86.54 v2(39.86,86.34)
  IN4 w0.102: v2(39.86,86.34) 39.35,85.83 37.79,85.83 36.96,85 36.96,68.2 33.15,64.39 33.15,52.87 35.26,50.76 35.26,47.63 40.37,42.53 48.75,42.53 52.18,39.1 v2(52.18,38.21) ; v2(59.37,20.63) 59.75,20.25 65.03,20.25 68,17.28 99.83,17.28 101.26,15.86 122.41,15.86 124.8,13.47 148.9,13.47 150.56,15.13 152.34,15.13 v2(152.75,14.72)
  BOTTOM w0.102: CON5602.5 83.75,188.14 v2(83.86,188.25) ; R30104.1 152.79,14.41 152.75,14.44 v2(152.75,14.72) v1(152.75,15.42)
MCK_LED_R_EC: length 3.2
  TOP w0.102: U3002.76 152.86,18.14 152.84,18.12 SR3023.2
MCT0: length 4.1
  TOP w0.508: U3401.24 305.67,154.54 306.3,153.91 306.3,152.79 R3400.1
MCT1: length 4.4
  TOP w0.102: R3401.1 307.42,150.71 v1(307.42,149.46)
  TOP w0.508: R3401.1 306.69,151.11 306.25,151.54 U3401.21
MCT2: length 3.7
  TOP w0.102: R3402.1 306.25,147.81 306.66,147.4 v1(307.42,147.4)
  TOP w0.508: U3401.18 305.75,148.54 305.8,148.49 R3402.1
MCT3: length 4.4
  TOP w0.102: v1(307.42,143.31) 306.25,144.48 R3403.1
  TOP w0.508: U3401.15 305.65,145.54 305.67,145.52 R3403.1
ME_AC_PRESENT: length 128.2
  TOP w0.102: SR3012.2 153.99,39.44 v2(154.01,39.45) ; R2442.2 244.13,66.3 244.02,66.2 R2459.1 243.62,66.2 243.15,65.73 242.05,65.73 v1(241.87,65.54) 241.11,64.79 240.12,64.79 239.27,63.94 238.68,63.94 237.67,62.93 236.37,62.93 v2(236.02,62.58)
  IN1 w0.102: v2(156.83,30.33) 157.16,30 161.63,30 162.19,29.45 164.63,29.45 165.24,30.05 195.89,30.05 202.26,36.43 202.26,38.22 206.73,42.69 206.73,43.61 211.65,48.53 215.26,48.53 215.55,48.83 217.66,48.83 218.02,48.46 219.89,48.46 220.17,48.75 228.68,48.75 229.14,49.2 230.86,49.2 231.43,49.77 231.88,49.77 232.14,50.03 232.14,51.87 232.69,52.42 235.12,52.42 235.72,53.02 236.9,53.02 237.88,53.99 237.88,61.38 237.48,61.78 236.41,61.78 236.02,62.17 v2(236.02,62.58)
  BOTTOM w0.102: U2000.BB15 237.4,62.77 237.03,62.77 236.98,62.79 236.52,62.79 236.41,62.75 236.19,62.75 v2(236.02,62.58) ; v2(156.83,30.33) 156.83,36.6 154.01,39.43 v2(154.01,39.45)
MEM_VDD_CTL: length 170.6
  TOP w0.102: SR8904.1 251.75,78.51 v1(251.75,78.24) 251.75,77.78 251.25,77.29 248.04,77.29 246.45,78.87 245.87,78.87 245.39,79.36 244.82,79.36 244.13,80.04 242.97,80.04 v2(242.67,80.35)
  IN2 w0.102: v2(242.67,80.35) 242.44,80.12 240.35,80.12 238.63,78.4 236.53,78.4 235.63,77.5 232.29,77.5 231.63,78.16 215.11,78.16 208.69,71.74 206.89,71.74 204.23,69.07 204.23,65.62 195.66,57.06 195.66,48.76 192.95,46.06 192.5,46.06 190.45,44.01 186.59,44.01 185.64,44.97 155.95,44.97 153.57,47.34 153.57,50.45 150.3,53.73 150.3,55.07 v2(150.48,55.25)
  IN4 w0.102: v2(150.48,55.25) 150.48,56.52 152.05,58.1 152.05,63.61 149.92,65.74 147.62,65.74 147.09,66.28 147.09,67.85 148.14,68.9 148.14,70.01 149.03,70.9 149.03,73.36 148.75,73.64 148.75,79.19 148.41,79.53 147.93,79.53 v3(146.9,78.5)
  BOTTOM w0.102: R7460.2 R7459.2 149.87,57.69 150.3,57.26 150.3,56.78 150.48,56.6 v2(150.48,55.25) ; v3(146.9,78.5) 146.55,78.15 U7000.BH4
MSM_TP: length 1.3
  TOP w0.102: v3(87.21,111.52) 87.57,111.89 T1001.1
  BOTTOM w0.102: U0300.AW13 86.88,111.2 v3(87.21,111.52)
N17_REST_BACKUP#: length 222.1
  TOP w0.102: R2481.1 245.22,52.37 v2(245.22,51.62)
  IN1 w0.102: v2(245.22,51.62) 245.22,50.65 244.94,50.38 244.94,46.12 242.74,43.92 241.4,43.92 241.4,43.91 240.99,43.91 239.88,42.81 239.88,41.72 239.47,41.31 238.87,41.31 237.81,40.24 234.75,40.24 234.32,39.81 232.3,39.81 229.76,37.26 225.23,37.26 224.52,37.98 217.45,37.98 210.11,30.64 209.36,30.64 201.56,22.84 184.65,22.84 184.04,23.45 178.22,23.45 177.68,22.91 175.03,22.91 174.36,23.57 171.45,23.57 171.36,23.48 167.24,23.48 167.18,23.43 164.27,23.43 164.14,23.3 157.56,23.3 157.21,23.65 142.76,23.65 139.22,27.19 127.44,27.19 v2(126.85,27.77)
  BOTTOM w0.102: U2000.BD34 238.66,53.2 238.76,53.2 238.89,53.12 239.2,52.81 240.12,52.81 240.85,52.08 241.6,52.08 241.65,52.13 242.75,52.13 242.83,52.2 244.26,52.2 244.34,52.13 244.71,52.13 v2(245.22,51.62) 245.71,51.62 R2465.2 ; v2(126.85,27.77) 126.85,27.36 123.68,24.19 122.57,24.19 122.25,24.51 122.25,25.28 122.94,25.98 122.94,31.73 123.87,32.66 123.87,34.12 124.28,34.52 124.28,35.51 126.09,37.32 126.09,52.48 128,54.39 128,64.3 127.65,64.64 127.65,66.28 126.33,67.6 126.33,79.98 v1(127.92,81.57) 129.88,83.52 129.88,88.33 130.05,88.51 U7002.1
NC_B4: length 4.8
  TOP w0.102: U1101.B4 299.05,44.48 299.22,44.66 299.77,44.66 300.78,43.65 v1(301.38,43.65) 302.85,43.65 R1126.1
NC_B5: length 2.5
  TOP w0.102: R1127.1 300.72,42.88 300.54,42.88 299.68,43.75 299.27,43.75 U1101.B5
NC_F19: length 4.1
  TOP w0.102: U1101.F19 297.05,37.5 v5(297.37,37.82)
  BOTTOM w0.102: R1124.2 298.02,36.43 297.66,36.07 v1(296.97,36.07) 296.87,36.17 296.87,37.37 297.32,37.82 v5(297.37,37.82)
NC_G2: length 4.4
  TOP w0.102: v1(293.58,47.48) 293.66,47.56 R1125.1 294.87,47.56 295.6,46.83 295.83,46.83 296.52,46.13 296.52,45.57 U1101.G2
Net_233: length 0.3
  BOTTOM w0.203: 115.01,122.66 115.01,122.33
Net_250: length 0.3
  BOTTOM w0.203: 115.01,123.91 115.01,124.24
Net_255: length 0.4
  BOTTOM w0.203: 75.68,103.39 75.68,103.74
Net_294: length 0.3
  TOP w0.203: 293.07,45.35 293.07,45.07
Net_296: length 0.3
  TOP w0.203: 293.99,45.35 293.99,45.07
NO_REBOOT_MODE: length 10.2
  BOTTOM w0.102: U2000.BD28 238.82,56.1 239.32,56.1 239.35,56.07 240.99,56.07 241.12,55.95 244.88,55.95 244.94,56.01 245.88,56.01 R2413.2 246.95,57.08 v1(247.22,57.08) 247.89,57.08 R2405.1
NTC_A: length 8.3
  BOTTOM w0.102: U8000.15 57.77,179.99 58.58,179.18 59.54,179.18 59.8,178.92 62.47,178.92 R8081.2 62.85,177.78 v1(63.13,177.5)
NTC_B: length 7.3
  BOTTOM w0.102: v1(63.07,189.44) 62.79,189.16 R8031.2 61.7,188.7 60.94,188.7 60.69,188.45 60.69,185.78 59.85,184.94 U8000.3
NVJTAG_SEL: length 7.4
  BOTTOM w0.102: R7425.2 139.2,89.31 139.38,89.49 142.66,89.49 144.27,91.1 144.8,91.1 U7000.BK23
NVVDD_EN: length 142.7
  TOP w0.102: U7415.4 144.11,64.52 143.76,64.17 v2(142.22,64.17) ; v2(144.89,59.67) 144.95,59.74 D7403.2
  IN3 w0.102: v2(119.59,164.32) 117.88,162.61 117.88,154.87 119.94,152.81 122.28,152.81 123.68,151.42 123.68,148.78 123.06,148.16 123.06,147.62 122.14,146.69 117.35,146.69 115.63,144.96 115.63,136.7 116.71,135.62 117.32,135.62 118.02,134.92 118.86,134.92 120.61,133.16 120.61,130.25 121.09,129.78 121.09,128.22 124.71,124.6 124.71,112.12 125.37,111.46 125.37,90.06 128.1,87.33 128.1,84.94 127.69,84.54 127.69,79.87 133.26,74.3 137.67,74.3 138.61,73.36 138.61,67.78 v2(142.22,64.17)
  IN4 w0.102: v2(142.22,64.17) 142.37,64.17 143.57,62.97 143.57,60.58 144.48,59.67 v2(144.89,59.67)
  BOTTOM w0.102: R8700.1 123.63,159.11 123.14,159.6 D8701.2 121.7,160.13 120.86,160.97 v1(120.86,161.2) 120.86,163.05 v2(119.59,164.32)
NVVDD_PSI: length 119
  TOP w0.432: SR8702.1 130.91,160.42 v2(131.22,160.74)
  TOP w0.508: v2(125.1,149.56) 124.03,149.56 v1(123.7,149.89)
  IN3 w0.508: v2(125.1,149.56) 125.28,149.74 125.28,152.84 128.76,156.32 128.76,159.09 130.13,160.45 130.94,160.45 v2(131.22,160.74) ; v2(120.52,134.69) 121.63,133.58 121.63,130.67 122.1,130.2 122.1,128.65 126.53,124.22 126.53,123.04 126.7,122.87 126.7,117.05 126.39,116.74 126.39,90.48 129.14,87.73 129.14,84.97 129.36,84.75 129.36,82.83 129.17,82.63 129.17,79.89 133.74,75.32 138.1,75.32 140.05,73.36 140.57,73.36 141,72.93 141,70.07 141.92,69.15 145.42,69.15 v2(146.41,68.16)
  IN4 w0.508: v2(125.1,149.56) 124.44,149.56 123.5,148.62 123.5,146.82 124.49,145.83 124.49,137.14 122.04,134.69 v2(120.52,134.69)
  BOTTOM w0.381: SR7409.2 146.41,68.52 v2(146.41,68.16)
NVVDD_PWROK: length 206.9
  TOP w0.102: v2(128.99,169.4) 129.27,169.4 131.01,167.66 131.01,167.24 133.61,164.64 133.61,161.55 133.33,161.27 131.85,161.27 SR8704.1 ; v2(168.84,43.03) 169.61,42.26 170.15,42.26 T9204.1 173.01,41.64 178.29,41.64 178.75,42.09 178.75,42.3 179.64,43.19 R9206.1
  IN2 w0.102: v2(168.84,43.03) 167.93,43.95 155.53,43.95 151.82,47.66 151.82,50.17 147.85,54.13 145.77,54.13 145.17,54.74 145.17,57.31 143.31,59.17 143.31,59.38 142.53,60.16 141.94,60.16 v2(141.88,60.1)
  IN3 w0.102: v2(141.88,60.1) 141.32,60.66 138.69,60.66 138.39,60.97 136.22,60.97 129.88,67.31 129.88,68.14 127.6,70.42 127.6,72.57 124.95,75.23 124.95,111.27 124.3,111.92 124.3,124.44 121.06,127.68 120.11,127.68 119.77,128.02 119.77,130.01 120.21,130.45 120.21,132.99 118.69,134.51 117.85,134.51 117.15,135.21 116.54,135.21 115.22,136.53 115.22,145.13 117.19,147.1 121.37,147.1 121.88,147.61 121.88,148.22 122.47,148.81 122.92,148.81 123.48,149.37 123.48,151.33 122.2,152.61 119.85,152.61 117.67,154.79 117.67,163.96 121.28,167.57 128.64,167.57 128.99,167.92 v2(128.99,169.4)
NVVDD_SCL: length 94.5
  TOP w0.121: SR8706.1 v2(132.57,158.35)
  IN3 w0.083: v2(132.57,158.35) 133.03,157.89 133.03,157.21 132.52,156.7 132.08,156.7 130.64,155.26 130.64,154.52 128.89,152.76 128.89,150.41 127.79,149.31 127.79,148.67 124.64,145.52 124.64,136.14 123.13,134.62 123.13,131.29 126.71,127.71 126.71,126.15 127.52,125.34 127.77,125.34 128.73,124.38 128.73,123.17 128.2,122.64 128.2,116.36 127.88,116.04 127.88,93.58 128.71,92.76 128.71,90.28 130.37,88.61 130.98,88.61 131.68,87.91 131.68,80.7 133.87,78.52 v2(135.06,78.52)
  BOTTOM w0.121: v1(133.23,158.35) v2(132.57,158.35) ; R7498.2 136.11,77.5 135.85,77.5 135.76,77.59 135.76,78.17 135.41,78.52 v2(135.06,78.52)
NVVDD_SDA: length 95.1
  TOP w0.121: SR8701.1 v2(132.57,157.33)
  IN3 w0.083: v2(132.57,157.33) 132.06,157.33 130.18,155.46 130.18,154.71 128.42,152.95 128.42,150.6 127.33,149.5 127.33,148.86 124.18,145.71 124.18,136.33 122.66,134.81 122.66,131.1 126.25,127.51 126.25,125.96 127.33,124.88 127.57,124.88 128.24,124.21 128.24,123.33 127.74,122.83 127.74,116.55 127.42,116.23 127.42,93.38 128.24,92.56 128.24,90.08 130.18,88.15 130.79,88.15 131.22,87.71 131.22,80.51 133.82,77.91 v2(135.06,77.91)
  BOTTOM w0.121: v1(132.57,156.65) v2(132.57,157.33) ; R7499.2 137.09,77.11 136.94,76.97 135.57,76.97 135.06,77.48 v2(135.06,77.91)
NVVDD_VDD_SENSE: length 60.7
  TOP w0.254: SR8708.2 132.62,153.63 v2(133.15,153.09)
  BOTTOM w0.15: U7000.BK45 144.8,107.2 144.3,107.2 143.8,107.7
  BOTTOM w0.254: 143.8,107.7 141.06,107.7 138.51,110.25 138.51,114.08 136.96,115.63 136.96,118.13 130.24,124.85 130.24,134.08 126.98,137.34 126.98,144.91 v1(127.31,145.24) 129.01,146.95 129.01,148.01 130.44,149.44 132.04,149.44 133.66,151.06 133.66,152.71 133.28,153.09 v2(133.15,153.09)
NVVDD_VID: length 122.2
  TOP w0.102: SR7403.2 146.67,70.48 v2(146.45,70.26) ; SR8703.1 132.19,161.94 v2(132.19,161.78) 132.26,161.7 v1(132.92,161.7)
  IN3 w0.102: v2(132.19,161.78) 132.19,159.87 130.03,157.72 130.03,156.7 127.11,153.78 127.11,148.95 123.83,145.67 123.22,145.67 122.94,145.4 117.79,145.4 116.85,144.45 116.85,137.21 117.22,136.84 117.83,136.84 118.52,136.14 120.22,136.14 122.44,133.92 122.44,131.01 122.92,130.53 122.92,128.98 127.24,124.66 127.48,124.66 128.02,124.12 128.02,123.42 127.52,122.92 127.52,116.64 127.2,116.32 127.2,90.81 130.28,87.73 130.28,82.97 131,82.25 131,80.42 133.92,77.5 135.41,77.5 136.79,76.13 138.43,76.13 140.39,74.18 140.91,74.18 141.87,73.22 141.87,72.1 143.22,70.75 145.97,70.75 v2(146.45,70.26)
