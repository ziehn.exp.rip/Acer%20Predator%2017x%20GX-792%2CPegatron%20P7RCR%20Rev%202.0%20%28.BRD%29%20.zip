# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
VX_C0201
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_C0201_H14
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_C0402_H20_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C0402_H24_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C0402_H26_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C0402_H28_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C0603_H39_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_C0603_H39_SMALL_T02
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_C0603_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_C0805_H55_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_C0805_H57_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_C0805_H57_SMALL_T02
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_C1206_H49
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
VX_C1206_H75
  rect 0.864x1.803 smd: 1(1.27,0) 2(-1.27,0)
VX_C3528
  rect 1.905x2.21 smd: 1(1.816,0) 2(-1.816,0)
VX_C3528_SANYO_H79
  rect 1.422x2.21 smd: 1(1.567,0) 2(-1.567,0)
VX_C7343D_3P
  rect 2.388x2.794 smd: 1(3.2,0) 3(-3.2,0)
  custom 0.675x0.675 smd: 2(0.15,0)
VX_C7343D_H83
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
VX_C7343D_KEMET
  rect 2.743x2.692 smd: 1(3.277,0) 2(-3.277,0)
VX_C_ARRAY_8P_79X49_H39
  rect 0.292x0.762 smd: 1(-0.75,-0.625) 2(-0.75,0.625) 3(-0.25,-0.625) 4(-0.25,0.625) 5(0.25,-0.625) 6(0.25,0.625) 7(0.75,-0.625) 8(0.75,0.625)
VX_CESMD_260X260_H240_COLAY
  rect 3.226x1.93 smd: 1(2.407,0) 2(-2.407,0)
VX_CESMD_260X260_PANASONIC
  rect 3.099x1.88 smd: 1(2.35,0) 2(-2.35,0)
VX_CHOKE_2P_453X394
  rect 3.15x4.597 smd: 1(4.469,0) 2(-4.469,0)
VX_CHOKE_2P_543X496
  rect 3.251x4.039 smd: 1(-5.625,0) 2(5.625,0)
VX_CHOKE_4P_39X49_QUIE_H24
  rect 0.356x0.559 smd: 1(-0.3,-0.625) 2(0.3,-0.625) 3(0.3,0.625) 4(-0.3,0.625)
VX_CHOKE_4P_49X39_MUR
  rect 0.762x0.305 smd: 1(-0.66,-0.275) 2(0.66,-0.275) 3(0.66,0.275) 4(-0.66,0.275)
VX_DDR4_260P_20_4H_RE_H177
  round 1.041 hole 1.041 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
VX_DDR4_260P_20_4H_REV_ARGO
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  custom 0.502x0.502 smd: 263(-37.75,12)
  rect 2.007x3.505 smd: 264(37.75,8)
VX_DDR4_260P_20_4HD_FOX
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.041 hole 1.041 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
VX_DDR4_260P_20_4HOD_REV_FO
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
VX_DFN_5P_50_209X228
  rect 0.508x0.711 smd: 1(-1.905,-2.695) 2(-0.635,-2.695) 3(0.635,-2.695) 4(1.905,-2.695)
  custom 1.053x1.053 smd: 5(0,0)
VX_DFN_8P_20_79X79_PAD_ON
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.295x0.864 smd: 9(0,0)
VX_DFN_8P_20_S79_P_I_H39_1V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.6x0.864 smd: 9(0,0)
  round 0.61 hole 0.305: 10(0,0)
VX_DFN_10P_16_118X79_PAD
  custom 0.15x0.15 smd: 1(-1.2,-1) 7(0.8,-1) 8(0.8,1) 14(-1.2,1)
  rect 0.203x0.711 smd: 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 10(0.4,1) 11(0,1) 12(-0.4,1)
  rect 2.54x0.838 smd: 15(0,0)
VX_DFN_10P_20_98X39_NXP
  rect 0.279x0.533 smd: 1(-1,-0.375) 2(-0.5,-0.375) 3(0,-0.375) 4(0.5,-0.375) 5(1,-0.375) 6(1,0.375) 7(0.5,0.375) 8(0,0.375) 9(-0.5,0.375) 10(-1,0.375)
VX_DFN_12P_18_S118_P_T01_7V
  rect 0.279x0.61 smd: 1(-1.125,-1.35) 2(-0.675,-1.35) 3(-0.225,-1.35) 4(0.225,-1.35) 5(0.675,-1.35) 6(1.125,-1.35) 7(1.125,1.35) 8(0.675,1.35) 9(0.225,1.35) 10(-0.225,1.35) 11(-0.675,1.35) 12(-1.125,1.35)
  rect 2.743x1.651 smd: 13(0,0)
  round 0.61 hole 0.305: 14(-0.5,0.5) 15(0.5,0.5) 16(-1,0) 17(0,0) 18(1,0) 19(-0.5,-0.5) 20(0.5,-0.5)
VX_DISPLAY_20P_39_4H_ACON
  rect 0.787x0.787 hole 0.533: 1(5.5,8.48)
  round 0.787 hole 0.533: 2(5,6.98) 3(4.5,8.48) 4(4,6.98) 5(3.5,8.48) 6(3,6.98) 7(2.5,8.48) 8(2,6.98) 9(1.5,8.48) 10(1,6.98) 11(0.5,8.48) 12(0,6.98) 13(-0.5,8.48) 14(-1,6.98) 15(-1.5,8.48) 16(-2,6.98) 17(-2.5,8.48) 18(-3,6.98) 19(-3.5,8.48) 20(-4,6.98)
  oval 1.016x2.007 hole 0.61x1.6: 21(8.2,7.58) 22(-8.2,7.58) 23(10.35,0) 24(-10.35,0)
VX_ESD_2P_24X13_PAD8X10
  rect 0.203x0.254 smd: 1(-0.2,0) 2(0.2,0)
VX_ESD_2P_33_39X24_COLAY
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
VX_ESD_2P_34_39X24_INPAQ
  rect 0.66x0.508 smd: 1(-0.433,0) 2(0.433,0)
VX_FPC_8P_20_2H_RA_ACE_B
  rect 0.305x0.889 smd: 1(-1.75,3.05) 2(-1.25,3.05) 3(-0.75,3.05) 4(-0.25,3.05) 5(0.25,3.05) 6(0.75,3.05) 7(1.25,3.05) 8(1.75,3.05)
  rect 0.991x2.007 smd: 9(-3.85,0) 10(3.85,0)
VX_FPC_12P_20_2HD_B
  rect 0.292x0.889 smd: 1(-2.75,3.05) 2(-2.25,3.05) 3(-1.75,3.05) 4(-1.25,3.05) 5(-0.75,3.05) 6(-0.25,3.05) 7(0.25,3.05) 8(0.75,3.05) 9(1.25,3.05) 10(1.75,3.05) 11(2.25,3.05) 12(2.75,3.05)
  rect 0.991x2.007 smd: 13(-4.85,0) 14(4.85,0)
VX_FPC_14P_20_2H_ACE_B
  rect 0.305x0.889 smd: 1(-3.25,3.05) 2(-2.75,3.05) 3(-2.25,3.05) 4(-1.75,3.05) 5(-1.25,3.05) 6(-0.75,3.05) 7(-0.25,3.05) 8(0.25,3.05) 9(0.75,3.05) 10(1.25,3.05) 11(1.75,3.05) 12(2.25,3.05) 13(2.75,3.05) 14(3.25,3.05)
  rect 0.991x2.007 smd: 15(-5.35,0) 16(5.35,0)
VX_FPC_14P_20_2HD_RA_ENTERY
  rect 0.305x0.787 smd: 1(-3.25,2.5) 2(-2.75,2.5) 3(-2.25,2.5) 4(-1.75,2.5) 5(-1.25,2.5) 6(-0.75,2.5) 7(-0.25,2.5) 8(0.25,2.5) 9(0.75,2.5) 10(1.25,2.5) 11(1.75,2.5) 12(2.25,2.5) 13(2.75,2.5) 14(3.25,2.5)
  rect 0.406x0.787 smd: 15(-4.25,0) 16(4.25,0)
VX_FPC_26P_39_2H_RA_B
  rect 0.61x1.092 smd: 1(-12.5,2.15) 2(-11.5,2.15) 3(-10.5,2.15) 4(-9.5,2.15) 5(-8.5,2.15) 6(-7.5,2.15) 7(-6.5,2.15) 8(-5.5,2.15) 9(-4.5,2.15) 10(-3.5,2.15) 11(-2.5,2.15) 12(-1.5,2.15) 13(-0.5,2.15) 14(0.5,2.15) 15(1.5,2.15) 16(2.5,2.15) 17(3.5,2.15) 18(4.5,2.15) 19(5.5,2.15) 20(6.5,2.15) 21(7.5,2.15) 22(8.5,2.15) 23(9.5,2.15) 24(10.5,2.15) 25(11.5,2.15) 26(12.5,2.15)
  rect 2.21x3.2 smd: 27(-15,0) 28(15,0)
VX_FPC_45P_20_2H_RA_ENTE_B
  rect 0.305x1.295 smd: 1(-11,2.65) 2(-10.5,2.65) 3(-10,2.65) 4(-9.5,2.65) 5(-9,2.65) 6(-8.5,2.65) 7(-8,2.65) 8(-7.5,2.65) 9(-7,2.65) 10(-6.5,2.65) 11(-6,2.65) 12(-5.5,2.65) 13(-5,2.65) 14(-4.5,2.65) 15(-4,2.65) 16(-3.5,2.65) 17(-3,2.65) 18(-2.5,2.65) 19(-2,2.65) 20(-1.5,2.65) 21(-1,2.65) 22(-0.5,2.65) 23(0,2.65) 24(0.5,2.65) 25(1,2.65) 26(1.5,2.65) 27(2,2.65) 28(2.5,2.65) 29(3,2.65) 30(3.5,2.65) 31(4,2.65) 32(4.5,2.65) 33(5,2.65) 34(5.5,2.65) 35(6,2.65) 36(6.5,2.65) 37(7,2.65) 38(7.5,2.65) 39(8,2.65) 40(8.5,2.65) 41(9,2.65) 42(9.5,2.65) 43(10,2.65) 44(10.5,2.65) 45(11,2.65)
  rect 1.803x1.397 smd: 46(-12.65,0) 47(12.65,0)
VX_FPC_CON_28P_20_2H_AC_B
  rect 0.292x1.295 smd: 1(-6.75,2.8) 2(-6.25,2.8) 3(-5.75,2.8) 4(-5.25,2.8) 5(-4.75,2.8) 6(-4.25,2.8) 7(-3.75,2.8) 8(-3.25,2.8) 9(-2.75,2.8) 10(-2.25,2.8) 11(-1.75,2.8) 12(-1.25,2.8) 13(-0.75,2.8) 14(-0.25,2.8) 15(0.25,2.8) 16(0.75,2.8) 17(1.25,2.8) 18(1.75,2.8) 19(2.25,2.8) 20(2.75,2.8) 21(3.25,2.8) 22(3.75,2.8) 23(4.25,2.8) 24(4.75,2.8) 25(5.25,2.8) 26(5.75,2.8) 27(6.25,2.8) 28(6.75,2.8)
  rect 1.803x1.397 smd: 29(-8.4,0) 30(8.4,0)
VX_H_CT276CB315D118_P2
  round 3.505 hole 2.997: 1(0,0)
VX_H_ST335CB315D118_P2
  round 3.505 hole 2.997: 1(0,0)
VX_HDMI_19P_4HLD_ACON
  rect 0.813x0.813 hole 0.559: 1(4.5,7.57)
  round 0.813 hole 0.559: 2(4,6.37) 3(3.5,7.57) 4(3,6.37) 5(2.5,7.57) 6(2,6.37) 7(1.5,7.57) 8(1,6.37) 9(0.5,7.57) 10(0,6.37) 11(-0.5,7.57) 12(-1,6.37) 13(-1.5,7.57) 14(-2,6.37) 15(-2.5,7.57) 16(-3,6.37) 17(-3.5,7.57) 18(-4,6.37) 19(-4.5,7.57)
  oval 1.168x2.362 hole 0.762x1.956: 20(9,5.2) 21(-9,5.2) 22(9,0) 23(-9,0)
VX_INDUCTOR_2P_118X118_MAG
  rect 0.991x2.997 smd: 1(-1.1,0) 2(1.1,0)
VX_INDUCTOR_2P_157X157_COIL
  rect 0.965x3.404 smd: 1(-1.185,0) 2(1.185,0)
VX_INDUCTOR_2P_268X268_MIC
  rect 2.489x2.896 smd: 1(-3.2,0) 2(3.2,0)
VX_INDUCTOR_2P_274X260
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
VX_INDUCTOR_2P_291X264
  rect 2.032x3.2 smd: 1(-3.22,0) 2(3.22,0)
VX_INDUCTOR_2P_439X394_M157
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
VX_L0603_H37_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_L0603_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_L0805_H43_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_LAN_JACK_8P_2HD_SAN_LF2
  round 1.27 hole 0.686: 1(-3.57,6.42) 2(-2.55,7.52) 3(-1.53,6.42) 4(-0.51,7.52) 5(0.51,6.42) 6(1.53,7.52) 7(2.55,6.42) 8(3.57,7.52)
  oval 1.905x3.581 hole 0.711x2.388: 9(9.525,0) 10(-9.525,0)
VX_LED_2P_39X20_EVERLIG
  rect 0.406x0.61 smd: 1(0.5,0) 2(-0.5,0)
VX_LGA_12P_20_79X79_BOSCH
  rect 0.279x0.406 smd: 1(-0.75,-0.815) 2(-0.25,-0.815) 3(0.25,-0.815) 4(0.75,-0.815) 7(0.75,0.815) 8(0.25,0.815) 9(-0.25,0.815) 10(-0.75,0.815)
  rect 0.406x0.279 smd: 5(0.815,-0.25) 6(0.815,0.25) 11(-0.815,0.25) 12(-0.815,-0.25)
VX_MINI_PCI_67P_20_4H_H128
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
VX_MINI_PCI_67P_20_4HLD_LOT
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 59(5.25,4.725) 60(5.5,-1.725) 61(5.75,4.725) 62(6,-1.725) 63(6.25,4.725) 64(6.5,-1.725) 65(6.75,4.725) 66(7,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
VX_MLP_28P_20_S197_S_H31_7V
  rect 0.305x0.762 smd: 1(-1.75,-2.425) 2(-1.25,-2.425) 3(-0.75,-2.425) 4(-0.25,-2.425) 5(0.25,-2.425) 6(0.75,-2.425) 7(1.25,-2.425) 8(1.75,-2.425) 16(1.75,2.425) 17(1.25,2.425) 18(0.75,2.425) 19(0.25,2.425) 20(-0.25,2.425) 21(-0.75,2.425) 22(-1.25,2.425) 23(-1.75,2.425)
  rect 0.762x0.305 smd: 24(-2.481,1.75) 25(-2.481,1.25) 26(-2.481,0.75) 27(-2.481,0.25) 28(-2.481,-0.25) 29(-2.481,-0.75) 30(-2.481,-1.25) 31(-2.481,-1.75)
  custom 0.339x0.339 smd: 32(1.06,-1.185)
  custom 0.551x0.551 smd: 33(0.15,0.74)
  rect 0.559x0.406 smd: 34(-1.526,0.1)
  rect 1.422x1.118 smd: 35(-1.09,-1.185)
  round 0.61 hole 0.305: 36(-1.325,1.23) 37(-0.375,1.23) 38(0.575,1.23) 39(1.525,1.23) 40(-0.375,0.23) 41(0.575,0.23) 42(1.525,0.23)
VX_NGFF_67P_20_4HOLD_H165
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
VX_POWERDI123
  rect 0.889x1.397 smd: 1(-1.605,0)
  rect 2.21x1.397 smd: 2(0.945,0)
VX_QFN_16P_20_118X118_MPS
  rect 0.254x2.108 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.711x0.254 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.254x0.889 smd: 10(-0.5,1.35)
VX_QFN_16P_20_S118_P_SIG_2V
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
  round 0.61 hole 0.305: 18(-0.533,0.533) 19(0.533,-0.533)
VX_QFN_16P_20_S118_PAD_RIC
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
VX_QFN_16P_26_S157_PAD_SIGE
  rect 0.381x0.762 smd: 1(-0.975,-1.775) 2(-0.325,-1.775) 3(0.325,-1.775) 4(0.975,-1.775) 9(0.975,1.775) 10(0.325,1.775) 11(-0.325,1.775) 12(-0.975,1.775)
  rect 0.762x0.381 smd: 5(1.775,-0.975) 6(1.775,-0.325) 7(1.775,0.325) 8(1.775,0.975) 13(-1.775,0.975) 14(-1.775,0.325) 15(-1.775,-0.325) 16(-1.775,-0.975)
  rect 2.311x2.311 smd: 17(0,0)
VX_QFN_16P_118X188_MPS
  rect 0.203x1.092 smd: 1(-0.525,-1.25) 2(0.175,-1.25) 8(0.525,1.25) 9(-0.175,1.25)
  rect 0.711x0.222 smd: 3(1.45,-0.8) 4(1.45,-0.4) 5(1.45,0) 6(1.45,0.4) 7(1.45,0.8) 10(-1.45,0.8) 11(-1.45,0.4) 12(-1.45,0) 13(-1.45,-0.4) 14(-1.45,-0.8)
  rect 0.203x0.66 smd: 15(-0.165,0) 16(0.435,0)
VX_QFN_20P_16_122X122_P_5V
  rect 0.229x0.61 smd: 1(-0.8,-1.395) 2(-0.4,-1.395) 3(0,-1.395) 4(0.4,-1.395) 5(0.8,-1.395) 11(0.8,1.395) 12(0.4,1.395) 13(0,1.395) 14(-0.4,1.395) 15(-0.8,1.395)
  rect 0.61x0.229 smd: 6(1.395,-0.8) 7(1.395,-0.4) 8(1.395,0) 9(1.395,0.4) 10(1.395,0.8) 16(-1.395,0.8) 17(-1.395,0.4) 18(-1.395,0) 19(-1.395,-0.4) 20(-1.395,-0.8)
  rect 1.753x1.753 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.57,-0.57) 23(0.57,-0.57) 24(0.57,0.57) 25(-0.57,0.57) 26(0,0)
VX_QFN_20P_16_S118_P_H31_2V
  rect 0.222x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.222 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(0.521,0.521) 23(-0.521,-0.521)
VX_QFN_20P_16_S118_P_H31_4V
  rect 0.229x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.229 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,0.5) 23(0.5,0.5) 24(-0.5,-0.5) 25(0.5,-0.5)
VX_QFN_20P_20_S157_PAD_M_2V
  rect 0.279x0.762 smd: 1(-1,-1.775) 2(-0.5,-1.775) 3(0,-1.775) 4(0.5,-1.775) 5(1,-1.775) 11(1,1.775) 12(0.5,1.775) 13(0,1.775) 14(-0.5,1.775) 15(-1,1.775)
  rect 0.762x0.279 smd: 6(1.775,-1) 7(1.775,-0.5) 8(1.775,0) 9(1.775,0.5) 10(1.775,1) 16(-1.775,1) 17(-1.775,0.5) 18(-1.775,0) 19(-1.775,-0.5) 20(-1.775,-1)
  rect 2.108x2.108 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.74,0.74) 23(-0.74,-0.74)
VX_QFN_28P_16_S157_PAD_4V
  rect 0.229x0.61 smd: 1(-1.2,-1.85) 2(-0.8,-1.85) 3(-0.4,-1.85) 4(0,-1.85) 5(0.4,-1.85) 6(0.8,-1.85) 7(1.2,-1.85) 15(1.2,1.85) 16(0.8,1.85) 17(0.4,1.85) 18(0,1.85) 19(-0.4,1.85) 20(-0.8,1.85) 21(-1.2,1.85)
  rect 0.61x0.229 smd: 8(1.85,-1.2) 9(1.85,-0.8) 10(1.85,-0.4) 11(1.85,0) 12(1.85,0.4) 13(1.85,0.8) 14(1.85,1.2) 22(-1.85,1.2) 23(-1.85,0.8) 24(-1.85,0.4) 25(-1.85,0) 26(-1.85,-0.4) 27(-1.85,-0.8) 28(-1.85,-1.2)
  rect 2.692x2.692 smd: 29(0,0)
  round 0.61 hole 0.305: 30(-1.041,1.041) 31(1.041,1.041) 32(-1.041,-1.041) 33(1.041,-1.041)
VX_QFN_40P_16_203X203_P_9V
  rect 0.229x0.61 smd: 1(-1.8,-2.345) 2(-1.4,-2.345) 3(-1,-2.345) 4(-0.6,-2.345) 5(-0.2,-2.345) 6(0.2,-2.345) 7(0.6,-2.345) 8(1,-2.345) 9(1.4,-2.345) 10(1.8,-2.345) 21(1.8,2.345) 22(1.4,2.345) 23(1,2.345) 24(0.6,2.345) 25(0.2,2.345) 26(-0.2,2.345) 27(-0.6,2.345) 28(-1,2.345) 29(-1.4,2.345) 30(-1.8,2.345)
  rect 0.61x0.229 smd: 11(2.345,-1.8) 12(2.345,-1.4) 13(2.345,-1) 14(2.345,-0.6) 15(2.345,-0.2) 16(2.345,0.2) 17(2.345,0.6) 18(2.345,1) 19(2.345,1.4) 20(2.345,1.8) 31(-2.345,1.8) 32(-2.345,1.4) 33(-2.345,1) 34(-2.345,0.6) 35(-2.345,0.2) 36(-2.345,-0.2) 37(-2.345,-0.6) 38(-2.345,-1) 39(-2.345,-1.4) 40(-2.345,-1.8)
  rect 3.251x3.251 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.083,1.083) 43(0,1.083) 44(1.083,1.083) 45(-1.083,0) 46(0,0) 47(1.083,0) 48(-1.083,-1.083) 49(0,-1.083) 50(1.083,-1.083)
VX_QFN_40P_16_S197_P_QUA_9V
  rect 0.229x0.559 smd: 1(-1.8,-2.37) 2(-1.4,-2.37) 3(-1,-2.37) 4(-0.6,-2.37) 5(-0.2,-2.37) 6(0.2,-2.37) 7(0.6,-2.37) 8(1,-2.37) 9(1.4,-2.37) 10(1.8,-2.37) 21(1.8,2.37) 22(1.4,2.37) 23(1,2.37) 24(0.6,2.37) 25(0.2,2.37) 26(-0.2,2.37) 27(-0.6,2.37) 28(-1,2.37) 29(-1.4,2.37) 30(-1.8,2.37)
  rect 0.559x0.229 smd: 11(2.37,-1.8) 12(2.37,-1.4) 13(2.37,-1) 14(2.37,-0.6) 15(2.37,-0.2) 16(2.37,0.2) 17(2.37,0.6) 18(2.37,1) 19(2.37,1.4) 20(2.37,1.8) 31(-2.37,1.8) 32(-2.37,1.4) 33(-2.37,1) 34(-2.37,0.6) 35(-2.37,0.2) 36(-2.37,-0.2) 37(-2.37,-0.6) 38(-2.37,-1) 39(-2.37,-1.4) 40(-2.37,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.49,1.49) 43(0,1.49) 44(1.49,1.49) 45(-1.49,0) 46(0,0) 47(1.49,0) 48(-1.49,-1.49) 49(0,-1.49) 50(1.49,-1.49)
VX_QFN_40P_16_S197_P_T01_5V
  rect 0.229x0.61 smd: 1(-1.8,-2.345) 2(-1.4,-2.345) 3(-1,-2.345) 4(-0.6,-2.345) 5(-0.2,-2.345) 6(0.2,-2.345) 7(0.6,-2.345) 8(1,-2.345) 9(1.4,-2.345) 10(1.8,-2.345) 21(1.8,2.345) 22(1.4,2.345) 23(1,2.345) 24(0.6,2.345) 25(0.2,2.345) 26(-0.2,2.345) 27(-0.6,2.345) 28(-1,2.345) 29(-1.4,2.345) 30(-1.8,2.345)
  rect 0.61x0.229 smd: 11(2.345,-1.8) 12(2.345,-1.4) 13(2.345,-1) 14(2.345,-0.6) 15(2.345,-0.2) 16(2.345,0.2) 17(2.345,0.6) 18(2.345,1) 19(2.345,1.4) 20(2.345,1.8) 31(-2.345,1.8) 32(-2.345,1.4) 33(-2.345,1) 34(-2.345,0.6) 35(-2.345,0.2) 36(-2.345,-0.2) 37(-2.345,-0.6) 38(-2.345,-1) 39(-2.345,-1.4) 40(-2.345,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.499,1.499) 43(1.499,1.499) 44(0,0) 45(-1.499,-1.499) 46(1.499,-1.499)
VX_QFN_42P_358X142_P_12V
  rect 0.279x0.61 smd: 1(-4,-1.595) 2(-3.5,-1.595) 3(-3,-1.595) 4(-2.5,-1.595) 5(-2,-1.595) 6(-1.5,-1.595) 7(-1,-1.595) 8(-0.5,-1.595) 9(0,-1.595) 10(0.5,-1.595) 11(1,-1.595) 12(1.5,-1.595) 13(2,-1.595) 14(2.5,-1.595) 15(3,-1.595) 16(3.5,-1.595) 17(4,-1.595) 22(4,1.595) 23(3.5,1.595) 24(3,1.595) 25(2.5,1.595) 26(2,1.595) 27(1.5,1.595) 28(1,1.595) 29(0.5,1.595) 30(0,1.595) 31(-0.5,1.595) 32(-1,1.595) 33(-1.5,1.595) 34(-2,1.595) 35(-2.5,1.595) 36(-3,1.595) 37(-3.5,1.595) 38(-4,1.595)
  rect 0.61x0.279 smd: 18(4.345,-0.75) 19(4.345,-0.25) 20(4.345,0.25) 21(4.345,0.75) 39(-4.345,0.75) 40(-4.345,0.25) 41(-4.345,-0.25) 42(-4.345,-0.75)
  rect 7.645x2.159 smd: 43(0,0)
  round 0.61 hole 0.305: 44(-2.5,-0.4) 45(-1.5,-0.4) 46(-0.5,-0.4) 47(0.5,-0.4) 48(1.5,-0.4) 49(2.5,-0.4) 50(-2.5,0.4) 51(-1.5,0.4) 52(-0.5,0.4) 53(0.5,0.4) 54(1.5,0.4) 55(2.5,0.4)
VX_QFN_48P_16_S236_P_REA_9V
  rect 0.229x0.61 smd: 1(-2.2,-2.845) 2(-1.8,-2.845) 3(-1.4,-2.845) 4(-1,-2.845) 5(-0.6,-2.845) 6(-0.2,-2.845) 7(0.2,-2.845) 8(0.6,-2.845) 9(1,-2.845) 10(1.4,-2.845) 11(1.8,-2.845) 12(2.2,-2.845) 25(2.2,2.845) 26(1.8,2.845) 27(1.4,2.845) 28(1,2.845) 29(0.6,2.845) 30(0.2,2.845) 31(-0.2,2.845) 32(-0.6,2.845) 33(-1,2.845) 34(-1.4,2.845) 35(-1.8,2.845) 36(-2.2,2.845)
  rect 0.61x0.229 smd: 13(2.845,-2.2) 14(2.845,-1.8) 15(2.845,-1.4) 16(2.845,-1) 17(2.845,-0.6) 18(2.845,-0.2) 19(2.845,0.2) 20(2.845,0.6) 21(2.845,1) 22(2.845,1.4) 23(2.845,1.8) 24(2.845,2.2) 37(-2.845,2.2) 38(-2.845,1.8) 39(-2.845,1.4) 40(-2.845,1) 41(-2.845,0.6) 42(-2.845,0.2) 43(-2.845,-0.2) 44(-2.845,-0.6) 45(-2.845,-1) 46(-2.845,-1.4) 47(-2.845,-1.8) 48(-2.845,-2.2)
  rect 4.648x4.648 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1.27,1.27) 51(0,1.27) 52(1.27,1.27) 53(-1.27,0) 54(0,0) 55(1.27,0) 56(-1.27,-1.27) 57(0,-1.27) 58(1.27,-1.27)
VX_QFN_48P_16_S240_PD_5V
  rect 0.229x0.66 smd: 1(-2.2,-2.825) 2(-1.8,-2.825) 3(-1.4,-2.825) 4(-1,-2.825) 5(-0.6,-2.825) 6(-0.2,-2.825) 7(0.2,-2.825) 8(0.6,-2.825) 9(1,-2.825) 10(1.4,-2.825) 11(1.8,-2.825) 12(2.2,-2.825) 25(2.2,2.825) 26(1.8,2.825) 27(1.4,2.825) 28(1,2.825) 29(0.6,2.825) 30(0.2,2.825) 31(-0.2,2.825) 32(-0.6,2.825) 33(-1,2.825) 34(-1.4,2.825) 35(-1.8,2.825) 36(-2.2,2.825)
  rect 0.66x0.229 smd: 13(2.825,-2.2) 14(2.825,-1.8) 15(2.825,-1.4) 16(2.825,-1) 17(2.825,-0.6) 18(2.825,-0.2) 19(2.825,0.2) 20(2.825,0.6) 21(2.825,1) 22(2.825,1.4) 23(2.825,1.8) 24(2.825,2.2) 37(-2.825,2.2) 38(-2.825,1.8) 39(-2.825,1.4) 40(-2.825,1) 41(-2.825,0.6) 42(-2.825,0.2) 43(-2.825,-0.2) 44(-2.825,-0.6) 45(-2.825,-1) 46(-2.825,-1.4) 47(-2.825,-1.8) 48(-2.825,-2.2)
  rect 4.547x4.547 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1.968,1.968) 51(1.968,1.968) 52(0,0) 53(-1.968,-1.968) 54(1.968,-1.968)
VX_QFN_48P_20_S276_PAD_PARA
  rect 0.279x0.61 smd: 1(-2.75,-3.35) 2(-2.25,-3.35) 3(-1.75,-3.35) 4(-1.25,-3.35) 5(-0.75,-3.35) 6(-0.25,-3.35) 7(0.25,-3.35) 8(0.75,-3.35) 9(1.25,-3.35) 10(1.75,-3.35) 11(2.25,-3.35) 12(2.75,-3.35) 25(2.75,3.35) 26(2.25,3.35) 27(1.75,3.35) 28(1.25,3.35) 29(0.75,3.35) 30(0.25,3.35) 31(-0.25,3.35) 32(-0.75,3.35) 33(-1.25,3.35) 34(-1.75,3.35) 35(-2.25,3.35) 36(-2.75,3.35)
  rect 0.61x0.279 smd: 13(3.35,-2.75) 14(3.35,-2.25) 15(3.35,-1.75) 16(3.35,-1.25) 17(3.35,-0.75) 18(3.35,-0.25) 19(3.35,0.25) 20(3.35,0.75) 21(3.35,1.25) 22(3.35,1.75) 23(3.35,2.25) 24(3.35,2.75) 37(-3.35,2.75) 38(-3.35,2.25) 39(-3.35,1.75) 40(-3.35,1.25) 41(-3.35,0.75) 42(-3.35,0.25) 43(-3.35,-0.25) 44(-3.35,-0.75) 45(-3.35,-1.25) 46(-3.35,-1.75) 47(-3.35,-2.25) 48(-3.35,-2.75)
  rect 3.912x3.912 smd: 49(0,0)
VX_QFP_128P_16_630X630
  rect 0.191x1.499 smd: 1(-6.2,-7.86) 2(-5.8,-7.86) 3(-5.4,-7.86) 4(-5,-7.86) 5(-4.6,-7.86) 6(-4.2,-7.86) 7(-3.8,-7.86) 8(-3.4,-7.86) 9(-3,-7.86) 10(-2.6,-7.86) 11(-2.2,-7.86) 12(-1.8,-7.86) 13(-1.4,-7.86) 14(-1,-7.86) 15(-0.6,-7.86) 16(-0.2,-7.86) 17(0.2,-7.86) 18(0.6,-7.86) 19(1,-7.86) 20(1.4,-7.86) 21(1.8,-7.86) 22(2.2,-7.86) 23(2.6,-7.86) 24(3,-7.86) 25(3.4,-7.86) 26(3.8,-7.86) 27(4.2,-7.86) 28(4.6,-7.86) 29(5,-7.86) 30(5.4,-7.86) 31(5.8,-7.86) 32(6.2,-7.86) 65(6.2,7.86) 66(5.8,7.86) 67(5.4,7.86) 68(5,7.86) 69(4.6,7.86) 70(4.2,7.86) 71(3.8,7.86) 72(3.4,7.86) 73(3,7.86) 74(2.6,7.86) 75(2.2,7.86) 76(1.8,7.86) 77(1.4,7.86) 78(1,7.86) 79(0.6,7.86) 80(0.2,7.86) 81(-0.2,7.86) 82(-0.6,7.86) 83(-1,7.86) 84(-1.4,7.86) 85(-1.8,7.86) 86(-2.2,7.86) 87(-2.6,7.86) 88(-3,7.86) 89(-3.4,7.86) 90(-3.8,7.86) 91(-4.2,7.86) 92(-4.6,7.86) 93(-5,7.86) 94(-5.4,7.86) 95(-5.8,7.86) 96(-6.2,7.86)
  rect 1.499x0.191 smd: 33(7.86,-6.2) 34(7.86,-5.8) 35(7.86,-5.4) 36(7.86,-5) 37(7.86,-4.6) 38(7.86,-4.2) 39(7.86,-3.8) 40(7.86,-3.4) 41(7.86,-3) 42(7.86,-2.6) 43(7.86,-2.2) 44(7.86,-1.8) 45(7.86,-1.4) 46(7.86,-1) 47(7.86,-0.6) 48(7.86,-0.2) 49(7.86,0.2) 50(7.86,0.6) 51(7.86,1) 52(7.86,1.4) 53(7.86,1.8) 54(7.86,2.2) 55(7.86,2.6) 56(7.86,3) 57(7.86,3.4) 58(7.86,3.8) 59(7.86,4.2) 60(7.86,4.6) 61(7.86,5) 62(7.86,5.4) 63(7.86,5.8) 64(7.86,6.2) 97(-7.86,6.2) 98(-7.86,5.8) 99(-7.86,5.4) 100(-7.86,5) 101(-7.86,4.6) 102(-7.86,4.2) 103(-7.86,3.8) 104(-7.86,3.4) 105(-7.86,3) 106(-7.86,2.6) 107(-7.86,2.2) 108(-7.86,1.8) 109(-7.86,1.4) 110(-7.86,1) 111(-7.86,0.6) 112(-7.86,0.2) 113(-7.86,-0.2) 114(-7.86,-0.6) 115(-7.86,-1) 116(-7.86,-1.4) 117(-7.86,-1.8) 118(-7.86,-2.2) 119(-7.86,-2.6) 120(-7.86,-3) 121(-7.86,-3.4) 122(-7.86,-3.8) 123(-7.86,-4.2) 124(-7.86,-4.6) 125(-7.86,-5) 126(-7.86,-5.4) 127(-7.86,-5.8) 128(-7.86,-6.2)
VX_R0201_H10
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
VX_R0402_0OHM_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_H14_SMALL_T01
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_H24_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_H24_SMALL_T02XT01
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0402_SMALL_SHORT
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
VX_R0402_SMALL_T01
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0603_0OHM_H28_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_H22_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_H24_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_H28_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0603_SMALL_SHORT
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
VX_R0612_4P_H31
  rect 2.311x0.991 smd: 1(1.22,-0.875) 4(1.22,0.875)
  rect 0.787x0.991 smd: 2(-0.72,-0.875) 3(-0.72,0.875)
VX_R0805_0OHM_H24_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_R0805_H24_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_R0805_SMALL_T01
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_R1206_H26
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_R1206_H28
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_R1206_H31
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
VX_R2512_H35_YAGEO
  rect 1.499x3.2 smd: 1(-2.874,0) 2(2.874,0)
VX_SC70_S5_TI
  rect 0.94x0.356 smd: 1(1.189,-0.65) 2(1.189,0) 3(1.189,0.65) 4(-1.189,0.65) 5(-1.189,-0.65)
VX_SC70_S6
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
VX_SI7501DN_H44
  rect 0.406x0.991 smd: 1(-0.99,-1.435) 2(-0.33,-1.435) 3(0.33,-1.435) 4(0.99,-1.435)
  custom 0.559x0.559 smd: 5(0,0)
VX_SI7850DP
  rect 0.61x1.27 smd: 1(-1.905,-1.68) 2(-0.635,-1.68) 3(0.635,-1.68) 4(1.905,-1.68)
  custom 1.105x1.105 smd: 5(0,1.68)
VX_SOD323_H35
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
VX_SOD323_H37
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
VX_SOD323_H39
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
VX_SOIC_8P_26_122X193_H48
  rect 0.356x1.448 smd: 1(-0.975,-2.335) 2(-0.325,-2.335) 3(0.325,-2.335) 4(0.975,-2.335) 5(0.975,2.335) 6(0.325,2.335) 7(-0.325,2.335) 8(-0.975,2.335)
VX_SOIC_8P_50_193X156T02X01
  rect 0.61x1.549 smd: 1(-1.905,-2.83) 2(-0.635,-2.83) 3(0.635,-2.83) 4(1.905,-2.83) 5(1.905,2.83) 6(0.635,2.83) 7(-0.635,2.83) 8(-1.905,2.83)
VX_SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.858) 6(0.635,2.858) 7(-0.635,2.858) 8(-1.905,2.858)
VX_SOIC_8P_50_197X236_COLAY
  rect 0.66x1.562 smd: 1(-1.905,-2.839) 2(-0.635,-2.839) 3(0.635,-2.839) 4(1.905,-2.839) 5(1.905,2.839) 6(0.635,2.839) 7(-0.635,2.839) 8(-1.905,2.839)
VX_SOIC_8P_50_211X311_H85
  rect 0.61x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
VX_SOIC_8P_50_213X311
  rect 0.635x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
VX_SOIC_28P_26_386X252
  rect 0.356x1.499 smd: 1(-4.225,-3.06) 2(-3.575,-3.06) 3(-2.925,-3.06) 4(-2.275,-3.06) 5(-1.625,-3.06) 6(-0.975,-3.06) 7(-0.325,-3.06) 8(0.325,-3.06) 9(0.975,-3.06) 10(1.625,-3.06) 11(2.275,-3.06) 12(2.925,-3.06) 13(3.575,-3.06) 14(4.225,-3.06) 15(4.225,3.06) 16(3.575,3.06) 17(2.925,3.06) 18(2.275,3.06) 19(1.625,3.06) 20(0.975,3.06) 21(0.325,3.06) 22(-0.325,3.06) 23(-0.975,3.06) 24(-1.625,3.06) 25(-2.275,3.06) 26(-2.925,3.06) 27(-3.575,3.06) 28(-4.225,3.06)
VX_SON_14P_16_118X79_PAD
  rect 0.203x0.762 smd: 1(-1.2,-1.025) 2(-0.8,-1.025) 3(-0.4,-1.025) 4(0,-1.025) 5(0.4,-1.025) 6(0.8,-1.025) 7(1.2,-1.025) 8(1.2,1.025) 9(0.8,1.025) 10(0.4,1.025) 11(0,1.025) 12(-0.4,1.025) 13(-0.8,1.025) 14(-1.2,1.025)
  rect 2.591x0.864 smd: 15(0,0)
VX_SOT23_2D4_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_2D4_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_2D4_H47
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_2D4_T01_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
VX_SOT23_H43
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_H44
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_H49
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
VX_SOT23_S5
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
VX_SOT23_S5_2D4_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
VX_SOT23_S5_2D4_T02_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
VX_SOT23_S5_H57
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
VX_SOT23_S5_SC70_RD4
  rect 0.762x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
VX_SOT23_S6_FITI_H57
  rect 0.61x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
VX_SOT25_DI
  rect 0.61x1.143 smd: 1(-0.95,-1.45) 2(0,-1.45) 3(0.95,-1.45) 4(0.95,1.45) 5(-0.95,1.45)
VX_SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
VX_SOT353
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 6(-0.65,0.95)
VX_SOT353_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(-0.65,1.19)
VX_SOT363_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
VX_SW_4P_146_S205_2HOLD_H63
  rect 0.61x0.991 smd: 1(-1.85,-2.2) 2(-1.85,2.2) 3(1.85,-2.2) 4(1.85,2.2)
  rect 0.457x0.991 smd: 5(-2.525,0) 6(2.525,0)
VX_SW_4P_185X185
  rect 1.194x0.787 smd: 1(-1.2,2.15) 2(1.2,2.15) 3(-1.2,-2.15) 4(1.2,-2.15)
VX_TRANS_24P_39_595X394_BO
  rect 0.584x1.956 smd: 1(-5.5,-4.632) 2(-4.5,-4.632) 3(-3.5,-4.632) 4(-2.5,-4.632) 5(-1.5,-4.632) 6(-0.5,-4.632) 7(0.5,-4.632) 8(1.5,-4.632) 9(2.5,-4.632) 10(3.5,-4.632) 11(4.5,-4.632) 12(5.5,-4.632) 13(5.5,4.632) 14(4.5,4.632) 15(3.5,4.632) 16(2.5,4.632) 17(1.5,4.632) 18(0.5,4.632) 19(-0.5,4.632) 20(-1.5,4.632) 21(-2.5,4.632) 22(-3.5,4.632) 23(-4.5,4.632) 24(-5.5,4.632)
VX_USB_9P_4HOLD_RA_SINGA
  rect 0.991x0.991 hole 0.737: 1(-3.5,-0.6)
  round 0.991 hole 0.737: 2(-1,-0.6) 3(1,-0.6) 4(3.5,-0.6)
  round 1.143 hole 0.737: 5(4,0.9) 6(2,0.9) 7(0,0.9) 8(-2,0.9) 9(-4,0.9)
  oval 0.813x2.21 hole 0.559x1.956: 10(-6.4,0) 11(6.4,0)
  oval 0.965x2.972 hole 0.559x2.565: 12(-7.85,-6.6) 13(7.85,-6.6)
VX_USB_24P_10HD_RA_ACON
  round 0.762 hole 0.762 unplated: (-3.6,0) (3.6,0)
  rect 0.508x0.406 smd: 1(-1.25,1.55) 2(1.25,1.55)
  oval 1.219x0.864 hole 0.813x0.457: 3(-3.845,1.55) 4(3.845,1.55)
  oval 1.016x1.6 hole 0.61x1.194: 7(-4.22,-1.25) 8(4.22,-1.25)
  oval 0.864x1.854 hole 0.457x1.448: 9(-4.5,-3.77) 10(4.5,-3.77)
  rect 0.305x0.889 smd: A1(-2.75,0.57) A2(-2.25,0.57) A3(-1.75,0.57) A4(-1.25,0.57) A5(-0.75,0.57) A6(-0.25,0.57) A7(0.25,0.57) A8(0.75,0.57) A9(1.25,0.57) A10(1.75,0.57) A11(2.25,0.57) A12(2.75,0.57)
  round 0.699 hole 0.406: B1(2.8,-0.65) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.2,-0.65) B5(0.8,-1.35) B6(0.4,-0.65) B7(-0.4,-0.65) B8(-0.8,-1.35) B9(-1.2,-0.65) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.65)
VX_WTOB_2P_49_2HOLD_ACE
  rect 0.787x1.6 smd: 1(0.625,2.9) 2(-0.625,2.9)
  rect 2.108x2.997 smd: 3(3.175,0) 4(-3.175,0)
VX_WTOB_3P_49_2H_RA_ACE
  rect 0.787x1.905 smd: 1(1.25,4.925) 2(0,4.925) 3(-1.25,4.925)
  rect 1.295x3.353 smd: 4(4.1,0) 5(-4.1,0)
VX_WTOB_4P_39_2H_ACES
  rect 0.61x1.549 smd: 1(1.5,2.525) 2(0.5,2.525) 3(-0.5,2.525) 4(-1.5,2.525)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
VX_WTOB_4P_49_2HD_ACE
  rect 0.787x1.6 smd: 1(1.875,2.9) 2(0.625,2.9) 3(-0.625,2.9) 4(-1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
