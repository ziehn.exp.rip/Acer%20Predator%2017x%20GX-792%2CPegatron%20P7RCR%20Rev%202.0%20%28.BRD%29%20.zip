# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D<27>: length 36.6
  IN1 w0.075: 169.15,138.04 169.15,138.62 169.46,138.93 v5(170.12,138.93)
  IN1 w0.127: 169.15,138.04 168.87,137.76 166.77,137.76 166.38,137.38 166.38,135.62 165.92,133.89 165.87,133.71 165.37,132.37 165.01,132.01 164.76,131.15 164.76,126.49 163.9,125.63 163.9,124.16 163.51,123.77 163.51,112.63 164.35,111.79 164.35,110.8 164.04,110.49 164.04,108.93 v5(164.38,108.58)
  BOTTOM w0.1: U7600.C3 169.47,138.93 v5(170.12,138.93)
  BOTTOM w0.184: v5(164.38,108.58) 164.38,108.58 U7000.AC47
FBA_D<28>: length 31.8
  IN1 w0.102: 165.46,110.55 165.46,108.21 v5(165.15,107.9)
  IN1 w0.127: 165.46,110.55 165.11,110.9 165.11,112.08 164.05,113.14 164.05,123.31 164.69,123.95 164.69,125.55 165.37,126.23 165.37,130.9 166.43,133.89 166.78,134.87 166.87,135.57 arc(166.88,135.61) 166.9,135.64 v5(167.4,136.14)
  BOTTOM w0.1: U7600.F4 168.17,136.33 167.59,136.33 v5(167.4,136.14)
  BOTTOM w0.184: v5(165.15,107.9) 165.15,107.9 165.16,107.91 165.16,107.96 U7000.AA47
FBA_D<29>: length 32.8
  IN1 w0.102: 165.79,107.85 165.79,108.86
  IN1 w0.127: v5(168.82,136.98) 168.84,136.96 168.84,136.91 167.8,135.88 167.59,135.3 167.13,134.32 166.97,133.89 166.21,131.82 165.96,130.64 165.96,126.02 165.61,125.67 165.61,123.7 164.59,122.68 164.59,113.81 165.79,112.61 165.79,108.86 ; v5(165.13,107.2) 165.79,107.85
  BOTTOM w0.184: U7600.F3 169.15,136.65 v5(168.82,136.98) ; v5(165.13,107.2) 165.13,107.23 U7000.AA46
FBA_D<30>: length 32.3
  IN1 w0.102: 166.1,107.48 166.1,108.87
  IN1 w0.127: v5(168.82,135.68) 167.91,134.76 167.51,133.89 167.32,133.49 166.55,131.05 166.55,125.49 166.3,125.25 166.3,123.16 165.32,122.18 165.32,114.09 166.5,112.91 166.5,110.8 166.25,110.55 166.25,109.02 166.1,108.87 ; v5(165.14,106.52) 166.1,107.48
  BOTTOM w0.17: v5(168.82,135.68) U7600.G4
  BOTTOM w0.184: v5(165.14,106.52) 165.14,106.54 U7000.AA45
FBA_D<31>: length 36.7
  IN1 w0.127: v5(166.5,105.85) 166.83,105.52 167.28,105.52 167.75,105.99 167.75,111.32 167.14,111.93 167.14,113.64 166.03,114.75 166.03,121.76 167.13,122.86 167.13,131.16 167.76,133.26 168.01,133.51 168.17,133.89 168.48,134.63 169.09,135.24 170.26,135.24 170.52,135.5 170.52,135.93 v5(170.12,136.33)
  BOTTOM w0.1: U7600.G3 169.47,136.33 v5(170.12,136.33)
  BOTTOM w0.17: v5(166.5,105.85) 166.45,105.85 U7000.Y44
FBA_D<32>: length 22.5
  IN4 w0.127: v5(144.32,127.2) 144.32,120.67 150.13,114.86 150.13,114.17 150.83,113.47 151.54,113.47 151.86,113.15 151.86,112.93 152.2,112.58 152.65,112.58 152.93,112.31 152.93,111.78 v5(152.53,111.38)
  BOTTOM w0.1: U7601.B4 144.32,128.53 v5(144.32,127.2)
  BOTTOM w0.184: v5(152.53,111.38) 152.53,111.36 U7000.AW51
FBA_D<33>: length 23
  IN4 w0.127: v5(151.85,112.15) 151.37,112.64 150.6,112.64 150.16,113.08 149.76,113.08 148.59,114.26 144.82,118.02 144.82,119.19 142.58,121.44 142.58,126.7 143.31,127.43 143.77,127.43 144.04,127.7 144.04,128.16 v5(143.67,128.53)
  BOTTOM w0.17: U7601.B3 v5(143.67,128.53)
  BOTTOM w0.184: U7000.BA52 v5(151.85,112.15)
FBA_D<34>: length 23.5
  IN4 w0.127: v5(144.97,128.53) 145.35,128.15 145.35,121.01 151.6,114.75 151.6,114.55 151.67,114.48 151.67,113.95 152.62,113 152.99,113 153.31,112.68 153.31,111.34 152.63,110.66 v5(152.51,110.66)
  BOTTOM w0.1: U7601.C4 144.65,129.5 144.97,129.18 v5(144.97,128.53)
  BOTTOM w0.184: v5(152.51,110.66) 152.54,110.66 U7000.AW50
FBA_D<35>: length 26
  IN4 w0.075: 142.82,129.5 U7601.C3 144.32,129.18 v5(144.32,129.18)
  IN4 w0.127: v5(151.76,111.39) 151.39,111.75 150.62,111.75 149.7,112.67 149.07,112.67 144.35,117.39 144.35,119 141.8,121.55 141.8,126.72 142.63,127.55 142.63,129.31 142.82,129.5
  BOTTOM w0.17: U7601.C3 144.32,129.18 v5(144.32,129.18)
  BOTTOM w0.184: U7000.BA51 151.76,111.36 v5(151.76,111.39)
FBA_D<36>: length 31.7
  IN4 w0.075: 142.41,131.87 142.64,132.1 143.35,132.1
  IN4 w0.102: 150.75,110.4 150.17,110.4
  IN4 w0.127: v5(151.11,110.04) 150.75,110.4 ; 142.41,131.87 142.26,131.72 141.35,131.72 140.34,130.72 140.34,121.68 143.41,118.61 143.41,116.18 149.2,110.4 150.17,110.4 ; v5(144.32,131.78) 143.67,131.78 143.35,132.1
  BOTTOM w0.17: U7601.F4 144.39,131.71 144.38,131.71 v5(144.32,131.78)
  BOTTOM w0.184: v5(151.11,110.04) 151.14,110.04 U7000.BA50
FBA_D<37>: length 27.9
  IN4 w0.127: v5(143.02,131.78) 142.67,131.42 142.67,131.32 142.11,130.77 141.71,130.77 141.05,130.11 141.05,121.64 143.88,118.8 143.88,116.78 149.91,110.75 v5(150.4,110.75)
  BOTTOM w0.1: v5(143.02,131.78) 143.67,131.78 U7601.F3
  BOTTOM w0.184: v5(150.4,110.75) 150.4,110.75 150.4,110.69 U7000.BB50
FBA_D<38>: length 38.2
  IN4 w0.127: v5(151.1,109.28) 150.7,108.88 148.88,108.88 142.47,115.29 142.47,118.22 139,121.69 139,131.67 140.91,133.58 142.24,133.58 142.58,133.92 144.3,133.92 144.46,133.76 144.46,132.94 v5(144.97,132.43)
  BOTTOM w0.17: v5(144.97,132.43) 144.65,132.1 U7601.G4
  BOTTOM w0.184: v5(151.1,109.28) 151.1,109.3 U7000.BA49
FBA_D<39>: length 34.5
  IN4 w0.075: 142.48,132.54 142.69,132.76 143.34,132.76 v5(143.67,132.43)
  IN4 w0.127: v5(152.55,109.3) 152.08,109.3 151.71,109.67 150.06,109.67 149.93,109.8 148.87,109.8 142.94,115.72 142.94,118.41 139.87,121.49 139.87,131.05 141.36,132.54 142.48,132.54
  BOTTOM w0.17: v5(143.67,132.43) 143.67,132.42 U7601.G3
  BOTTOM w0.184: v5(152.55,109.3) 152.55,109.37 152.83,109.65 U7000.AW49
FBA_D<40>: length 22.8
  IN1 w0.127: v5(149.68,127.72) 149.68,127.46 149.25,127.02 149.25,126.86 148.7,126.32 148.7,118.49 152.36,114.82 152.36,114.29 152.48,114.17 152.48,113.8 153.39,112.89 153.39,109.76 v5(153.86,109.29)
  BOTTOM w0.1: v5(149.68,127.72) 149.53,127.87 149.53,128.52 U7601.B11
  BOTTOM w0.184: v5(153.86,109.29) 153.86,109.26 U7000.AV48
FBA_D<41>: length 21.3
  IN1 w0.127: v5(154.61,109.98) 154.65,110.02 154.65,111.75 154.3,112.09 154.3,114.18 154.3,114.59 150.59,118.31 v5(150.59,126.83)
  BOTTOM w0.1: U7601.B12 150.17,128.53 150.17,127.25 v5(150.59,126.83)
  BOTTOM w0.184: U7000.AT49 v5(154.61,109.98)
FBA_D<42>: length 26.4
  IN1 w0.127: v5(149.52,129.18) 149.74,129.39 150.32,129.39 150.54,129.61 150.97,129.61 151.24,129.34 151.24,118.62 155.14,114.72 155.14,112.74 155.33,112.55 155.33,108.57 v5(154.65,107.9)
  BOTTOM w0.17: U7601.C11 v5(149.52,129.18)
  BOTTOM w0.184: v5(154.65,107.9) 154.66,107.9 154.66,107.96 U7000.AT47
FBA_D<43>: length 24.5
  IN1 w0.127: v5(154.65,109.29) 154.3,109.64 153.98,109.64 153.74,109.88 153.74,110.33 153.85,110.44 153.85,114.23 149.36,118.72 149.36,125.91 150.2,126.75 150.2,128.56 v5(150.82,129.18)
  BOTTOM w0.1: v5(150.82,129.18) 150.17,129.18 U7601.C12
  BOTTOM w0.184: U7000.AT48 154.65,109.25 v5(154.65,109.29)
FBA_D<44>: length 29.5
  IN1 w0.075: v5(149.52,131.13) 149.19,130.8 148.55,130.8 148.43,130.68
  IN1 w0.127: 148.43,130.68 148.23,130.47 148.23,118.06 151.54,114.76 151.54,114.58 151.67,114.45 151.67,113.94 151.96,113.66 151.96,113.29 152.96,112.29 152.96,107.54 153.64,106.85 154.25,106.85 v5(154.61,107.22)
  BOTTOM w0.17: U7601.F11 149.52,131.13 v5(149.52,131.13)
  BOTTOM w0.184: U7000.AT46 154.65,107.25 154.65,107.24 154.62,107.22 v5(154.61,107.22)
FBA_D<45>: length 28.3
  IN1 w0.075: 148.61,131.45 U7601.F12
  IN1 w0.127: U7601.F12 150.17,131.13 v5(150.82,131.13) ; v5(151.25,113.95) 151.2,113.9 150.39,113.9 150,114.29 150,115.43 147.51,117.91 147.51,130.42 148.54,131.45 148.61,131.45
  BOTTOM w0.1: v5(150.82,131.13) 150.17,131.13 U7601.F12
  BOTTOM w0.102: v5(151.25,113.95) 151.37,113.95 151.91,113.41 152.81,113.41 153.9,112.32 153.9,111.55 153.55,111.2 U7000.AV51
FBA_D<46>: length 30.2
  IN1 w0.127: v5(151.49,112.99) 151.14,112.64 150.77,112.64 150.71,112.69 149.45,112.69 145.9,116.24 145.9,127.7 146.3,128.1 146.3,131.8 147.61,133.11 148.12,133.11 149.35,132.6 149.52,132.43 v5(149.52,132.43)
  BOTTOM w0.102: v5(151.49,112.99) 151.54,113.04 152.66,113.04 153.55,112.15 U7000.AV52
  BOTTOM w0.17: v5(149.52,132.43) 149.52,132.43 U7601.G11
FBA_D<47>: length 30.3
  IN1 w0.075: v5(150.17,131.78) 150.17,131.78 U7601.G12 149.33,132.1
  IN1 w0.127: 149.33,132.1 149.29,132.06 149.1,132.06 148.94,132.22 148.01,132.22 146.96,131.17 146.96,127.65 146.59,127.28 146.59,116.72 148.95,114.37 148.95,113.95 149.42,113.47 v5(150.06,113.47)
  BOTTOM w0.102: U7000.AV49 153.2,110 153.2,111.95 152.6,112.55 150.84,112.55 150.06,113.33 v5(150.06,113.47)
  BOTTOM w0.17: U7601.G12 150.17,131.78 v5(150.17,131.78)
FBA_D<48>: length 42.2
  IN1 w0.102: 159.93,110.33 159.93,109.58 v5(160.2,109.3)
  IN1 w0.127: 159.93,110.33 160.03,110.43 160.03,116.05 159.42,116.67 158.58,117.5 158.58,136.9 154.29,141.18 149.76,141.18 149.37,140.79 148.96,140.79 148.72,140.55 148.72,139.73 v5(148.87,139.58)
  BOTTOM w0.17: U7000.AJ48 v5(160.2,109.3) ; v5(148.87,139.58) U7601.V11
FBA_D<49>: length 39.2
  IN1 w0.102: 158.9,111.38 159.35,110.93 159.35,108.75
  IN1 w0.127: v5(150.17,139.58) 150.55,139.96 151.93,139.96 152.38,139.5 153.79,139.5 156.88,136.41 156.88,117.59 158.9,115.57 158.9,111.38 ; v5(160.18,107.92) 159.35,108.75
  BOTTOM w0.17: v5(150.17,139.58) U7601.V12
  BOTTOM w0.184: v5(160.18,107.92) 160.18,107.88 U7000.AJ46
FBA_D<50>: length 42.3
  IN1 w0.075: v5(148.87,138.28) U7601.U11 149.2,139.74 149.21,139.75
  IN1 w0.127: 149.21,139.75 149.21,139.85 149.59,140.23 149.59,140.35 149.96,140.71 152.07,140.71 152.37,140.41 153.89,140.41 157.59,136.71 157.59,117.55 159.43,115.71 159.43,111.6 159.64,111.39 159.64,109.11 v5(160.16,108.59)
  BOTTOM w0.17: U7601.U11 149.05,138.46 v5(148.87,138.28)
  BOTTOM w0.184: U7000.AJ47 160.16,108.56 v5(160.16,108.59)
FBA_D<51>: length 36.1
  IN1 w0.075: 151,138.6 U7601.U12 v5(149.52,138.93)
  IN1 w0.127: 151,138.6 151.03,138.63 153.51,138.63 156.17,135.97 156.17,117.64 158.35,115.47 158.35,111.4 159.08,110.67 159.08,110.23 v5(158.85,110)
  BOTTOM w0.17: v5(149.52,138.93) U7601.U12
  BOTTOM w0.184: U7000.AK49 158.85,109.95 v5(158.85,110)
FBA_D<52>: length 37
  IN1 w0.075: v5(148.87,136.98) 148.88,136.99 148.9,136.99 149.22,137.3 149.67,137.3 149.85,137.48 149.85,137.77 150.02,137.95 150.5,137.95
  IN1 w0.127: 150.5,137.95 150.59,137.86 152.76,137.86 155.54,135.09 155.54,117.61 157.86,115.28 157.86,111.16 157.72,111.01 157.72,108.93 v5(158.07,108.58)
  BOTTOM w0.17: U7000.AM47 158.07,108.57 v5(158.07,108.58) ; v5(148.87,136.98) U7601.P11
FBA_D<53>: length 35.2
  IN1 w0.127: v5(158.05,107.9) 157.16,108.79 157.16,111.1 157.31,111.26 157.31,115.17 154.88,117.6 154.88,134.72 152.87,136.73 151.73,136.73 151.09,137.37 150.56,137.37 v5(150.17,136.98)
  BOTTOM w0.17: v5(150.17,136.98) 149.85,136.65 U7601.P12
  BOTTOM w0.184: U7000.AM46 158.05,107.85 v5(158.05,107.9)
FBA_D<54>: length 32.4
  IN1 w0.127: v5(156.72,109.33) 156.38,109.66 155.91,109.66 155.71,109.86 155.71,110.64 156.21,111.14 156.21,114.94 153.52,117.64 153.52,132.93 151.67,134.78 149.77,134.78 v5(148.87,135.68)
  BOTTOM w0.17: U7601.N11 149.19,136 v5(148.87,135.68)
  BOTTOM w0.184: U7000.AN48 156.72,109.28 v5(156.72,109.33)
FBA_D<55>: length 30.6
  IN1 w0.127: v5(150.17,135.68) 150.58,135.27 152.73,135.27 154.22,133.78 154.22,117.6 156.67,115.15 156.67,110.19 v5(156.62,110.14)
  BOTTOM w0.17: v5(150.17,135.68) U7601.N12
  BOTTOM w0.184: U7000.AN49 156.62,110.08 v5(156.62,110.14)
FBA_D<56>: length 42.8
  IN4 w0.102: v5(158.1,105.8) 157.42,106.48 157.42,108.04 157.5,108.13 157.5,111.08
  IN4 w0.127: 157.5,111.08 157.34,111.25 157.34,115.18 151.26,121.26 151.26,134.63 150.63,135.25 148.04,135.25 147.83,135.47 147.83,138.21 146.6,139.44 146.02,139.44 145.85,139.28 145.27,139.28 v5(144.97,139.58)
  BOTTOM w0.17: v5(144.97,139.58) U7601.V4
  BOTTOM w0.184: U7000.AM44 v5(158.1,105.8)
FBA_D<57>: length 45.4
  IN4 w0.102: 157.67,106.88 157.67,107.99 157.71,108.03 157.71,110.77 157.77,110.82
  IN4 w0.127: 157.77,110.82 157.77,115.41 152.14,121.04 152.14,139.51 151.7,139.96 146.93,139.96 146.86,140.02 144.68,140.02 144.62,139.96 144.05,139.96 v5(143.67,139.58) ; v5(158.05,106.5) 157.67,106.88
  BOTTOM w0.17: v5(143.67,139.58) 143.68,139.57 U7601.V3
  BOTTOM w0.184: v5(158.05,106.5) 158.05,106.55 U7000.AM45
FBA_D<58>: length 40.1
  IN4 w0.075: 149.85,129.62 149.85,132.81
  IN4 w0.102: 157.2,110.88 157.28,110.8 157.28,108.21 157.14,108.07 157.14,106.92
  IN4 w0.127: 149.85,132.81 149.55,133.11 148.93,133.11 148.47,133.56 148.47,134.51 148.24,134.74 147.85,134.74 147.36,135.23 147.36,137.36 146.11,138.61 v5(146.11,139.01) ; v5(156.75,106.5) 156.75,106.52 156.78,106.55 156.78,106.56 157.14,106.92 ; 157.2,110.88 156.89,111.19 156.89,114.96 150.2,121.66 150.2,129.27 149.85,129.62
  BOTTOM w0.1: U7601.U4 144.97,138.93 146.03,138.93 v5(146.11,139.01)
  BOTTOM w0.184: v5(156.75,106.5) 156.75,106.55 U7000.AN45
FBA_D<59>: length 43.3
  IN4 w0.075: 142.79,138.61 144,138.61 v5(144.32,138.93)
  IN4 w0.102: 155.75,106.85 155.75,106.86 156.4,106.86
  IN4 w0.127: 142.79,138.61 142.63,138.45 142.63,135.23 143.06,134.8 144.45,134.8 145,134.25 145,133.65 145.93,132.72 145.99,132.55 145.99,121.21 152.36,114.84 152.36,114.62 152.46,114.52 152.46,114.03 153.72,112.76 153.72,109.95 153.33,109.56 153.33,107.24 153.72,106.85 155.75,106.85 ; v5(156.72,107.17) 156.4,106.86
  BOTTOM w0.17: U7601.U3 v5(144.32,138.93)
  BOTTOM w0.184: U7000.AN46 156.71,107.21 156.71,107.18 v5(156.72,107.17)
FBA_D<60>: length 32.9
  IN4 w0.127: v5(155.96,109.29) 155.73,109.52 155.73,112.07 155.1,112.7 155.1,115.22 147.8,122.52 147.8,132.05 147.11,133.77 146.41,134.47 146.41,135.79 v5(145.92,136.28)
  BOTTOM w0.1: U7601.P4 144.97,136.33 145.87,136.33 v5(145.92,136.28)
  BOTTOM w0.184: v5(155.96,109.29) 155.96,109.26 U7000.AR48
FBA_D<61>: length 37.1
  IN4 w0.075: 144.57,136.65 U7601.P3 v5(143.67,136.98)
  IN4 w0.102: 156.98,110.55 156.98,109.81 157.08,109.71 157.08,108.39 156.84,108.15
  IN4 w0.127: v5(156.75,107.9) 156.75,108.06 156.84,108.15 ; 144.57,136.65 146.3,136.65 146.89,136.07 146.89,134.89 147.54,134.04 147.71,133.6 148.55,132.76 148.55,132.32 148.43,132.2 148.43,122.76 156.33,114.86 156.33,111.21 156.98,110.55
  BOTTOM w0.17: U7601.P3 143.74,136.91 143.74,136.91 143.68,136.97 143.68,136.97 v5(143.67,136.98)
  BOTTOM w0.184: v5(156.75,107.9) 156.75,107.95 U7000.AN47
FBA_D<62>: length 32.7
  IN4 w0.127: v5(144.97,135.68) 145.94,134.71 145.94,134.24 146.72,133.46 147.22,131.93 147.22,122.13 154.29,115.06 154.29,113.76 154.52,113.53 154.52,111.9 155.39,111.03 155.39,108.87 155.67,108.59 v5(155.99,108.59)
  BOTTOM w0.17: v5(144.97,135.68) 144.65,136 U7601.N4
  BOTTOM w0.184: v5(155.99,108.59) 155.86,108.59 155.65,108.38 U7000.AR47
FBA_D<63>: length 34.1
  IN4 w0.127: v5(155.96,107.9) 155.86,107.9 155.06,108.7 155.06,110.61 154.12,111.55 154.12,113.22 153.82,113.52 153.82,114.48 146.6,121.7 146.6,132.23 146.35,133.03 145.47,133.91 145.47,134.45 144.64,135.28 144.06,135.28 v5(143.67,135.68)
  BOTTOM w0.17: v5(143.67,135.68) U7601.N3
  BOTTOM w0.184: U7000.AR46 155.96,107.86 155.96,107.9 v5(155.96,107.9)
FBA_DBI<0>: length 25.1
  IN2 w0.075: 169.15,128.93 169.15,129.57
  IN2 w0.127: v5(169.47,130.48) 169.47,129.89 169.15,129.57 ; 169.15,128.93 169.4,128.68 169.4,127.54 166.8,124.94 166.8,118.82 168.42,117.19 168.42,110.49 168.19,110.26 168.19,108.99 v5(168.59,108.59)
  BOTTOM w0.17: U7600.R3 v5(169.47,130.48)
  BOTTOM w0.184: U7000.U47 v5(168.59,108.59)
FBA_DBI<1>: length 23.8
  IN2 w0.075: v5(163.62,130.48) 163.95,130.15 164.52,130.15 164.75,129.93
  IN2 w0.127: 164.75,129.93 164.75,117.74 165.94,116.54 165.94,112.19 166.52,111.61 166.52,110.24 v5(166.63,110.13)
  BOTTOM w0.102: U7000.Y48 166.15,109.19 166.48,109.52 166.48,109.98 v5(166.63,110.13)
  BOTTOM w0.17: U7600.R12 v5(163.62,130.48)
FBA_DBI<2>: length 38.4
  IN2 w0.075: 162.72,138.67 162.65,138.6 162.1,138.6
  IN2 w0.127: 162.1,138.6 162.06,138.56 161.32,138.56 160.99,138.23 159.7,138.23 157.2,135.74 157.2,118.81 160.59,115.42 160.59,111.03 161.32,110.3 161.32,108.96 v5(160.95,108.6) ; v5(163.62,138.28) 163.24,138.67 162.72,138.67
  BOTTOM w0.1: U7600.E12 163.62,137.63 v5(163.62,138.28)
  BOTTOM w0.184: U7000.AG47 160.96,108.54 160.96,108.6 v5(160.95,108.6)
FBA_DBI<3>: length 38.9
  IN2 w0.127: v5(166.84,137.23) 166.5,136.89 166.5,135.5 165.82,134.82 161.44,134.82 160.89,134.27 160.13,134.27 159.76,133.91 159.76,119.75 163.82,115.7 163.82,111.26 164.41,110.67 v5(164.41,110.01)
  BOTTOM w0.1: U7600.E3 168.82,137.63 167.25,137.63 v5(166.84,137.23)
  BOTTOM w0.102: v5(164.41,110.01) 164.41,109.55 164.05,109.19 U7000.AC48
FBA_DBI<4>: length 27
  IN2 w0.075: v5(143.67,131.13) 143.35,130.8 142.77,130.8
  IN2 w0.127: v5(151.09,111.39) 150.83,111.13 149.92,111.13 141.85,119.2 141.85,130.48 142.19,130.82 142.75,130.82 142.77,130.8
  BOTTOM w0.17: U7601.E3 143.76,131.04 143.75,131.04 v5(143.67,131.13)
  BOTTOM w0.184: U7000.BB51 v5(151.09,111.39)
FBA_DBI<5>: length 26
  IN2 w0.075: v5(149.52,130.48) 149.19,130.8 148.58,130.8
  IN2 w0.127: v5(152.04,114.1) 151.58,114.56 151.58,115.2 147.35,119.42 147.35,129.57 148.58,130.8
  BOTTOM w0.102: U7000.AV50 153.9,110.7 153.9,111.2 154.11,111.41 154.11,112.83 153.15,113.78 152.35,113.78 v5(152.04,114.1)
  BOTTOM w0.17: U7601.E12 149.52,130.48 v5(149.52,130.48)
FBA_DBI<6>: length 34.3
  IN2 w0.075: v5(149.52,137.63) 149.85,137.3 150.42,137.3 150.48,137.36
  IN2 w0.114: 151.34,137.01 150.99,137.36 150.48,137.36
  IN2 w0.127: v5(158.09,109.97) 157.81,110.25 157.81,115.58 154.97,118.41 154.97,134.56 152.52,137.01 151.34,137.01
  BOTTOM w0.102: U7000.AM48 157.75,109.18 158.09,109.52 v5(158.09,109.97)
  BOTTOM w0.17: v5(149.52,137.63) U7601.R12
FBA_DBI<7>: length 37.3
  IN2 w0.075: 145.34,135.32 145.34,136.02
  IN2 w0.127: 145.34,135.32 147.35,133.31 152.08,133.31 152.43,133.66 153.03,133.66 153.22,133.47 153.22,117.48 155.07,115.63 155.07,114.37 v5(154.68,113.98) ; v5(144.32,137.63) 145.34,136.61 145.34,136.02
  BOTTOM w0.102: v5(154.68,113.98) 155.24,113.42 155.24,112.59 155.37,112.46 155.37,111.99 155.3,111.92 155.3,110 U7000.AR49
  BOTTOM w0.17: v5(144.32,137.63) U7601.R3
FBA_EDC<0>: length 25.2
  IN2 w0.127: v5(169.32,109.28) 169.75,109.7 169.75,110.55 169.08,111.22 169.08,117.8 167.91,118.97 167.91,123.53 171.17,126.79 171.17,129.37 171.03,129.52 170.43,129.52 v5(170.12,129.83)
  BOTTOM w0.1: v5(170.12,129.83) 169.47,129.83 U7600.T3
  BOTTOM w0.184: U7000.R48 v5(169.32,109.28)
FBA_EDC<1>: length 23.5
  IN2 w0.127: v5(162.97,129.83) 162.97,128.97 163.81,128.12 163.81,117.61 165.3,116.12 165.3,111.85 165.99,111.16 165.99,110.03 166.4,109.62 166.91,109.62 v5(167.23,109.29)
  BOTTOM w0.17: U7600.T12 163.3,130.15 v5(162.97,129.83)
  BOTTOM w0.184: U7000.V48 167.23,109.27 v5(167.23,109.29)
FBA_EDC<2>: length 37.6
  IN2 w0.127: v5(162.32,137.63) 162.32,137.63 162.3,137.61 161.21,137.61 160.3,136.7 159.62,136.7 158,135.08 158,118.97 162.05,114.93 162.05,109.63 161.78,109.36 161.78,108.68 161.65,108.54 161.65,107.13 v5(162.26,106.51)
  BOTTOM w0.1: U7600.D12 162.98,137.63 v5(162.32,137.63)
  BOTTOM w0.184: U7000.AF44 162.26,106.46 v5(162.26,106.51)
FBA_EDC<3>: length 37.9
  IN2 w0.127: v5(169.47,137.63) 168.29,137.63 167.8,137.14 167.8,135.95 167.72,135.87 167.72,135.37 165.7,133.35 164.03,133.35 163.93,133.45 161.46,133.45 161.25,133.24 161.25,119.13 164.49,115.89 164.49,111.59 165.47,110.6 165.47,109.63 v5(165.1,109.26)
  BOTTOM w0.17: v5(165.1,109.26) 165.14,109.26 U7000.AA48 ; v5(169.47,137.63) U7600.D3
FBA_EDC<4>: length 23
  IN2 w0.075: 144.59,129.5 144,129.5 143.67,129.83 v5(143.67,129.83)
  IN2 w0.127: v5(149.89,111.87) 149.89,112.66 143.81,118.74 143.81,127.41 144.13,127.73 144.13,128.34 144.72,128.93 144.72,129.38 144.59,129.5
  BOTTOM w0.17: U7601.D3 143.67,129.83 v5(143.67,129.83)
  BOTTOM w0.184: U7000.BB52 150.65,111.75 150.48,111.92 149.94,111.92 v5(149.89,111.87)
FBA_EDC<5>: length 22.1
  IN2 w0.127: v5(153.42,114.14) 153.47,114.18 153.47,114.84 150.2,118.11 150.2,129.8 150.17,129.83 v5(150.17,129.83)
  BOTTOM w0.102: U7000.AT50 154.95,110.55 154.57,110.92 154.57,111.87
  BOTTOM w0.17: v5(153.42,114.14) 153.59,114.14 154.55,113.17 154.55,111.89 154.57,111.87 ; v5(150.17,129.83) 150.17,129.83 U7601.D12
FBA_EDC<6>: length 36
  IN2 w0.127: v5(150.17,138.28) 150.57,137.88 153.07,137.88 155.75,135.2 155.75,118.49 158.89,115.35 158.89,111.26 159.25,110.9 159.25,109.06 158.84,108.65 v5(158.84,108.61)
  BOTTOM w0.17: v5(150.17,138.28) U7601.T12
  BOTTOM w0.184: U7000.AK48 158.84,108.64 v5(158.84,108.61)
FBA_EDC<7>: length 39.5
  IN2 w0.075: v5(143.67,138.28) 143.35,137.95 142.8,137.95 142.78,137.93
  IN2 w0.127: v5(155.66,113.45) 155.57,113.36 154.66,113.36 154.11,113.9 154.11,115.25 152.15,117.21 152.15,132.62 151.79,132.98 151.34,132.98 151.21,132.84 148.79,132.84 148.55,132.59 148.55,132.47 148.29,132.21 147.02,132.21 144.22,135.01 142.97,135.01 142.62,135.36 142.62,137.77 142.78,137.93
  BOTTOM w0.17: U7000.AR51 155.65,111.22 156.01,111.58 156.01,113.1 v5(155.66,113.45) ; U7601.T3 143.67,138.28 v5(143.67,138.28)
FBA_VREFC: length 14.6
  TOP w0.432: v5(162.32,134.38) 162.32,134.47 161.82,134.97 161.21,134.97 160.66,134.42 C7603.1 159.8,134.7 159.37,135.13 v5(158.95,135.13)
  TOP w0.508: v5(153.6,135.26) 151.97,135.26 151.77,135.06 151.5,135.06 v5(150.82,134.38)
  BOTTOM w0.25: v5(150.82,134.38) U7601.K13 ; v5(162.32,134.38) U7600.K13
  BOTTOM w0.432: v5(153.6,135.26) 153.85,135.26 154.59,134.53 C7604.1 R7611.2 R7609.2 R7610.1 v1(158.73,134.53) 158.95,134.75 v5(158.95,135.13)
FBA_VREFC_Q: length 1.3
  BOTTOM w0.432: R7609.1 Q7600.3
FBA_WCK01: length 28.1
  IN2 w0.114: v5(168.17,130.48) 168.05,130.48 167.93,130.36 167.93,130.11 167.65,129.83 167.39,129.83 165.76,128.2 165.76,118.71 166.92,117.55 166.92,115.8 167.15,115.57 167.15,111.93 167.81,111.27 167.81,106.56 168.13,106.24 168.45,106.24 168.57,106.36 v5(168.57,106.51)
  BOTTOM w0.122: v5(168.17,130.48) 168.17,130.29 168.31,130.15 U7600.T4 ; U7000.U45 168.57,106.53 v5(168.57,106.51)
FBA_WCK01*: length 28.2
  IN2 w0.114: v5(167.52,130.48) 167.71,130.29 167.71,130.2 167.56,130.05 167.3,130.05 165.54,128.29 165.54,118.62 166.71,117.46 166.71,115.71 166.94,115.48 166.94,111.84 167.6,111.18 167.6,106.47 168.04,106.03 168.35,106.03 v5(168.56,105.81)
  BOTTOM w0.122: v5(167.52,130.48) U7600.T5
  BOTTOM w0.14: U7000.U44 168.56,105.84 v5(168.56,105.81)
FBA_WCK23: length 43.3
  IN2 w0.114: v5(164.35,106.5) 164.35,106.33 164.22,106.2 164.06,106.2 163.74,106.52 163.74,110.32 163.06,111.01 163.06,115.39 159,119.45 159,134.22 159.83,135.05 165.1,135.05 165.7,135.65 165.7,136.72 166.59,137.61 167.65,137.61 167.89,137.85 167.89,138.14 168.03,138.28 v5(168.17,138.28)
  BOTTOM w0.122: v5(168.17,138.28) 168.17,138.12 168.34,137.95 U7600.D4
  BOTTOM w0.14: U7000.AC45 164.35,106.55 v5(164.35,106.5)
FBA_WCK23*: length 43.3
  IN2 w0.114: v5(164.35,105.8) 164.17,105.99 163.97,105.99 163.53,106.44 163.53,110.23 162.84,110.92 162.84,115.3 158.78,119.36 158.78,134.31 159.74,135.27 165.01,135.27 165.48,135.74 165.48,136.81 166.5,137.83 167.56,137.83 167.67,137.94 167.67,138.13 v5(167.51,138.3)
  BOTTOM w0.122: U7000.AC44 164.35,105.85 v5(164.35,105.8) ; v5(167.51,138.3) U7600.D5
FBA_WCK45: length 29.9
  IN2 w0.082: v5(144.97,130.48) 145.17,130.66 145.18,130.68 145.19,130.85 145.4,131.06 146.01,131.06 146.09,130.99
  IN2 w0.114: 146.09,130.99 146.4,130.67 146.4,117.99 150.81,113.58 151.9,113.58 153.36,112.13 153.36,107.83 153.5,107.69 153.63,107.69 153.83,107.89 153.84,107.89 153.87,107.92 v5(153.87,107.92)
  BOTTOM w0.122: v5(144.97,130.48) U7601.D4
  BOTTOM w0.14: v5(153.87,107.92) 153.87,107.93 U7000.AV47
FBA_WCK45*: length 30
  IN2 w0.082: v5(145.62,130.48) 145.62,130.47 145.58,130.44 145.45,130.45 145.35,130.56 145.36,130.67 145.37,130.77 145.47,130.88 145.89,130.88 145.97,130.8
  IN2 w0.114: 145.97,130.8 146.19,130.58 146.19,117.9 150.72,113.37 151.81,113.37 153.14,112.04 153.14,107.74 153.41,107.47 153.81,107.47 153.87,107.41 v5(153.87,107.22)
  BOTTOM w0.122: U7601.D5 145.29,130.16 145.62,130.48 v5(145.62,130.48)
  BOTTOM w0.14: U7000.AV46 153.55,107.39 153.72,107.22 v5(153.87,107.22)
FBA_WCK67: length 42.8
  IN2 w0.075: v5(144.97,138.28) 145.33,138.64 146.05,138.64
  IN2 w0.114: 146.05,138.64 147.03,137.66 147.03,136.1 147.97,135.16 152.97,135.16 154.21,133.92 154.21,118.1 156.54,115.78 156.54,112.21 155.33,111 155.33,106.45 155.42,106.36 155.81,106.36 v5(155.95,106.5)
  BOTTOM w0.122: U7601.T4 v5(144.97,138.28)
  BOTTOM w0.14: U7000.AR45 155.95,106.55 v5(155.95,106.5)
FBA_WCK67*: length 42.7
  IN2 w0.075: v5(145.62,138.28) 145.81,138.46 145.92,138.46 146.23,138.15
  IN2 w0.114: 146.23,138.15 146.81,137.57 146.81,136.01 147.57,135.25 147.88,134.95 152.88,134.95 154,133.83 154,118.01 156.32,115.69 156.32,112.3 155.11,111.09 155.11,106.36 155.33,106.14 155.87,106.14 155.95,106.07 v5(155.95,105.8)
  BOTTOM w0.122: U7601.T5 145.39,137.95 145.62,138.18 v5(145.62,138.28)
  BOTTOM w0.14: U7000.AR44 155.53,106.03 155.53,105.89 155.62,105.8 v5(155.95,105.8)
FBA_ZQ_1_B: length 3.4
  TOP w0.432: v5(162.32,135.68) 161.05,135.68 v1(160.69,135.31) 160.31,135.31 R7612.2
  BOTTOM w0.254: v5(162.32,135.68) 162.33,135.68 U7600.H13
FBA_ZQ_2_B: length 4
  TOP w0.432: v5(150.82,132.43) 150.82,132.71 151.26,133.15 v1(152.03,133.15) 152.03,133.31 152.46,133.74 153.37,133.74 R7613.2
  BOTTOM w0.254: U7601.H13 v5(150.82,132.43)
FBB_CLK0: length 44.1
  IN1 w0.114: v5(199.71,121.99) 199.86,121.99 199.96,122.09 199.96,122.41 199.86,122.51 191.32,122.51 183.6,114.8 183.6,110.61 178.89,105.89 178.89,104.92 178.43,104.46 174.85,104.46 174.24,105.07 v5(174.24,105.1)
  IN4 w0.114: v5(199.71,121.99) 199.86,121.99 199.94,121.9 199.94,121.5 200.17,121.27 200.92,121.27 201.5,120.69 201.59,120.6 201.59,118.75 201.75,118.59 201.75,118.27 201.68,118.21 v5(201.68,117.94)
  BOTTOM w0.122: v5(201.68,117.94) 201.89,117.94 202.01,118.06 U7700.K11
  BOTTOM w0.14: v5(174.24,105.1) 174.17,105.02 174.17,104.7 174.3,104.57 174.42,104.57 174.55,104.7 U7000.H42
FBB_CLK0*: length 44
  IN1 w0.114: v5(174.9,105.05) 174.81,104.96 174.81,104.81 174.94,104.67 178.34,104.67 178.67,105.01 178.67,105.98 183.39,110.69 183.39,114.89 191.23,122.73 199.95,122.73 200.17,122.5 200.17,122.22 v5(200.41,121.99)
  IN4 w0.114: v5(200.41,121.99) 200.16,121.74 200.16,121.59 200.26,121.49 201.01,121.49 201.81,120.69 201.81,118.84 201.96,118.68 201.96,118.27 202.06,118.16 202.06,117.67 v5(201.68,117.29)
  BOTTOM w0.122: v5(201.68,117.29) U7700.K10
  BOTTOM w0.14: v5(174.9,105.05) 174.95,105.05 U7000.G42
FBB_CLK1: length 38.5
  IN1 w0.114: v5(183.52,134.43) 183.31,134.22 183.14,134.22 182.85,133.93 182.85,133.52 183.3,133.07 186.38,133.07 186.71,132.74 186.71,132.4 187.2,131.91 187.48,131.91 v5(187.69,131.7)
  IN4 w0.114: v5(176.28,107.93) 176.63,108.28 177.17,108.28 177.64,108.76 179.1,108.76 180.42,110.08 180.42,114.33 184.56,118.47 184.56,123.44 188.29,127.17 188.29,131.54 188.02,131.8 187.8,131.8 v5(187.69,131.7)
  BOTTOM w0.122: v5(183.52,134.43) U7701.K11
  BOTTOM w0.14: v5(176.28,107.93) 176.27,107.93 U7000.F47
FBB_CLK1*: length 38.6
  IN1 w0.114: v5(187.69,132.5) 187.73,132.46 187.73,132.28 187.58,132.13 187.29,132.13 186.92,132.49 186.92,132.83 186.47,133.28 183.39,133.28 183.06,133.61 183.06,133.84 183.12,133.89 183.22,134 183.42,134 183.53,133.89 v5(183.52,133.78)
  IN4 w0.114: v5(177.01,107.92) 177.11,107.92 177.73,108.54 179.19,108.54 180.64,109.99 180.64,114.24 184.78,118.38 184.78,123.35 188.5,127.08 188.5,131.63 188.11,132.02 187.87,132.02 187.69,132.19 v5(187.69,132.5)
  BOTTOM w0.122: U7701.K10 183.2,133.9 183.32,133.78 v5(183.52,133.78)
  BOTTOM w0.14: U7000.E47 176.65,108.12 176.83,107.94 176.98,107.94 177,107.92 v5(177.01,107.92)
FBB_CMD<0>: length 32.1
  BOTTOM w0.1: 202.88,110.87 202.93,110.92 202.93,111.59 202.98,111.64 202.98,113.39 U7700.H4
  BOTTOM w0.102: U7000.B35 178.9,99.85 179.25,99.5 182.96,99.5
  BOTTOM w0.14: 202.88,110.87 200.74,108.72 195.38,108.72 186.04,99.38 183.08,99.38 182.96,99.5
FBB_CMD<1>: length 29.6
  TOP w0.13: 201.45,110.43 v5(201.39,110.49)
  TOP w0.14: R7115.1 201.99,109.89 201.45,110.43
  BOTTOM w0.102: U7000.A35 183.02,99.85
  BOTTOM w0.136: v5(201.39,110.49) 201.75,110.85 201.75,111.41 201.69,111.47 201.69,112.09 U7700.K2
  BOTTOM w0.14: v5(201.39,110.49) 201.39,110.12 200.69,109.43 195.5,109.43 185.92,99.85 183.02,99.85
FBB_CMD<2>: length 31.4
  BOTTOM w0.1: 200.61,110.85 201.02,111.26 201.02,113.4 U7700.M4
  BOTTOM w0.102: 179.56,100.2 177.7,100.2 U7000.D35
  BOTTOM w0.14: 195.56,110.72 194.98,110.14 194.98,109.49 185.69,100.2 179.56,100.2
  BOTTOM w0.184: 195.56,110.72 200.48,110.72 200.61,110.85
FBB_CMD<3>: length 30.7
  BOTTOM w0.1: 195.31,113.62 195.31,114.69 195.64,115.03 199.26,115.03 199.5,114.79 200.93,114.79 U7700.L5
  BOTTOM w0.14: 195.31,113.62 194.34,112.65 194.34,109.44 185.45,100.55 U7000.A36
FBB_CMD<4>: length 32.6
  BOTTOM w0.1: U7700.L4 201.66,114.02 201.66,114.49 201.13,115.02 199.6,115.02 199.39,115.23 195.52,115.23 194.95,114.66
  BOTTOM w0.102: U7000.B36 178.95,100.55 179.3,100.9 182.92,100.9
  BOTTOM w0.14: 194.95,114.66 194.95,114.03 193.82,112.89 193.82,109.5 185.21,100.9 182.92,100.9
FBB_CMD<5>: length 33
  BOTTOM w0.1: U7700.K5 202.01,114.67 201.42,115.25 199.67,115.25 199.49,115.43 195.29,115.43 195.28,115.41
  BOTTOM w0.102: U7000.C36 178.27,100.55 178.62,100.9 178.95,100.9 179.15,101.1 181.87,101.1 182.06,101.29
  BOTTOM w0.111: 194.45,114.58 195.28,115.41
  BOTTOM w0.14: 194.45,114.58 193.3,113.44 193.3,109.57 185.02,101.29 182.06,101.29
FBB_CMD<6>: length 34.2
  BOTTOM w0.1: 194.45,115.05 195.03,115.63 199.64,115.63 199.76,115.51 201.45,115.51 202.31,114.65 202.31,114.02 U7700.K4
  BOTTOM w0.102: 182.03,101.71 181.93,101.71 181.62,101.4 179.1,101.4 178.9,101.6 178.4,101.6 U7000.C38
  BOTTOM w0.14: 182.03,101.71 184.85,101.71 192.78,109.64 192.78,113.68 193.82,114.73 194.12,114.73 194.45,115.05
FBB_CMD<7>: length 33.6
  BOTTOM w0.1: 194.83,115.83 199.78,115.83 199.88,115.73 201.86,115.73 202.66,114.93 U7700.J5
  BOTTOM w0.102: 194.45,115.45 194.83,115.83 ; U7000.B38 178.9,101.95 179.25,101.6 181.41,101.6 181.87,102.06
  BOTTOM w0.14: 181.87,102.06 184.61,102.06 192.26,109.7 192.26,114.27 193.23,115.25 194.24,115.25 194.45,115.45
FBB_CMD<8>: length 34.3
  BOTTOM w0.1: U7700.J4 202.98,114.04 202.98,115.34 202.58,115.74 202.33,115.99 199.94,115.99 199.79,116.15 194.71,116.15 194.45,115.88
  BOTTOM w0.102: 181.76,102.43 181.28,101.95 U7000.A38
  BOTTOM w0.14: 181.76,102.43 184.4,102.43 191.73,109.77 191.73,114.57 192.94,115.77 194.33,115.77 194.45,115.88
FBB_CMD<9>: length 36.6
  BOTTOM w0.1: 194.49,116.3 194.59,116.39 199.88,116.39 200.07,116.2 202.37,116.2 202.98,116.81 202.98,117.94 U7700.J11
  BOTTOM w0.102: 194.45,116.3 194.49,116.3 ; 181.52,102.77 181.05,102.3 177.7,102.3 U7000.D38
  BOTTOM w0.14: 194.45,116.3 192.52,116.3 191.21,114.99 191.21,109.83 184.15,102.77 181.52,102.77
FBB_CMD<10>: length 33.5
  BOTTOM w0.1: U7700.J10 202.72,117.55 202.72,116.95 202.33,116.56 202.17,116.4 200.2,116.4 199.98,116.62 194.45,116.62
  BOTTOM w0.102: 181.46,103.16 180.95,102.65 U7000.A39
  BOTTOM w0.14: 181.46,103.16 183.95,103.16 190.69,109.9 190.69,115.44 192.11,116.85 194.22,116.85 194.45,116.62
FBB_CMD<11>: length 33.5
  BOTTOM w0.1: U7700.L10 201.32,117.57 201.32,116.97 200.94,116.6 200.33,116.6 200.09,116.84 194.76,116.84 194.45,117.15
  BOTTOM w0.102: U7000.B39 178.95,102.65 179.3,103 180.66,103 181.13,103.46
  BOTTOM w0.14: 181.13,103.46 183.67,103.46 190.17,109.97 190.17,116.12 191.58,117.52 194.08,117.52 194.45,117.15
FBB_CMD<12>: length 35.4
  BOTTOM w0.1: 194.74,117.54 195.22,117.07 200.22,117.07 200.48,116.8 200.83,116.8 201.03,117.01 201.03,117.94 U7700.L11
  BOTTOM w0.102: 183.24,103.76 180.86,103.76 180.31,103.2 179.15,103.2 178.95,103 178.55,103 178.2,102.65 U7000.C39
  BOTTOM w0.14: 194.74,117.54 194.17,118.11 190.88,118.11 189.65,116.88 189.65,110.03 183.38,103.76 183.24,103.76
FBB_CMD<13>: length 35.1
  BOTTOM w0.1: U7700.M11 200.38,117.94 200.38,117.48 200.21,117.31 195.61,117.31 195,117.92
  BOTTOM w0.102: 183.24,104.21 183.2,104.17 180.58,104.17 179.91,103.5 179.1,103.5 178.9,103.7 178.4,103.7 U7000.C41
  BOTTOM w0.14: 195,117.92 194.13,118.79 R7102.1 190.03,118.79 189.13,117.88 189.13,110.1 183.24,104.21
FBB_CMD<14>: length 41
  BOTTOM w0.1: 201.56,120.72 201.55,120.71 201.55,120.54 201.68,120.41 201.68,119.24 U7700.K12
  BOTTOM w0.102: 182.86,104.41 180.36,104.41 179.65,103.7 179.25,103.7 178.9,104.05 U7000.B41
  BOTTOM w0.14: 182.86,104.41 188.61,110.16 188.61,119.7 191.85,122.94 194.75,122.94 195.38,123.58 200.26,123.58 201.68,122.16 201.68,121.66 201.56,121.54 201.56,120.72
FBB_CMD<15>: length 42.3
  BOTTOM w0.1: 202.83,121.56 202.83,120.48 202.98,120.33 202.98,118.59 U7700.H11
  BOTTOM w0.102: U7000.A41 180.08,104.68 182.54,104.68
  BOTTOM w0.14: 202.83,121.56 202.83,122.05 200.66,124.22 192.32,124.22 188.09,119.99 188.09,110.23 182.54,104.68
FBB_CMD<16>: length 33.3
  BOTTOM w0.1: 176.07,135.1 178.99,135.1 U7701.M4
  BOTTOM w0.102: 180.12,112.24 180.33,112.03 180.33,110.6 179.73,110 179.1,110 U7000.B49
  BOTTOM w0.104: 180.12,112.24 179.68,112.68
  BOTTOM w0.14: 179.68,112.68 179.31,112.68 178.42,113.57 178.42,119.39 174.25,123.55 174.25,133.28 176.07,135.1
FBB_CMD<17>: length 31
  TOP w0.14: R7114.1 175.88,133.97 v5(175.99,134.08)
  BOTTOM w0.1: U7701.K2 178,134.1 177.69,134.41 176.32,134.41 176,134.09
  BOTTOM w0.102: 179.78,113.24 180.7,112.33 180.7,110.58 179.77,109.65 U7000.A49
  BOTTOM w0.14: 176,134.09 v5(175.99,134.08) 174.86,132.95 174.86,123.74 178.98,119.62 178.98,114.05 179.78,113.24
FBB_CMD<18>: length 31.7
  BOTTOM w0.1: U7701.H4 178.97,133.13 178.97,133.58 178.76,133.79 177.01,133.79 176.89,133.67 176.7,133.67 176.26,133.23
  BOTTOM w0.102: 176.26,133.23 176,133.23 ; U7000.A48 181.05,110.55 181.05,112.82 180.45,113.42
  BOTTOM w0.14: 176,133.23 175.49,132.72 175.49,123.91 179.56,119.84 179.56,114.31 180.45,113.42
FBB_CMD<19>: length 31.8
  BOTTOM w0.1: U7701.J5 180.62,132.79 180.62,128.01 179.64,127.03 178.52,127.03
  BOTTOM w0.102: U7000.D47 177.7,108.6 179.65,108.6 181.42,110.37 181.42,113.2 180.93,113.7
  BOTTOM w0.14: 178.52,127.03 177.6,126.12 177.6,122.56 180.14,120.02 180.14,114.48 180.93,113.7
FBB_CMD<20>: length 30
  BOTTOM w0.1: 179.62,126.65 180.82,127.85 180.82,133.04 180.08,133.78 179.62,133.78 U7701.J4
  BOTTOM w0.102: 181.2,114.12 181.88,113.45 181.88,110.43 179.7,108.25 U7000.A47
  BOTTOM w0.104: 181.2,114.12 181.2,115.42
  BOTTOM w0.14: 179.62,126.65 179.33,126.65 179.08,126.4 179.08,121.9 181.2,119.78 181.2,115.42
FBB_CMD<21>: length 30.7
  BOTTOM w0.1: U7701.K5 180.3,134.1 181.02,133.38 181.02,127.65 179.92,126.55
  BOTTOM w0.102: 182.36,115.42 182.36,110.54 179.73,107.9 179.25,107.9 178.9,108.25 U7000.B47
  BOTTOM w0.14: 182.36,115.42 182.36,119.4 179.71,122.05 179.71,126.34 179.92,126.55
FBB_CMD<22>: length 33.2
  BOTTOM w0.1: U7701.K4 179.62,134.43 180.47,134.43 181.22,133.68 181.22,127.35 180.42,126.55
  BOTTOM w0.102: 181.76,109.53 179.92,107.7 179.1,107.7 178.9,107.9 178.4,107.9 U7000.C47
  BOTTOM w0.14: 181.76,109.53 182.88,110.66 182.88,119.75 180.24,122.38 180.24,126.38 180.42,126.55
FBB_CMD<23>: length 33.3
  BOTTOM w0.1: 180.9,126.65 181.42,127.17 181.42,133.93 180.59,134.75 U7701.L5
  BOTTOM w0.102: U7000.C45 178.26,106.85 178.61,107.2 178.95,107.2 179.15,107.4 180.02,107.4 181.89,109.27
  BOTTOM w0.14: 181.89,109.27 183.4,110.78 183.4,120.09 180.78,122.71 180.78,126.53 180.9,126.65
FBB_CMD<24>: length 34.2
  BOTTOM w0.1: 181.34,126.73 181.62,127.01 181.62,134.1 180.76,134.97 180.19,134.97 180.08,135.08 179.62,135.08 U7701.L4
  BOTTOM w0.102: U7000.B45 178.95,106.85 179.3,107.2 180.41,107.2 180.51,107.3
  BOTTOM w0.14: 181.34,126.73 181.34,123.04 183.92,120.46 183.92,110.72 180.51,107.3
FBB_CMD<25>: length 33.8
  BOTTOM w0.1: U7701.L11 183.52,135.08 182.64,135.08 181.83,134.26 181.83,127.1 181.9,127.03
  BOTTOM w0.102: 180.8,107.01 180.64,106.85 U7000.A45
  BOTTOM w0.14: 180.8,107.01 184.44,110.65 184.44,120.9 181.9,123.45 181.9,127.03
FBB_CMD<26>: length 35.6
  BOTTOM w0.1: 182.43,126.91 182.03,127.31 182.03,134.14 182.64,134.75 U7701.L10
  BOTTOM w0.102: U7000.D44 177.7,106.5 180.88,106.5
  BOTTOM w0.14: 182.43,126.91 182.43,123.81 184.97,121.27 184.97,110.58 180.88,106.5
FBB_CMD<27>: length 32.9
  BOTTOM w0.1: U7701.J10 182.55,133.45 182.23,133.13 182.23,127.59 182.81,127.01
  BOTTOM w0.102: U7000.A44 181.12,106.15 181.19,106.21
  BOTTOM w0.14: 181.19,106.21 185.49,110.51 185.49,121.66 182.99,124.16 182.99,126.83 182.81,127.01
FBB_CMD<28>: length 34.9
  BOTTOM w0.1: U7701.J11 183.52,133.13 182.66,133.13 182.43,132.9 182.43,127.87 183.11,127.19
  BOTTOM w0.102: U7000.B44 178.9,106.15 179.24,105.81 181.36,105.81 181.44,105.88
  BOTTOM w0.14: 181.44,105.88 186.01,110.45 186.01,122.11 183.52,124.59 183.52,126.78 183.11,127.19
FBB_CMD<29>: length 35.3
  BOTTOM w0.1: U7701.H11 183.52,132.48 183.09,132.48 182.81,132.2 182.81,127.97
  BOTTOM w0.102: U7000.C44 178.4,105.8 178.9,105.8 179.1,105.6 181.74,105.6
  BOTTOM w0.14: 181.74,105.6 186.53,110.38 186.53,122.58 184.08,125.03 R7103.1 184.08,126.7 182.81,127.97
FBB_CMD<30>: length 38.8
  BOTTOM w0.1: U7701.K12 184.82,133.78 184.82,133.35 185.04,133.13 186.39,133.13 186.46,133.05
  BOTTOM w0.102: U7000.C42 178.29,104.75 178.64,105.1 178.95,105.1 179.16,105.31 181.99,105.31
  BOTTOM w0.14: 186.46,133.05 186.95,132.57 186.95,131.53 187.69,130.79 188.37,130.79 188.89,130.27 188.89,123.84 187.05,122 187.05,111.03 187.04,111.02 187.05,111.01 187.05,110.36 181.99,105.31
FBB_CMD<31>: length 40.9
  BOTTOM w0.1: U7701.M11 184.15,135.1 186.02,135.1 186.11,135.2
  BOTTOM w0.102: 182.24,104.97 179.78,104.97 179.7,105.05 179.25,105.05 178.95,104.75 U7000.B42
  BOTTOM w0.14: 186.11,135.2 186.46,135.2 187.14,134.51 187.14,134.1 189.41,131.83 189.41,123.6 187.57,121.76 187.57,110.3 182.24,104.97
FBB_D<0>: length 32.4
  IN1 w0.127: v5(174.9,97.45) 175.82,98.37 177.79,98.37 177.93,98.51 178.57,98.51 178.93,98.87 178.93,99.49 179.39,99.95 180.37,99.95 187.98,107.56 187.98,111.68 190.48,114.18 195.23,114.18 195.35,114.31 196.21,114.31 v5(196.48,114.04)
  BOTTOM w0.17: U7700.V4 196.81,113.71 v5(196.48,114.04)
  BOTTOM w0.184: U7000.H32 174.85,97.45 v5(174.9,97.45)
FBB_D<1>: length 29.5
  IN1 w0.127: v5(180.52,97.72) 180.52,98.04 180.71,98.23 181.09,98.23 181.26,98.4 181.26,98.92 183.51,101.17 183.51,101.69 188.92,107.09 188.92,110.97 190.78,112.83 194.81,112.83 v5(195.2,112.44)
  BOTTOM w0.1: v5(195.2,112.44) 195.49,112.74 196.48,112.74 U7700.V3
  BOTTOM w0.102: v5(180.52,97.72) 180.13,98.12 177.72,98.12 U7000.D32
FBB_D<2>: length 27.8
  IN1 w0.075: 196.9,113.06 197.46,113.06 v5(197.78,113.39) ; 195.74,112.48 195.43,112.17 195.43,112.02 195.38,111.97
  IN1 w0.127: v5(182.18,98.63) 189.39,105.85 189.39,109.8 190.26,110.67 192.74,110.67 193.91,111.84 195.26,111.84 195.38,111.97 ; 195.74,112.48 196.01,112.75 196.35,112.75 196.66,113.06 196.9,113.06
  BOTTOM w0.102: U7000.A33 180.26,98.45 180.62,98.09 181.78,98.09 182.18,98.48 v5(182.18,98.63)
  BOTTOM w0.17: U7700.U4 v5(197.78,113.39)
FBB_D<3>: length 29.5
  IN1 w0.075: 196.81,111.91 196.81,112.41 v5(197.13,112.74)
  IN1 w0.127: 196.81,111.91 196.78,111.88 196.78,111.08 196.62,110.93 194.68,110.93 193.66,109.92 190.26,109.92 189.86,109.51 189.86,103.69 184.27,98.1 181.64,98.1 v5(181.19,97.66)
  BOTTOM w0.102: U7000.B32 178.9,97.75 179.23,97.42 179.75,97.42 179.81,97.37 180.9,97.37 v5(181.19,97.66)
  BOTTOM w0.17: U7700.U3 v5(197.13,112.74)
FBB_D<4>: length 38.1
  IN1 w0.075: 200.11,111.69 200.06,111.75 200.06,113.71
  IN1 w0.127: 200.06,113.71 v5(199.73,114.04) ; 200.11,111.69 200.11,110.42 199.97,110.28 199.97,109.8 198.37,108.2 191.03,108.2 190.8,107.97 190.8,101.24 186.3,96.74 181.12,96.74 181.04,96.82 179.73,96.82 179.1,97.46 177.92,97.46 v5(177.76,97.3)
  BOTTOM w0.102: v5(177.76,97.3) 177.63,97.42 176.97,97.42 U7000.E32
  BOTTOM w0.17: U7700.P4 v5(199.73,114.04)
FBB_D<5>: length 34
  IN1 w0.075: 196.26,113.71 198.76,113.71 198.79,113.68
  IN1 w0.127: v5(175.6,97.45) 176.24,98.09 178.82,98.09 179.53,98.8 179.53,99.16 179.77,99.41 180.57,99.41 188.45,107.29 188.45,111.49 190.48,113.52 196.07,113.52 196.26,113.71 ; 198.79,113.68 v5(199.08,113.39)
  BOTTOM w0.17: U7700.P3 v5(199.08,113.39)
  BOTTOM w0.184: v5(175.6,97.45) 175.55,97.45 U7000.G32
FBB_D<6>: length 41
  IN1 w0.127: v5(173.5,96.67) 173.52,96.65 173.52,96.65 174.12,96.05 175.87,96.05 176.11,96.29 177.86,96.29 178.2,96.63 179.32,96.63 179.55,96.4 180.78,96.4 180.91,96.27 186.57,96.27 191.27,100.97 191.27,105.09 193.4,107.22 198.61,107.22 200.97,109.58 200.97,112.8 v5(200.38,113.39)
  BOTTOM w0.17: U7700.N4 v5(200.38,113.39)
  BOTTOM w0.184: v5(173.5,96.67) 173.53,96.67 U7000.J30
FBB_D<7>: length 36.6
  IN1 w0.075: 199.41,111.78 199.41,112.41 v5(199.73,112.74)
  IN1 w0.127: v5(176.3,97.45) 176.63,97.78 179.24,97.78 179.8,97.22 185.87,97.22 190.33,101.68 190.33,109.04 190.35,109.07 198.05,109.07 198.91,109.93 198.91,110.19 199.38,110.66 199.38,111.75 199.41,111.78
  BOTTOM w0.17: U7700.N3 v5(199.73,112.74)
  BOTTOM w0.184: v5(176.3,97.45) 176.25,97.45 U7000.F32
FBB_D<8>: length 34.8
  IN4 w0.102: 174.68,100.42 175.52,100.42 175.64,100.3 177.39,100.3 177.53,100.44 177.77,100.44
  IN4 w0.127: 177.77,100.44 177.81,100.44 178.01,100.64 178.44,100.64 178.68,100.88 178.68,101.17 179.65,102.14 181.46,102.14 186.87,107.55 186.87,112.43 190.09,115.65 190.09,116.59 192.13,118.62 194.29,118.62 194.48,118.43 v5(195.18,118.43) ; v5(174.18,100.87) 174.19,100.87 174.21,100.86 174.24,100.86 174.68,100.42
  BOTTOM w0.1: v5(195.18,118.43) 195.78,118.43 195.94,118.59 196.48,118.59 U7700.V11
  BOTTOM w0.184: v5(174.18,100.87) 174.23,100.87 U7000.H36
FBB_D<9>: length 36.5
  IN4 w0.102: 174.55,101.79 174.55,101.26 v5(174.93,100.88)
  IN4 w0.127: 174.55,101.79 175.05,102.29 178.07,102.29 179.24,103.46 181.11,103.46 185.93,108.28 185.93,112.82 189.15,116.04 189.15,119.13 190.27,120.25 194.82,120.25 v5(195.26,119.81)
  BOTTOM w0.1: v5(195.26,119.81) 195.83,119.24 196.48,119.24 U7700.V12
  BOTTOM w0.184: U7000.G36 174.93,100.87 v5(174.93,100.88)
FBB_D<10>: length 35.5
  IN4 w0.102: 174.3,100.1 177.89,100.1
  IN4 w0.127: v5(173.51,100.89) 174.3,100.1 ; v5(197.13,118.59) 196.96,118.41 195.76,118.41 195.15,117.81 192.96,117.81 187.34,112.19 187.34,107.24 181.63,101.53 179.94,101.53 178.67,100.26 178.05,100.26 177.89,100.1
  BOTTOM w0.17: U7700.U11 v5(197.13,118.59)
  BOTTOM w0.184: U7000.J36 v5(173.51,100.89)
FBB_D<11>: length 35.3
  IN4 w0.102: v5(175.64,100.9) 175.64,100.89 176.03,100.5 177.15,100.5 177.36,100.71 177.36,101.11
  IN4 w0.127: v5(197.13,119.89) 196.63,119.38 191.7,119.38 189.62,117.31 189.62,115.84 186.4,112.62 186.4,107.97 181.29,102.86 179.62,102.86 178.53,101.77 177.61,101.77 177.36,101.52 177.36,101.11
  BOTTOM w0.1: U7700.U12 197.13,119.24 v5(197.13,119.89)
  BOTTOM w0.184: v5(175.64,100.9) 175.64,100.9 175.64,100.86 U7000.F36
FBB_D<12>: length 37.1
  IN4 w0.102: 178.74,98.29 176.94,98.29 176.8,98.43 175.98,98.43 v5(175.62,98.79)
  IN4 w0.127: v5(199.73,118.59) 200.13,118.19 200.13,117.74 198.24,115.84 194.22,115.84 188.75,110.38 188.75,106.31 182.17,99.73 180.19,99.73 178.74,98.29
  BOTTOM w0.17: U7700.P11 v5(199.73,118.59)
  BOTTOM w0.184: v5(175.62,98.79) 175.62,98.78 U7000.F33
FBB_D<13>: length 34.7
  IN4 w0.075: v5(199.08,119.24) 199.41,118.91 199.41,117.72 199.1,117.42
  IN4 w0.102: v5(177.71,98.83) 177.85,98.83 178.15,98.54 178.51,98.54 178.76,98.79 178.76,98.8
  IN4 w0.127: 178.76,98.8 178.76,98.84 180.15,100.22 181.88,100.22 188.28,106.63 188.28,110.57 194.17,116.46 198.14,116.46 199.1,117.42
  BOTTOM w0.17: U7700.P12 v5(199.08,119.24)
  BOTTOM w0.184: U7000.D33 177.71,98.81 v5(177.71,98.83)
FBB_D<14>: length 41.5
  IN4 w0.102: 176.85,97.94 176.64,98.15 174.22,98.15
  IN4 w0.127: v5(173.51,97.44) 174.22,98.15 ; 176.85,97.94 178.94,97.94 180.22,99.22 182.45,99.22 189.22,105.99 189.22,110.18 194.22,115.18 199.21,115.18 201.14,117.11 201.14,118.28 201.03,118.39 v5(201.03,118.59)
  BOTTOM w0.1: U7700.N11 200.38,118.59 v5(201.03,118.59)
  BOTTOM w0.184: U7000.J32 173.54,97.44 v5(173.51,97.44)
FBB_D<15>: length 40.1
  IN4 w0.075: 197.46,117.76 197.46,118.94 197.39,119.01 ; 197.56,119.55 197.56,119.56 198.04,119.56 198.13,119.65 ; 199.41,119.56 199.41,119.56 198.79,119.56
  IN4 w0.102: 177.91,99.82 177.85,99.88 174.69,99.88 174.63,99.82
  IN4 w0.127: 197.46,117.76 196.92,117.22 193.61,117.22 187.81,111.42 187.81,106.93 181.76,100.87 179.84,100.87 178.79,99.82 177.91,99.82 ; 197.39,119.01 197.39,119.39 197.56,119.55 ; 198.79,119.56 198.7,119.65 198.13,119.65 ; v5(174.91,98.77) 174.43,99.24 174.43,99.62 174.63,99.82 ; 199.41,119.56 v5(199.73,119.89)
  BOTTOM w0.1: U7700.N12 199.73,119.24 v5(199.73,119.89)
  BOTTOM w0.184: U7000.G33 174.93,98.77 v5(174.91,98.77)
FBB_D<16>: length 51.8
  IN4 w0.127: v5(176.99,107.16) 177.46,107.62 177.46,107.84 177.67,108.05 179.43,108.05 181.22,109.84 181.22,113.54 185.32,117.64 185.32,121.76 190.41,126.85 203.76,126.85 208.69,121.92 208.69,119.01 v5(208.26,118.58)
  BOTTOM w0.1: U7700.B11 207.52,118.58 v5(208.26,118.58)
  BOTTOM w0.184: U7000.E45 176.96,107.16 v5(176.99,107.16)
FBB_D<17>: length 48.5
  IN4 w0.075: v5(207.53,119.24) 207.88,119.58 207.88,121.01
  IN4 w0.127: v5(177.7,107.17) 177.78,107.1 179.2,107.1 181.99,109.89 181.99,113.64 185.79,117.43 185.79,121.56 190.6,126.38 203.56,126.38 207.8,122.14 207.8,121.09 207.88,121.01
  BOTTOM w0.17: v5(207.53,119.24) U7700.B12
  BOTTOM w0.184: v5(177.7,107.17) 177.67,107.17 U7000.D45
FBB_D<18>: length 51.3
  IN4 w0.075: 207.21,120.73 207.21,119.65
  IN4 w0.127: v5(206.88,117.94) 206.87,117.95 206.87,117.98 207.27,118.37 207.27,118.87 207.14,118.99 207.14,119.59 207.21,119.65 ; v5(175.64,107.19) 176.21,106.62 179.56,106.62 182.6,109.66 182.6,113.58 186.26,117.24 186.26,121.37 190.8,125.91 203.19,125.91 204.98,124.12 204.98,123.76 207.02,121.72 207.02,121.2 207.21,121.01 207.21,120.73
  BOTTOM w0.17: v5(206.88,117.94) U7700.C11
  BOTTOM w0.184: U7000.F45 175.64,107.16 v5(175.64,107.19)
FBB_D<19>: length 49.7
  IN4 w0.075: 206.56,120.84 206.56,120.21 v5(206.88,119.89)
  IN4 w0.127: 206.56,120.84 206.15,121.24 206.15,121.77 204.26,123.66 204.26,123.98 203.82,124.41 203.48,124.41 202.61,125.28 190.84,125.28 186.73,121.17 186.73,117.04 183.35,113.66 183.35,109.63 180.04,106.32 175.51,106.32 174.85,106.98 v5(174.79,106.98)
  BOTTOM w0.1: v5(206.88,119.89) 206.88,119.24 U7700.C12
  BOTTOM w0.184: v5(174.79,106.98) 174.92,106.85 U7000.G45
FBB_D<20>: length 47.1
  IN4 w0.075: 205.26,120.71 205.26,120.71 205.26,119.59
  IN4 w0.127: 205.26,119.59 205.31,119.54 205.31,118.95 204.95,118.59 v5(204.93,118.59) ; 205.26,120.71 205.26,121.67 203.67,123.25 203.34,123.25 202.93,123.67 202.93,124.1 202.32,124.7 190.92,124.7 187.2,120.98 187.2,116.85 183.98,113.63 183.98,109.49 180.29,105.8 178.4,105.8 178.25,105.95 177.67,105.95 177.43,105.71 177.43,105.32 v5(177.7,105.05)
  BOTTOM w0.17: U7700.F11 v5(204.93,118.59)
  BOTTOM w0.184: U7000.D42 177.65,105.05 v5(177.7,105.05)
FBB_D<21>: length 44.9
  IN4 w0.075: 204.61,120.68 204.61,120.68 204.61,119.56 v5(204.28,119.24)
  IN4 w0.127: v5(176.99,105.06) 176.99,105.03 176.98,105.02 176.98,104.99 177.3,104.67 178.21,104.67 178.81,105.27 180.51,105.27 184.45,109.21 184.45,113.43 187.67,116.65 187.67,120.78 190.98,124.1 201.61,124.1 204.61,121.1 204.61,120.68
  BOTTOM w0.17: v5(204.28,119.24) 204.28,119.24 U7700.F12
  BOTTOM w0.184: v5(176.99,105.06) 176.96,105.06 U7000.E42
FBB_D<22>: length 46.7
  IN4 w0.075: 203.96,120.08 203.96,118.26 v5(204.28,117.94)
  IN4 w0.127: 203.96,120.08 203.87,120.16 203.87,121.02 201.45,123.44 198.62,123.44 197.82,122.64 190.21,122.64 188.14,120.57 188.14,116.46 184.92,113.24 184.92,108.88 180.8,104.76 179,104.76 178.49,104.24 177,104.24 176.58,104.66 176.03,104.66 v5(175.62,105.07)
  BOTTOM w0.17: U7700.G11 v5(204.28,117.94)
  BOTTOM w0.184: v5(175.62,105.07) 175.63,105.07 U7000.F42
FBB_D<23>: length 45.9
  IN4 w0.123: 203.07,119.79 203.07,120.98
  IN4 w0.127: 203.07,119.79 203.07,119.15 v5(203.63,118.59) ; v5(174.89,103.74) 175.29,104.14 176.5,104.14 176.8,103.84 178.78,103.84 179.1,104.15 180.98,104.15 183.24,106.42 185.39,108.56 185.39,113.04 188.61,116.26 188.61,120.25 189.62,121.26 190.86,121.26 190.88,121.25 198.09,121.25 198.67,121.82 198.67,122.38 199.08,122.8 201.25,122.8 203.07,120.98
  BOTTOM w0.17: U7700.G12 203.96,118.91 v5(203.63,118.59)
  BOTTOM w0.184: U7000.H41 174.86,103.74 v5(174.89,103.74)
FBB_D<24>: length 51
  IN1 w0.127: v5(176.31,103.74) 177.54,103.74 177.64,103.84 178.14,103.84 178.41,103.57 178.87,103.57 180.15,104.85 180.15,105.2 184.61,109.66 184.61,114.38 190.72,120.49 194.39,120.49 194.88,120.97 202.84,120.97 203.03,121.16 203.78,121.16 203.98,120.97 208.35,120.97 208.63,120.69 208.63,115.95 v5(207.63,114.96)
  BOTTOM w0.1: U7700.B4 207.53,114.03 207.53,114.86 v5(207.63,114.96)
  BOTTOM w0.184: v5(176.31,103.74) 176.34,103.74 U7000.E41
FBB_D<25>: length 55.2
  IN1 w0.102: 178.27,104.12 176.1,104.12 175.95,103.98 175.95,103.3 175.92,103.27
  IN1 w0.127: v5(207.53,112.74) 207.88,112.74 209.1,113.96 209.1,121.14 208.29,121.95 202.08,121.95 201.57,121.44 191.02,121.44 184.14,114.57 184.14,110.38 179.73,105.97 179.73,105.1 178.75,104.12 178.27,104.12 ; v5(175.62,102.97) 175.92,103.27
  BOTTOM w0.17: v5(207.53,112.74) U7700.B3
  BOTTOM w0.184: v5(175.62,102.97) 175.63,102.97 U7000.F39
FBB_D<26>: length 43.4
  IN1 w0.075: v5(206.88,113.39) 206.88,113.39 U7700.C4 206.02,113.71
  IN1 w0.127: v5(177.01,102.97) 177.47,102.51 179.28,102.51 185.55,108.78 185.55,113.99 190.05,118.48 194.39,118.48 195.35,117.53 199.69,117.53 200.44,116.78 202.74,116.78 203.26,116.26 204.56,116.26 205.77,115.05 205.77,113.95 206.02,113.71
  BOTTOM w0.17: v5(206.88,113.39) 206.88,113.39 U7700.C4
  BOTTOM w0.184: U7000.E39 176.97,102.97 v5(177.01,102.97)
FBB_D<27>: length 46.6
  IN1 w0.075: 198.81,119.56 199.44,119.56 ; 207.21,113.71 207.21,113.05 ; 197.36,119.56 198.13,119.56
  IN1 w0.127: 207.21,113.71 207.32,113.82 207.32,114.38 207.15,114.56 207.15,115.3 205.6,116.85 203.5,116.85 202,118.35 201.45,118.35 201.32,118.21 200.79,118.21 199.44,119.56 ; v5(206.88,112.09) 206.88,112.73 207.21,113.05 ; 198.13,119.56 198.19,119.62 198.75,119.62 198.81,119.56 ; v5(177.7,102.96) 177.86,102.81 178.75,102.81 185.08,109.14 185.08,114.18 190.51,119.61 194.84,119.61 195.05,119.41 197.2,119.41 197.36,119.56
  BOTTOM w0.1: U7700.C3 206.88,112.74 v5(206.88,112.09)
  BOTTOM w0.184: U7000.D39 177.66,102.96 v5(177.7,102.96)
