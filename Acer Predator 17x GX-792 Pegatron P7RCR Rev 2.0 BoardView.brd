# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GSENSOR_INT2: length 376.6
  TOP w0.102: v1(308.34,134.02) v2(307.63,134.02) 307.42,134.22 R5807.1
  IN2 w0.102: v2(89.85,23.22) 89.83,23.24 63.02,23.24 60.94,21.15 51.26,21.15 49.25,19.14 39.58,19.14 36.89,16.45 32.23,16.45 v2(31.88,16.8)
  IN3 w0.102: v2(89.85,23.22) 96.91,23.22 97.85,22.28 106.61,22.28 109.96,25.64 116.04,25.64 121.34,30.94 125.33,30.94 125.63,30.64 132.43,30.64 134.65,32.87 142.58,32.87 146.67,28.79 158.43,28.79 158.98,28.24 167.59,28.24 168.3,28.95 185.61,28.95 185.63,28.94 186.69,28.94 187.24,28.39 196.07,28.39 199.41,31.74 203.88,31.74 205.94,33.8 212.94,33.8 217.13,37.98 224.44,37.98 225.11,37.31 229.93,37.31 232.69,40.08 240.74,40.08 241.43,40.77 249.86,40.77 251.6,42.52 253.61,42.52 254.95,43.85 254.95,46.11 254.27,46.79 254.27,53.67 255.72,55.13 261.75,55.13 262.21,54.67 266.1,54.67 270.76,59.33 270.76,60.07 274.28,63.59 274.28,65.16 275.9,66.79 277.71,66.79 279.14,68.22 279.14,69.72 280.28,70.86 280.28,74.43 282.53,76.68 282.53,80.84 281.49,81.88 281.49,87.1 281.72,87.33 281.72,88.79 285.09,92.16 288.77,92.16 292.03,95.42 292.03,105.26 289.44,107.86 289.44,112.76 288.58,113.62 288.58,116.95 287.91,117.61 287.91,121.39 296.3,129.78 303.51,129.78 304.4,130.66 305.48,130.66 308.04,133.23 308.04,133.6 v2(307.63,134.02)
  BOTTOM w0.102: R5131.2 34.07,17.08 33.89,17.25 32.34,17.25 v2(31.88,16.8)
GSPI1_MOSI: length 13.8
  TOP w0.102: v2(234.47,55.56) 235.11,54.92 236.73,54.92 236.86,55.05 238.31,55.05 239.51,53.85 239.79,53.85 240.14,53.5 240.95,53.5 241.21,53.76 241.96,53.76 242.51,54.31 245.32,54.31 v1(245.42,54.41) R2424.2
  BOTTOM w0.102: U2000.AT29 234.47,55.73 v2(234.47,55.56)
H_BPM_N0: length 34.8
  TOP w0.089: v3(75.36,122.83) 75.11,122.58 v1(75.11,122.05)
  IN4 w0.083: v3(75.36,122.83) 75.36,122.3 75.14,122.08 72.29,122.08 71.55,122.82 66.32,122.82 63.27,125.87 63.27,127.52 62.74,128.05 62.74,133.99 63.73,134.98 63.73,138.7 63.08,139.36 63.08,141.77 v2(63.94,142.63)
  BOTTOM w0.102: U0300.BR27 75.36,122.76 v3(75.36,122.83)
  BOTTOM w0.121: SR4404.2 64.41,143.1 v2(63.94,142.63)
H_BPM_N0_R: length 4.9
  BOTTOM w0.121: XDP4400.21 62.1,141.45 63.57,142.92 SR4404.1 63.57,143.99 v1(64.01,144.43)
H_BPM_N1: length 29.4
  IN4 w0.083: v2(63.86,140.32) 63.46,139.92 63.46,139.52 64.12,138.86 64.12,134.82 63.13,133.83 63.13,128.21 63.66,127.68 63.66,126.03 66.47,123.21 72.3,123.21 v3(73.04,122.47)
  BOTTOM w0.076: U0300.BT27 74.23,122.44 73.82,122.84 73.41,122.84 v3(73.04,122.47)
  BOTTOM w0.121: SR4405.2 63.4,140.77 v2(63.86,140.32) 64.07,140.11 v1(64.5,140.11)
H_BPM_N1_R: length 3.8
  BOTTOM w0.121: XDP4400.23 62.23,140.95 63.03,141.75 SR4405.1 64.31,141.75 v1(64.4,141.84)
H_CFG0: length 43.9
  TOP w0.102: v2(62.46,127.74) v1(63.18,127.74) ; v3(76.66,121.25) 76.42,121.5 R0702.1
  IN4 w0.102: v2(62.68,144.58) 63.2,144.07 63.2,142.78 62.32,141.9 62.32,137.7 62.31,137.69 62.31,137.35 62.32,137.35 62.32,136.94 62.31,136.93 62.31,136.59 62.32,136.59 62.32,127.89 v2(62.46,127.74) 62.87,127.34 62.87,125.7 66.15,122.42 68.43,122.42 69.16,121.7 70.29,121.7 70.54,121.95 71.71,121.95 72.35,121.32 75.54,121.32 75.85,121.64 76.28,121.64 v3(76.66,121.25)
  BOTTOM w0.102: v3(76.66,121.25) 76.66,121.19 U0300.BN25 ; v2(62.46,127.74) 61.52,127.74 61.26,127.49 61.26,126.04 61.43,125.88 61.43,125.1 R4416.2 ; XDP4400.9 62.55,144.45 v2(62.68,144.58)
H_CFG1: length 39.1
  TOP w0.102: v3(76.66,122.83) 76.26,123.23 74.35,123.23 R0701.1 73.19,123.12 v1(69.4,123.12) 68.95,123.12 68.11,122.28 v2(64.45,122.28)
  IN4 w0.102: v2(64.45,122.28) 64.45,123.55 61.77,126.23 61.77,137.61 61.55,137.83 61.55,143.24 62.19,143.87 v2(62.72,143.87)
  BOTTOM w0.102: v2(62.72,143.87) 62.64,143.95 XDP4400.11 ; v3(76.66,122.83) 76.34,122.5 U0300.BN27
H_CFG2: length 37.5
  TOP w0.102: v3(76.01,121.25) 74.92,121.25 R0723.1
  IN4 w0.102: v3(76.01,121.25) 75.74,120.98 71.74,120.98 71.36,121.37 66.92,121.37 61.98,126.31 61.98,137.7 61.75,137.92 61.75,141.97 v6(62.74,142.95)
  BOTTOM w0.102: U0300.BN26 76.34,121.58 v3(76.01,121.25) ; XDP4400.15 v6(62.74,142.95)
H_CFG3: length 51.4
  TOP w0.102: v3(76.01,122.83) 76.01,122.34 75.29,121.62 74.45,121.62 74,122.08 72.27,122.08 71.89,122.46 71.07,122.46 R0725.1 70.64,121.52 69.98,120.86 66.15,120.86 v2(66.07,120.78) 65.67,120.78 v1(65.46,120.58)
  IN4 w0.102: v2(58.89,143.34) 60.84,141.39 60.84,137.68 61.16,137.36 61.16,125.72 62.29,124.59 62.29,122.77 64.27,120.78 v2(66.07,120.78)
  BOTTOM w0.102: XDP4400.17 59.49,142.45 58.89,143.06 v2(58.89,143.34) 58.89,144.95 59.65,145.71 59.65,146.62 59.85,146.82 60.61,146.82 61.17,147.38 61.17,148.55 61.8,149.18 R4422.2 ; U0300.BN28 76.01,122.9 v3(76.01,122.83)
H_CFG4: length 52.8
  TOP w0.089: R0724.1 72.24,117.8 72.34,117.8 R0754.2 71.76,117.51 v3(71.63,117.38)
  IN4 w0.102: v2(57.97,140.9) 58.17,140.7 58.17,139.56 58.03,139.42 58.03,134.25 55.61,131.82 55.61,130.26 56.34,129.52 56.34,128.7 55.74,128.1 55.74,127.4 57.08,126.06 57.08,120.47 58.26,119.29 61.48,119.29 62.85,117.92 64.81,117.92 65.5,117.23 71.48,117.23 v3(71.63,117.38)
  BOTTOM w0.102: U0300.BR20 74.71,117.25 71.76,117.25 v3(71.63,117.38) ; v1(65.26,138.54) 64.37,138.54 62.96,139.95 XDP4400.27 58.92,139.95 v2(57.97,140.9)
H_CFG5: length 58.4
  TOP w0.102: v3(76.66,116.53) 76.28,116.91 75.08,116.91 74.93,117.05 R0745.2 R0703.1
  IN4 w0.102: v3(76.66,116.53) 76.28,116.15 74.95,116.15 74.53,116.57 65.44,116.57 64.53,117.48 62.72,117.48 61.31,118.88 58.1,118.88 55.73,121.24 55.73,125.95 53.91,127.78 53.91,131.01 57.61,134.72 57.61,137.75 57.3,138.07 v2(57.3,140.79)
  BOTTOM w0.102: U0300.BM20 76.99,116.85 v3(76.66,116.53) ; v2(57.3,140.79) 58.63,139.45 XDP4400.29 63.03,139.45 63.76,138.72 63.76,137.57 v1(64.07,137.27)
H_CFG6: length 38.3
  IN4 w0.102: v2(59.49,138.59) 59.65,138.59 60.96,137.28 60.96,125.63 62.08,124.51 62.08,122.61 64.36,120.33 v2(68.39,120.33)
  BOTTOM w0.102: U0300.BT20 74.25,116.78 70.9,116.78 69.03,118.66 69.03,119.7 v2(68.39,120.33) 67.87,120.33 67.37,120.83 R0744.2 66.66,120.83 66.5,120.68 66.5,120.44 R0705.1 66.1,120.17 65.59,120.68 65.59,120.89 v1(65.34,121.14) ; v2(59.49,138.59) 59.63,138.45 XDP4400.33
H_CFG7: length 35.7
  TOP w0.102: v2(69.01,120.45) 70.65,120.45 v1(71.35,119.74) 71.76,119.34 74.17,119.34 R0709.1 74.91,118.6 74.91,118.02 75.21,117.72 75.6,117.72 v3(76.01,117.32)
  IN4 w0.102: v2(59.49,137.95) 59.73,137.95 60.76,136.92 60.76,125.55 61.14,125.16 61.14,123.26 64.28,120.12 67.93,120.12 68.12,119.93 68.56,119.93 69.01,120.37 v2(69.01,120.45)
  BOTTOM w0.102: v3(76.01,117.32) 75.69,116.99 U0300.BP20 ; XDP4400.35 v2(59.49,137.95)
H_CFG8: length 45
  TOP w0.089: v3(73.78,119.94) v1(73.16,119.94)
  IN4 w0.102: v3(73.78,119.94) 73.12,119.29 71.48,119.29 70.36,120.4 69.6,120.4 68.1,118.9 67.01,118.9 66.66,119.26 63.28,119.26 59.14,123.41 59.14,132.71 59.77,133.34 59.77,137.1 59.09,137.78 59.09,138.77 59.9,139.58 59.9,140.91 58.95,141.87 58.95,142.47 57.8,143.62 v2(57.8,143.86)
  BOTTOM w0.102: U0300.BR23 74.6,119.72 74.01,119.72 v3(73.78,119.94) ; XDP4400.10 57.21,144.45 v2(57.8,143.86)
H_CFG9: length 51.3
  TOP w0.102: v2(70.45,119.15) 68.89,119.15 68.64,119.41 R0700.2 67.93,119.41 67.62,119.72 67.25,119.72 66.94,119.4 66.94,118.37 v1(66.53,117.96) 65.22,116.65 v2(64.41,116.65)
  IN4 w0.102: v2(57.12,143.95) 56.88,143.71 56.88,138.16 57.41,137.62 57.41,134.81 53.7,131.1 53.7,127.69 55.53,125.86 55.53,121.16 58.01,118.68 61.23,118.68 62.75,117.15 63.91,117.15 v2(64.41,116.65)
  BOTTOM w0.102: v2(70.45,119.15) 71.02,118.59 72.79,118.59 73.18,118.98 74.12,118.98 74.26,118.84 74.69,118.84 U0300.BR22 ; XDP4400.12 v2(57.12,143.95)
H_CFG10: length 42.3
  TOP w0.102: v1(69.58,119.74) 70.4,119.74 v2(70.42,119.76)
  IN4 w0.102: v2(70.42,119.76) 68.98,118.32 65.59,118.32 64.88,119.03 63.23,119.03 58.88,123.37 58.88,138.85 58.99,138.95 58.99,141.54 58.02,142.51 v2(58.02,142.78)
  BOTTOM w0.102: XDP4400.16 56.79,142.95 57.08,143.24 57.87,143.24 58.02,143.09 v2(58.02,142.78) ; U0300.BT23 73.9,119.29 73.65,119.53 70.66,119.53 v2(70.42,119.76)
H_CFG11: length 41.4
  TOP w0.102: v1(69.58,117.96) 69.65,118.04 v2(70.31,118.04)
  IN4 w0.102: v2(57.38,142.78) 58.78,141.38 58.78,139.3 58.68,139.2 58.68,123.29 63.14,118.83 64.79,118.83 65.58,118.04 v2(70.31,118.04)
  BOTTOM w0.102: XDP4400.18 57.05,142.45 v2(57.38,142.78) ; v2(70.31,118.04) 70.49,118.22 72.8,118.22 73.31,118.73 73.95,118.73 74.17,118.5 U0300.BT22
H_CFG12: length 47.3
  IN4 w0.102: v6(57.77,139.73) 57.58,139.54 57.58,138.07 57.82,137.84 57.82,134.37 54.11,130.66 54.11,128.02 56.78,125.36 56.78,120.49 58.18,119.08 61.4,119.08 62.8,117.68 64.72,117.68 65.49,116.91 76.93,116.91 v3(77.31,116.53)
  BOTTOM w0.102: v3(77.31,116.53) 76.99,116.21 U0300.BM19 ; v6(57.77,139.73) 57.54,139.95 XDP4400.28
H_CFG13: length 64.9
  IN4 w0.102: v2(58.48,146.57) 62.77,146.57 64.72,144.61 64.72,134.57 63.73,133.58 63.73,128.45 64.26,127.93 64.26,126.41 64.7,125.97 v2(67.16,125.97)
  BOTTOM w0.102: XDP4400.30 53.68,139.45 52.53,140.6 52.53,143.36 51.75,144.15 51.75,146.49 52.05,146.79 58.25,146.79 v2(58.48,146.57) ; U0300.BR19 74.66,115.76 71.36,115.76 69.22,117.89 66.06,117.89 64.85,119.09 64.85,122.97 66.33,124.44 v1(66.33,124.64) 66.33,125.13 v2(67.16,125.97)
H_CFG14: length 45.5
  TOP w0.102: v2(66.41,118.8) 66.41,118.61 65.77,117.96 v1(64.75,117.96) 63.73,116.95 v2(63.73,116.69)
  IN4 w0.102: v2(56.98,137.45) 57.21,137.22 57.21,134.89 53.5,131.18 53.5,127.61 55.33,125.78 55.33,121.07 57.93,118.47 61.14,118.47 62.92,116.69 v2(63.73,116.69)
  BOTTOM w0.102: XDP4400.34 56.33,138.45 56.98,137.8 v2(56.98,137.45) ; U0300.BP19 75.26,116.57 70.83,116.57 69.28,118.12 67.1,118.12 v2(66.41,118.8)
H_CFG15: length 42.7
  TOP w0.102: v3(73.17,116.19) 73.17,116.17 v1(72.47,115.48)
  IN4 w0.102: v2(56.8,136.81) 56.8,134.77 53.22,131.19 53.22,122.89 57.87,118.24 61.04,118.24 63.1,116.19 v3(73.17,116.19)
  BOTTOM w0.102: XDP4400.36 56.3,137.95 56.57,137.68 56.57,137.04 v2(56.8,136.81) ; v3(73.17,116.19) 73.22,116.14 U0300.BT19
H_CFG16: length 42.9
  IN4 w0.102: v3(75.36,119.68) 74.73,120.31 73.95,120.31 73.94,120.33 73.62,120.33 73.61,120.31 71.29,120.31 70.67,120.94 66.49,120.94 66.24,121.19 64.15,121.19 63.25,122.09 63.25,124.13 61.37,126.01 61.37,137.44 61.04,137.77 61.04,143.61 59.15,145.5 v6(58.63,145.5)
  BOTTOM w0.102: v6(58.63,145.5) 58.22,145.09 56.85,145.09 56.49,145.45 XDP4400.6 ; v3(75.36,119.68) 75.69,119.35 U0300.BP23
H_CFG17: length 47.6
  IN4 w0.102: v2(59.18,145.95) 61.35,143.79 61.35,137.75 61.57,137.53 61.57,126.1 63.46,124.21 63.46,122.17 64.23,121.39 66.32,121.39 66.58,121.14 70.77,121.14 71.39,120.52 73.52,120.52 73.54,120.53 74.02,120.53 74.03,120.52 75.17,120.52 v3(76.01,119.68)
  BOTTOM w0.102: v2(59.18,145.95) 58.12,145.95 57.9,145.73 56.95,145.73 56.73,145.95 XDP4400.4 54.23,145.95 53.63,145.35 52.84,145.35 52.23,145.96 v1(52.23,146.29) ; U0300.BN23 76.01,119.61 v3(76.01,119.68)
H_CFG18: length 50.9
  IN4 w0.102: v3(76.01,118.1) 75.63,118.49 71.62,118.49 70.57,117.43 65.58,117.43 64.59,118.42 62.97,118.42 57.39,124 57.39,126.11 55.94,127.56 55.94,128.01 56.55,128.62 56.55,129.61 55.81,130.34 55.81,131.74 58.24,134.16 58.24,139.33 58.38,139.47 58.38,141.07 57.88,141.56 v2(57.44,141.56)
  BOTTOM w0.102: v1(52.23,144.33) 52.94,143.63 52.94,141.59 53.58,140.95 XDP4400.24 56.62,140.95 57.23,141.56 v2(57.44,141.56) ; U0300.BN22 76.34,118.43 v3(76.01,118.1)
H_CFG19: length 45.6
  TOP w0.089: v3(76.01,118.89) 75.97,118.85 v1(75.39,118.85)
  IN4 w0.102: v3(76.01,118.89) 71.74,118.89 70.48,117.63 70.15,117.63 70.13,117.65 65.65,117.65 64.67,118.63 63.06,118.63 57.89,123.79 57.89,126.55 56.94,127.5 56.94,128.67 56.75,128.86 56.75,129.69 56.01,130.43 56.01,131.65 58.48,134.12 58.48,139.29 58.58,139.39 58.58,141.15 57.56,142.17 v2(57.36,142.17)
  BOTTOM w0.102: XDP4400.22 56.64,141.45 v2(57.36,142.17) ; v3(76.01,118.89) 75.69,118.57 U0300.BP22
H_PECI_EC: length 4.5
  TOP w0.121: U3002.117 161.74,29.11 v2(160.13,27.5)
  BOTTOM w0.121: R0733.1 159.82,27.8 v2(160.13,27.5) 159.86,27.5 v1(159.54,27.19)
H_PRDY#: length 395
  TOP w0.076: v3(73.65,122.46) 73.27,122.85 70.64,122.85
  TOP w0.102: 70.64,122.85 70.22,122.85 69.75,122.38 69.75,121.65 69.5,121.39 65.81,121.39 65.63,121.22 64.19,121.22 63.66,121.75 62.29,121.75 62.11,121.57 62.11,117.76 61.07,116.72 59.62,116.72 58.83,115.93 v1(57.13,115.93) 56.32,115.12 v2(53.73,115.12)
  IN3 w0.102: v2(237.19,73.29) 236.51,72.6 234.42,72.6 232.03,75 232.03,75.89 230.99,76.92 220.68,76.92 218.56,74.81 218.56,73.63 217.25,72.33 215.8,72.33 213.52,70.05 213.06,70.05 211.03,68.01 211.03,65.81 210.31,65.08 209.45,65.08 208.03,63.66 204.27,63.66 200.08,59.48 200.08,48.4 195.87,44.18 195.87,43.97 192.15,40.25 171.5,40.25 170.29,39.05 152.54,39.05 146.61,44.98 135.69,44.98 135.57,44.86 134.3,44.86 129.4,39.96 121.85,39.96 119.34,37.45 103.23,37.45 96.57,30.79 61.42,30.79 57.84,27.21 45.55,27.21 41.26,31.5 41.26,40.03 36.3,44.99 36.3,70.94 51.9,86.54 51.9,98.7 48.44,102.17 48.44,110.05 52.24,113.85 52.69,113.85 53.32,114.48 53.32,114.71 v2(53.73,115.12)
  IN4 w0.102: v2(62.69,145.22) 64.52,143.38 64.52,134.66 63.53,133.67 63.53,128.37 64.05,127.85 64.05,126.19 66.34,123.91 71.91,123.91 72.04,124.04 72.55,124.04 73.65,122.94 v3(73.65,122.46)
  BOTTOM w0.102: 238.06,74.78 237.72,74.78 237.62,74.68 237.62,73.46 237.45,73.29 v2(237.19,73.29) ; U0300.BP27 75.36,122.1 74.01,122.1 v3(73.65,122.46) ; v2(62.69,145.22) 62.45,145.45 XDP4400.5
H_PREQ#: length 46.5
  TOP w0.102: R0738.2 v2(65.28,121.83)
  IN1 w0.102: v2(65.28,121.83) 65.28,124.72 v2(67.16,126.6)
  IN4 w0.102: v2(67.16,126.6) 64.71,126.6 64.46,126.85 64.46,128.02 63.94,128.54 63.94,133.5 64.93,134.49 64.93,143.54 v2(65.77,144.38)
  BOTTOM w0.076: 72.96,124.44 73.36,124.04 73.84,124.04 74.17,124.36 77.32,124.36 U0300.BL30
  BOTTOM w0.089: 72.96,124.52 72.96,124.44
  BOTTOM w0.102: R4403.1 66.07,144.08 v2(65.77,144.38) 64.75,145.4 64.75,145.7 v1(64.01,146.44) 63.86,146.29 62.74,146.29 62.41,145.95 XDP4400.3 ; 72.96,124.52 72.12,125.36 69.86,125.36 68.61,126.6 v2(67.16,126.6)
H_TCK: length 393.8
  TOP w0.076: 70.68,122.46 70.8,122.46 70.99,122.66 72.3,122.66 v3(72.48,122.47)
  TOP w0.102: v2(62.52,121.32) v1(63.3,121.32) 63.61,121.01 65.72,121.01 65.89,121.19 69.83,121.19 70.14,121.5 70.14,122.28 70.31,122.46 70.68,122.46
  IN3 w0.102: v2(59.54,130.18) 54.02,135.71 53.49,135.71 51.82,134.04 51.82,130.96 53.63,129.15 53.63,126.95 52.81,126.13 52.81,121.6 54.13,120.28 54.13,111.04 49.05,105.96 49.05,102.42 52.51,98.96 52.51,84.72 37.12,69.32 37.12,45.04 41.87,40.29 41.87,31.75 45.8,27.82 57.59,27.82 61.4,31.63 96.55,31.63 102.98,38.07 119.1,38.07 121.66,40.63 129.21,40.63 134.04,45.47 135.32,45.47 135.44,45.59 147.59,45.59 152.91,40.27 169.84,40.27 170.43,40.86 191.89,40.86 195.26,44.22 195.26,44.43 199.29,48.47 199.29,59.74 203.92,64.37 203.92,66.35 206.01,68.44 206.01,69.05 206.31,69.34 206.31,70.26 207.05,71 213.6,71 215.54,72.94 216.65,72.94 217.95,74.24 217.95,75.06 220.43,77.53 231.6,77.53 233.33,75.8 234.68,75.8 234.96,75.53 234.96,74.25 v2(235.9,73.31)
  IN4 w0.102: v2(59.54,130.18) 60.1,130.18 60.55,129.73 60.55,125.46 60.94,125.08 60.94,122.89 v2(62.52,121.32)
  BOTTOM w0.076: U0300.BR28 74.71,122.89 74.1,122.89 73.94,123.05 73.31,123.05 73.13,122.87 72.02,122.87
  BOTTOM w0.102: 72.02,122.87 71.91,122.87 71.02,123.76 R0741.1 71.85,122.47 v3(72.48,122.47) ; v2(235.9,73.31) 235.87,73.34 235.87,74.67 235.98,74.77 SR2305.2 ; v2(59.54,130.18) 59.29,130.44 59.29,131.88 59.86,132.45 XDP4400.57
H_TDI: length 375.7
  TOP w0.076: v3(78.16,125.78) 77.58,126.36 73.81,126.36 73.13,127.03 73.13,128.32 73.11,128.34 71.62,128.34 71.21,127.93 R4427.2
  TOP w0.102: R4427.2 70.39,128.35 69.13,128.35 68.73,127.95 64.27,127.95 62.44,129.78 v1(62.08,129.78) 58.99,129.78 58.63,130.13 v2(57.16,130.13)
  IN2 w0.102: v2(53.07,113.39) 53.12,113.39 53.22,113.49 53.22,125.99 53.85,126.63 53.85,128.86 55.02,130.03 56.5,130.03 56.6,130.13 v2(57.16,130.13)
  IN3 w0.102: v2(53.07,113.39) 52.89,113.57 52.25,113.57 48.65,109.97 48.65,102.25 52.11,98.79 52.11,86.46 36.51,70.85 36.51,45.08 41.47,40.12 41.47,31.58 45.64,27.41 57.76,27.41 61.34,31 96.49,31 103.14,37.65 119.26,37.65 121.77,40.16 129.31,40.16 134.21,45.07 135.49,45.07 135.6,45.18 147.36,45.18 152.68,39.86 170.01,39.86 170.6,40.45 192.06,40.45 195.66,44.05 195.66,44.26 199.8,48.4 199.8,59.49 205.12,64.8 208.66,64.8 209.2,65.34 210.28,65.34 210.83,65.89 210.83,68.19 213.07,70.44 213.63,70.44 215.71,72.53 217.17,72.53 218.36,73.72 218.36,74.89 220.6,77.13 231.08,77.13 232.23,75.97 232.23,75.37 v2(234.41,73.18)
  BOTTOM w0.102: v2(234.41,73.18) 234.52,73.18 235,73.66 235,74.58 235.19,74.77 SR2304.2 ; XDP4400.56 56.66,132.95 56.88,132.73 56.88,130.41 v2(57.16,130.13) ; v3(78.16,125.78) 78.09,125.78 U0300.BL32
H_TDO: length 373.2
  TOP w0.102: v2(67.16,124.95) v1(66.47,125.64) 66.04,125.64 62.85,128.84 58.84,128.84 57.95,129.73 56.99,129.73 56.75,129.96 56.75,130.36 v2(57.59,131.2)
  IN2 w0.102: v2(52.42,113.16) 52.42,113.56 53.02,114.15 53.02,126.08 53.65,126.71 53.65,128.95 55.9,131.2 v2(57.59,131.2)
  IN3 w0.102: v2(52.42,113.16) 48.85,109.6 48.85,102.33 52.31,98.87 52.31,86.37 36.71,70.77 36.71,45.16 41.67,40.2 41.67,31.67 45.72,27.62 57.67,27.62 61.25,31.2 96.4,31.2 103.07,37.86 119.18,37.86 121.75,40.43 129.29,40.43 134.13,45.27 135.41,45.27 135.52,45.38 147.49,45.38 152.81,40.07 169.92,40.07 170.51,40.65 191.98,40.65 195.46,44.14 195.46,44.35 199.55,48.44 199.55,59.52 205.07,65.04 208.59,65.04 209.1,65.55 210.2,65.55 210.62,65.97 210.62,68.29 212.99,70.65 213.55,70.65 215.63,72.73 217.09,72.73 218.16,73.8 218.16,74.97 220.51,77.33 231.45,77.33 233.33,75.45 233.33,75.19 233.57,74.95 234.14,74.95 v2(234.55,75.36)
  BOTTOM w0.076: 72.14,123.07 72.99,123.07 73.14,123.22 74.02,123.22 74.02,123.22 U0300.BT28
  BOTTOM w0.102: SR2303.2 234.58,75.33 v2(234.55,75.36) ; v2(67.16,124.95) 66.76,124.54 66.76,124.15 67,123.91 67.47,123.91 67.67,124.11 R0739.2 68.04,124.42 68.75,125.13 69.3,125.13 69.63,124.8 70.28,124.8 72.01,123.07 72.14,123.07 ; v2(57.59,131.2) 57.59,133.13 56.77,133.95 XDP4400.52
H_THMTRIP#: length 238.2
  IN3 w0.083: v2(226.19,72.98) 225.25,72.98 223.93,71.66 221.8,71.66 218.01,67.87 218.01,66.44 217.31,65.73 214.12,65.73 213.75,65.37 213.75,64.66 211,61.91 211,60.87 210.4,60.26 208.37,60.26 205.98,57.88 203.09,57.88 203.06,57.86 203.06,54.46 204.64,52.88 204.64,48.08 194.85,38.28 194.32,38.28 192.28,36.24 162.38,36.24 162,35.86 150.14,35.86 143.96,42.03 136.14,42.03 135.2,41.09 133.28,41.09 130.14,37.95 127.85,37.95 v2(127.5,37.61)
  IN4 w0.083: v2(129.09,76.84) 129.09,82.05 129.45,82.42 129.45,87.82 128.99,88.29 128.99,104.31 123.71,109.58 123.71,120 121.84,121.88 119.92,121.88 119.56,122.23 119.56,122.51 118.63,123.44 117.16,123.44 116.78,123.82 114.73,123.82 114.38,123.48 113.57,123.48 112.82,124.23 111.32,124.23 110.75,124.79 v3(110.75,125.46)
  BOTTOM w0.121: U0300.J31 v3(110.75,125.46) ; R2450.2 225.23,74.81 225.18,74.76 R2454.2 225.58,73.69 225.58,73.58 v2(226.19,72.98) ; v2(129.09,76.84) 128.24,75.99 128.24,67.86 129.17,66.93 129.17,65.49 129.43,65.22 v1(129.43,56.46) 129.43,55.52 134.13,50.82 134.13,47.44 130.46,43.77 130.46,40.56 v2(127.5,37.61)
H_TMS: length 375.9
  TOP w0.102: v2(54.55,128.19) 55.85,128.19 57.18,129.52 57.87,129.52 58.96,128.43 59.75,128.43 62.53,125.65 v1(64.65,125.65) 65.98,124.31 v2(67.16,124.31)
  IN3 w0.102: v2(54.55,128.19) 54.03,127.67 54.03,126.78 53.22,125.97 53.22,121.95 55.38,119.79 55.38,111.65 49.46,105.74 49.46,102.59 52.94,99.11 52.94,84.57 37.52,69.16 37.52,45.31 42.48,40.35 42.48,31.72 45.97,28.23 54.57,28.23 58.38,32.04 96.32,32.04 102.76,38.47 118.93,38.47 121.57,41.12 129.11,41.12 133.88,45.88 135.15,45.88 135.43,46.16 147.68,46.16 153.17,40.68 169.67,40.68 170.26,41.26 191.72,41.26 194.85,44.39 194.85,44.6 198.76,48.51 198.76,59.78 203.39,64.42 203.39,67 205.17,68.78 205.17,69.7 206.88,71.4 213.44,71.4 215.65,73.62 215.65,76.16 217.43,77.94 231.8,77.94 233.53,76.21 235.95,76.21 236.13,76.03 236.51,76.03 v2(237.17,75.37)
  BOTTOM w0.076: U0300.BP28 75.37,123.54 73.19,123.54 72.92,123.27 72.29,123.27
  BOTTOM w0.102: XDP4400.58 56.49,132.45 56.62,132.32 56.62,129.04 55.77,128.19 v2(54.55,128.19) ; 72.29,123.27 72.09,123.27 70.36,125 69.72,125 69.39,125.33 68.55,125.33 68.38,125.16 R4428.2 67.74,124.86 67.71,124.86 v2(67.16,124.31) ; SR2302.2 v2(237.17,75.37)
H_TRIGIN: length 214.9
  IN3 w0.083: v3(109.24,118.93) 110.09,118.08 110.09,117.71 110.75,117.05 112.91,117.05 114.92,115.04 114.92,114.06 121.15,107.82 121.15,105.34 120.34,104.52 120.34,88.74 120.55,88.53 120.55,88.53 121.4,87.69 121.4,86.11 120.75,85.47 120.75,75.3 124.85,71.2 124.85,65.05 132.05,57.84 133.72,57.84 138.55,53.01 138.55,51.69 v2(138.02,51.15) ; v2(136.28,43.8) 145.9,43.8 150.13,39.57 150.13,39.16 151.41,37.88 170.78,37.88 171.57,38.67 192.3,38.67 196.59,42.95 197.15,42.95 201.38,47.18 201.38,50.58 201.83,51.04 201.83,51.89 201.38,52.35 201.38,59.12 204.75,62.49 208.73,62.49 209.8,63.56 210.46,63.56 212.2,65.3 212.2,66.07 212.73,66.6 212.73,67.47 214.23,68.97 215.63,68.97 216.98,70.32 217.84,70.32 218.02,70.49 218.02,70.84 221.91,74.73 222.97,74.73 223.99,75.75 229.81,75.75 v2(230.21,75.35)
  BOTTOM w0.102: v3(109.24,118.93) 109.42,119.11 110.01,119.11 U0300.H23
  BOTTOM w0.121: v2(136.28,43.8) 136.56,44.08 v1(136.56,45.27) 136.56,50.1 137.61,51.15 v2(138.02,51.15) ; R2326.2 v2(230.21,75.35)
H_TRIGOUT: length 227.3
  TOP w0.121: v2(126.09,117.96) 124.95,119.11 124.95,120.15 123.2,121.9 v1(123.19,121.9) 123.14,121.95 120,121.95 119.16,121.11 116.49,121.11 116.16,121.44 113.16,121.44 112.99,121.62 R0743.1
  IN2 w0.083: v2(126.09,117.96) 125.99,117.86 125.99,98.51 125.46,97.97 125.46,76.82 128.98,73.29 128.98,71.69 129.59,71.08 129.59,53 133.25,49.33 133.25,46.21 v2(135.64,43.82)
  IN3 w0.083: v2(230.26,71.9) 230.78,71.9 231.24,72.36 231.24,75.53 230.63,76.14 223.83,76.14 222.81,75.12 221.36,75.12 217.76,71.52 216.23,71.52 212.35,67.63 212.35,66.76 211.81,66.23 211.81,65.46 210.37,64.02 209.7,64.02 208.55,62.88 204.59,62.88 200.97,59.26 200.97,52.21 201.45,51.73 201.45,51.2 200.97,50.72 200.97,47.32 196.99,43.34 196.42,43.34 192.14,39.06 171.41,39.06 170.62,38.26 151.57,38.26 150.62,39.21 150.62,39.62 146.05,44.19 136.11,44.19 135.74,43.82 v2(135.64,43.82)
  BOTTOM w0.121: v2(230.26,71.9) 230.44,71.9 231.52,70.82 U2000.AK1
H_TRIGOUT_R: length 2.4
  TOP w0.089: R0743.2 v1(110.01,119.87) 109.66,119.51 v3(109.23,119.51)
  BOTTOM w0.102: U0300.J23 v3(109.23,119.51)
H_TRST#: length 389.3
  TOP w0.102: SR2301.2 235.12,74.77 234.96,74.61 234.96,73.08 v2(235.03,73.01) ; v2(57.59,130.59) 58.45,130.59 v1(59.1,131.24) 59.85,130.49 62.23,130.49 64.56,128.15 68.54,128.15 69,128.61 71.08,128.61 v3(71.1,128.58)
  IN3 w0.102: v2(57.59,130.59) 57.18,131 57.18,132.23 53.91,135.5 53.57,135.5 52.03,133.96 52.03,131.04 53.83,129.24 53.83,126.86 53.02,126.05 53.02,121.68 54.34,120.36 54.34,110.96 49.26,105.88 49.26,102.5 52.72,99.04 52.72,84.64 37.32,69.24 37.32,45.13 42.08,40.37 42.08,31.84 45.89,28.02 57.5,28.02 61.31,31.83 96.41,31.83 102.84,38.27 119.01,38.27 121.66,40.91 129.2,40.91 133.96,45.68 135.24,45.68 135.35,45.79 147.71,45.79 153.03,40.47 169.76,40.47 170.34,41.06 191.81,41.06 195.05,44.3 195.05,44.52 199.03,48.49 199.03,59.76 203.67,64.41 203.67,66.41 205.8,68.54 205.8,69.16 206.1,69.46 206.1,70.34 206.96,71.2 213.52,71.2 215.46,73.14 216.56,73.14 217.75,74.33 217.75,75.14 220.34,77.73 231.69,77.73 233.42,76 235.29,76 236.3,74.99 236.3,73.14 236.06,72.91 235.13,72.91 v2(235.03,73.01)
  BOTTOM w0.076: 73.82,125.86 73.91,125.95 74.47,125.95 74.71,125.71 74.71,125.43 74.96,125.18 75.31,125.18 U0300.BP30
  BOTTOM w0.102: R0740.1 70.87,128.81 v3(71.1,128.58) 71.4,128.58 72.26,127.72 72.26,127.6 72.42,127.43 72.42,126.35 73.08,125.69 73.64,125.69 73.82,125.86 ; XDP4400.54 56.63,133.45 57.13,132.95 57.13,130.67 57.21,130.59 v2(57.59,130.59)
HDA_AZRST#_L500MIL: length 10.6
  BOTTOM w0.102: U2000.BD8 238.79,66.35 238.84,66.39 239.25,66.39 239.92,67.06 239.92,68.02 240.72,68.82 240.72,68.94
  BOTTOM w0.121: 240.72,68.94 240.72,69.48 241.06,69.82 241.06,70.34 241.81,71.1 v1(242.02,71.1) 242.34,71.42 242.34,71.62 243.4,72.69 243.4,73.27 R2306.2
HDA_BCLK: length 287.6
  TOP w0.121: v2(46.26,29.98) 46.25,29.97 46.25,25.71 40.12,19.58 38.12,19.58 36.97,18.42 33.29,18.42 32.94,18.07 29.58,18.07 v1(29.3,17.78) 27.81,17.78 26.53,16.49 18.95,16.49 18.16,17.29 16.13,17.29 15.48,16.64 10.41,16.64 8.16,18.89 8.16,21.09 8.29,21.22 SR3603.2
  IN3 w0.083: v2(242.55,78.87) 242.17,79.25 239.35,79.25 239.12,79.02 236.57,79.02 235.73,79.86 216.64,79.86 210.1,73.32 205.04,73.32 199.44,67.73 199.44,64.85 195.45,60.85 195.45,47.9 193.73,46.18 190.17,46.18 187.16,43.17 169.9,43.17 169.53,43.55 154.62,43.55 149.37,48.8 140.66,48.8 140.06,48.19 133.78,48.19 128.41,42.82 120.86,42.82 118.22,40.18 102.05,40.18 96.6,34.72 49.63,34.72 45.86,30.96 45.86,30.38 v2(46.26,29.98)
  BOTTOM w0.121: R2301.1 243.44,75.53 243.55,75.64 243.55,76.19 243.44,76.31 C2301.1 243.01,77.25 243.01,78.41 v2(242.55,78.87)
HDA_BCLK_R: length 5.3
  TOP w0.121: U3600.6 8.54,25.99 9.07,25.46 v1(9.07,23.6) 8.9,23.43 C3629.1 8.11,23.03 8.29,22.85 SR3603.1
HDA_BITCLK_24MHZ_L500MIL: length 11.5
  BOTTOM w0.102: U2000.BA9 237.4,66.05 237.99,66.63 238.74,66.63 238.78,66.6 239.17,66.6 239.71,67.14 239.71,68.11 240.49,68.89 240.49,69.12
  BOTTOM w0.121: 240.49,69.12 240.49,69.58 240.83,69.92 240.83,70.83 242.9,72.9 242.9,73.61 R2301.2
HDA_RST#: length 293.5
  TOP w0.121: U3600.11 10.54,26.3 10.8,26.04 11.31,26.04 12.68,24.67 C3626.1 13.16,23.98 13.78,23.37 13.78,19.58 14.3,19.06 19.34,19.06 19.55,18.85 20.17,18.85 20.58,19.26 20.58,20.2 21.25,20.87 21.71,20.87 21.95,20.63 21.95,20.15 21.7,19.9 Q3601.5 21.7,19.31 22.42,18.59 v1(25.93,18.59) 26.36,18.59 27.84,20.07 33.23,20.07 34.62,21.46 40.59,21.46 44.81,25.68 44.81,31.15 v2(43.95,32.01)
  IN3 w0.083: v2(43.95,32.01) 44.32,31.64 45.89,31.64 49.44,35.19 96.41,35.19 101.86,40.64 118.03,40.64 120.67,43.29 128.21,43.29 133.63,48.7 139.73,48.7 140.86,49.83 148.99,49.83 154.81,44.01 169.72,44.01 170.09,43.64 186.97,43.64 189.97,46.64 193.54,46.64 194.98,48.09 194.98,61.04 198.98,65.04 198.98,67.95 204.82,73.79 209.91,73.79 216.45,80.33 237.86,80.33 238.48,79.71 243.49,79.71 v2(244.33,78.87)
  BOTTOM w0.121: R2306.1 244.28,76.08 244.33,76.13 C2300.1 243.87,77.28 243.87,78.41 v2(244.33,78.87)
HDA_SDI0: length 299.7
  TOP w0.121: R3613.1 10.45,22.92 10.45,17.74 11.04,17.14 15.27,17.14 16.06,17.93 18.28,17.93 19.21,17 26.04,17 27.98,18.93 v1(31.6,18.93) 32.93,18.93 34.96,20.97 40.79,20.97 45.75,25.92 45.75,30.28 v2(46.26,30.79)
  IN3 w0.083: v2(241.77,78.27) 241.77,78.61 241.69,78.69 241.01,78.69 240.93,78.61 240.93,78.45 240.84,78.37 240.6,78.37 240.51,78.45 240.51,78.7 240.43,78.79 239.54,78.79 239.25,78.49 239.04,78.49 238.96,78.41 238.96,77.36 238.87,77.27 238.63,77.27 238.54,77.36 238.54,78.41 238.46,78.49 238.22,78.49 238.14,78.41 238.14,78.02 238.05,77.93 237.72,77.93 237.64,78.02 237.64,78.41 237.56,78.49 237.23,78.49 237.15,78.41 237.15,78.02 237.06,77.93 236.73,77.93 236.65,78.02 236.65,78.41 236.57,78.49 236.44,78.49 235.54,79.4 216.84,79.4 210.3,72.86 205.24,72.86 199.91,67.53 199.91,64.65 196.07,60.82 196.07,47.86 193.92,45.72 190.36,45.72 187.35,42.71 169.66,42.71 169.43,42.48 163.42,42.48 162.9,43 154.51,43 149.18,48.33 142.12,48.33 141.52,47.73 133.97,47.73 128.6,42.36 121.06,42.36 118.41,39.71 102.24,39.71 96.79,34.26 49.82,34.26 46.35,30.79 v2(46.26,30.79)
  BOTTOM w0.102: 240.13,68.83 239.51,68.21 239.51,67.23 239.21,66.93 239.1,66.93 U2000.BE7
  BOTTOM w0.121: 240.13,68.83 240.13,69.61 240,69.74 240,71.18 241.46,72.64 241.93,72.64 242.4,73.11 242.4,73.82 242.55,73.97 C2310.1 242.09,77.27 242.09,77.95 v2(241.77,78.27)
HDA_SDO: length 293.3
  TOP w0.121: U3600.5 8.14,25.42 7.93,25.2 7.93,24.82 7.55,24.44 7.55,23.22 7.65,23.12 7.65,18.69 10.74,15.6 v1(12.99,15.6) 13.43,16.04 14.96,16.04 15.02,15.98 26.8,15.98 28,17.18 30.16,17.18 30.47,17.49 33.07,17.49 33.5,17.92 37.25,17.92 38.41,19.08 40.44,19.08 46.95,25.58 v2(46.95,29.47)
  IN3 w0.083: v2(46.95,29.47) 47.15,29.67 47.15,31.07 50.13,34.05 96.88,34.05 102.33,39.5 118.5,39.5 121.14,42.15 128.69,42.15 134.06,47.52 141.6,47.52 142.2,48.12 149.09,48.12 154.42,42.79 162.81,42.79 163.33,42.27 169.52,42.27 169.75,42.5 187.44,42.5 190.44,45.51 194.01,45.51 197.11,48.61 197.11,61.56 200.12,64.57 200.12,67.43 205.33,72.65 210.38,72.65 216.92,79.19 235.45,79.19 236.24,78.4 236.24,77.11 236.48,76.87 240.06,76.87 240.24,77.05 v2(240.24,77.91)
  BOTTOM w0.121: v2(240.24,77.91) 240.24,77.45 240.88,76.81 C2303.1 242.27,76.2 242.27,74.81 R2308.1
HDA_SDO_L500MIL: length 21.2
  TOP w0.121: v2(241.66,73.05) 241.66,73.2 243.84,75.37 243.84,76.7 243.62,76.92 v1(243.62,77.55) 243.9,77.83 243.9,79.16 D2301.2 242.58,79.53 242.02,78.98 240.16,78.98 240.06,79.08 R2378.2
  IN1 w0.083: v2(241.66,73.05) 240.62,73.05 238.99,71.43 238.99,70.64 237.75,69.4 v2(237.75,67.55)
  BOTTOM w0.121: v2(241.66,73.05) 241.97,73.36 R2308.2 ; v2(237.75,67.55) 237.75,67.08 U2000.BB7
HDA_SPKR_LN: length 34.3
  TOP w0.229: U3600.43 5.25,29.37 5.24,29.38 3.73,29.38 v4(3.23,28.89)
  TOP w0.254: v1(2.52,28.53) 2.88,28.53 v4(3.23,28.89)
  IN4 w0.762: v4(3.23,28.89) 2.49,28.14 2.49,22.08 4.76,19.81 4.76,16.42 5.95,15.22 13.67,15.22 14.56,14.33 15.32,14.33 16.52,15.53 v4(16.52,16.72)
  BOTTOM w0.762: 15.81,18.92 15.81,18.17 16.52,17.46 v4(16.52,16.72)
HDA_SPKR_LP: length 38.4
  TOP w0.229: U3600.42 5.43,29.77 5.37,29.71 3.35,29.71 v4(3.18,29.88)
  IN4 w0.762: v4(3.18,29.88) 2.86,29.88 1.52,28.54 1.52,21.68 3.79,19.41 3.79,16.02 5.55,14.26 13.27,14.26 14.16,13.37 15.75,13.37 17.66,15.27 v4(17.66,16.75)
  BOTTOM w0.762: v4(17.66,16.75) 17.66,17.63 v1(17.29,18) 16.77,18.52 16.77,19.02
HDA_SPKR_RN: length 25
  TOP w0.229: v4(3.89,28.15) 3.89,28.31 4.63,29.05 5.1,29.05 5.18,28.97 U3600.44
  IN4 w0.762: v4(3.89,28.15) 3.55,27.81 3.55,25.34 7.19,21.7 7.19,20.15 5.82,18.78 v4(5.82,17.76)
  BOTTOM w0.762: v4(5.82,17.76) 6.92,16.67 9.15,16.67 10.12,15.7 13.54,15.7 14.46,16.62
  vias: v1(15.63,16.85)
HDA_SPKR_RP: length 20.1
  TOP w0.229: v4(4.88,28.46) 5,28.57 U3600.45
  TOP w0.762: v1(8.39,17) v4(7.8,17.58)
  IN4 w0.762: v4(4.88,28.46) 4.88,27.77 4.51,27.4 4.51,25.83 8.16,22.18 8.16,18.52 7.8,18.17 v4(7.8,17.58)
  BOTTOM w0.762: v4(7.8,17.58) 7.85,17.63 9.55,17.63 10.52,16.67 12.94,16.67
HDA_SYNC: length 291.6
  TOP w0.121: U3600.10 10.14,26.34 10.75,25.74 11.26,25.74 12.17,24.82 12.17,22.6 12.6,22.18 13.29,22.18 13.44,22.03 13.44,19.57 14.2,18.81 18.44,18.81 19.36,17.89 v1(23.37,17.89) 26.02,17.89 27.95,19.82 33.33,19.82 34.72,21.21 40.69,21.21 45.2,25.72 45.2,31.5 v2(44.66,32.04)
  IN3 w0.083: v2(245.24,78.92) 244.25,79.92 241.43,79.92 240.82,80.54 216.36,80.54 209.82,74 204.71,74 198.77,68.06 198.77,65.13 194.77,61.13 194.77,48.18 193.45,46.85 189.89,46.85 186.88,43.84 170.18,43.84 169.8,44.22 155.08,44.22 149.26,50.04 140.77,50.04 139.64,48.91 133.54,48.91 128.13,43.5 120.59,43.5 117.94,40.85 101.77,40.85 96.32,35.4 48.02,35.4 v2(44.66,32.04)
  BOTTOM w0.121: R2300.1 245.12,75.98 245.22,76.08 C2302.1 244.76,77.27 244.76,78.44 v2(245.24,78.92)
HDA_SYNC_L500MIL: length 13.6
  BOTTOM w0.102: 240.94,68.89 240.94,68.76 240.12,67.94 240.12,66.98 239.33,66.19 238.93,66.19 238.79,66.05 238.61,66.05 U2000.BD9
  BOTTOM w0.121: v1(245.9,75.9) 245.54,75.54 245.54,74.57 R2300.2 244.53,73.57 244.38,73.57 243.65,72.84 243.65,72.59 242.7,71.64 242.7,71.12 240.94,69.36 240.94,68.89
HDMI_CTRCLK_C: length 29.9
  TOP w0.121: v2(306.43,85.71) 306.51,85.78 R4807.2 C4809.1 ; U1301.32 298.4,86.69 v2(298.56,86.85) 298.56,86.88 299.12,87.43 R1308.1 300.54,87.43 v1(300.77,87.66)
  IN3 w0.083: CON4800.15 312.72,98.35 312.4,98.03 312.4,96.88 312.76,96.53 312.76,95.46 309.91,92.62 309.91,89.19 v2(306.43,85.71) 305.77,86.37 299.04,86.37 v2(298.56,86.85)
HDMI_CTRLDATA_C: length 31.3
  TOP w0.121: v1(309.3,85.17) 309.12,85 C4810.1 R4806.2 306.51,85 v2(306.43,85.07) ; U1301.33 298,86.9 297.92,86.98 R1309.1 298.51,87.43 v2(298.56,87.48)
  IN3 w0.083: v2(298.56,87.48) 298.15,87.08 298.15,86.6 298.86,85.88 305.49,85.88 306.3,85.07 v2(306.43,85.07) 306.56,85.07 310.41,88.92 310.41,92.45 314.03,96.08 314.03,97.1 314.63,97.7 CON4800.16
HDMI_HOTPLUG_DET: length 23.5
  TOP w0.102: v2(301.73,85.45) 300.98,84.7 U1301.28 ; CON4800.19 311.54,96.35 310.8,97.09 R4801.2 v2(310.11,96.5)
  BOTTOM w0.102: v2(310.11,96.5) 309.33,95.71 309.33,93.49 308.74,92.91 308.74,91.12 308.16,90.53 307.68,90.53 306.86,89.72 306.86,89 306.29,88.42 305.32,88.42 304.78,87.88 v1(304.78,86.34) 302.62,86.34 v2(301.73,85.45)
HDMI_OUT_5V_L1: length 6.8
  TOP w0.102: D4800.1 305.95,87.66 v1(305.95,84.51) 305.95,84.44 306.25,84.13 R4806.1
HDMI_OUT_5V_L2: length 2.2
  TOP w0.102: D4800.2 307.37,87.15 307.42,87.11 R4807.1 306.69,86.65 v1(306.46,86.42)
HDMI_OUT_CLK_N: length 18.6
  TOP w0.108: RN4803.1 307.93,91.32 308.16,91.55 309.1,91.55 v2(309.23,91.42) 309.33,91.52 309.98,91.52 C4811.2
  IN1 w0.076: CON4800.12 314.63,100.02 314.38,100.26 314.24,100.26 314.24,100.26 314.21,100.26 314.16,100.2 314.06,99.88 314.06,99.8 314.17,99.48 314.17,99.25 314.17,99.21 314.08,98.95 314.08,98.72 314.18,98.48 314.18,98.31 314.17,98.21 314.08,97.95 314.08,97.72 314.18,97.48 314.18,97.24 314.18,97.23 314.07,96.91 314.07,96.81 314.08,96.72 314.23,96.36 314.23,96 314.27,95.96 314.27,95.94
  IN1 w0.089: 314.27,95.94 314.27,95.09 313.57,94.39 313.57,93.25 312.51,92.2 311.86,92.2 311.46,92.59 311.46,93.43 311.3,93.59 310.81,93.59 310.61,93.39 310.61,91.74 310.29,91.42 v2(309.23,91.42)
HDMI_OUT_CLK_P: length 18.6
  TOP w0.108: RN4803.3 307.91,92.12 308.18,91.86 309.06,91.86 v2(309.23,92.03) 309.43,91.83 309.98,91.83 C4811.1
  IN1 w0.076: 314,95.94 314,95.96 314.04,96 314.04,96.32 313.89,96.68 313.88,96.78 313.88,96.98 313.99,97.28 313.99,97.45 313.89,97.68 313.89,98.02 313.98,98.25 313.99,98.32 313.99,98.45 313.89,98.68 313.89,99.02 313.98,99.25 313.98,99.45 313.86,99.77 313.87,99.92 313.99,100.28 314.05,100.37 314.09,100.42 314.15,100.48 314.26,100.48 CON4800.10
  IN1 w0.089: v2(309.23,92.03) 309.57,91.69 310.18,91.69 310.34,91.85 310.34,93.5 310.7,93.86 311.41,93.86 311.73,93.54 311.73,92.7 311.97,92.46 312.4,92.46 313.3,93.36 313.3,94.5 314,95.2 314,95.94
HDMI_OUT_DATA0_N: length 16
  TOP w0.108: v2(309.87,94.35) 309.74,94.49 308.31,94.49 308.06,94.24 RN4800.1
  IN1 w0.089: CON4800.9 313.03,101.75 313.01,101.75 309.96,101.75 309.45,101.25 309.45,100.44 309.7,100.19 311.05,100.19 311.58,99.66 311.58,95.52 310.6,94.55 310.06,94.55 v2(309.87,94.35)
HDMI_OUT_DATA0_P: length 16
  TOP w0.108: v2(309.89,94.96) 309.72,94.8 308.31,94.8 308.07,95.04 RN4800.3
  IN1 w0.089: CON4800.7 313.1,102.02 312.9,102.02 309.85,102.02 309.19,101.36 309.19,100.33 309.59,99.92 310.93,99.92 311.31,99.55 311.31,95.63 310.49,94.81 310.04,94.81 v2(309.89,94.96)
HDMI_OUT_DATA1_N: length 11.2
  TOP w0.108: RN4801.1 307.88,103.16 308.89,103.16 v2(309.09,102.96)
  IN1 w0.076: 313.99,105.27 313.89,105.04 313.89,104.68 313.98,104.45 313.98,104.23 313.87,103.95 313.89,103.72 313.98,103.44 314.05,103.33 314.15,103.23 314.5,103.23 314.63,103.11 CON4800.6
  IN1 w0.083: 313.99,105.58 313.99,105.58 313.99,105.49 313.99,105.27
  IN1 w0.089: v2(309.09,102.96) 309.29,103.17 310.08,103.17 311.04,104.14 312.85,105.94 313.63,105.94 313.99,105.58
HDMI_OUT_DATA1_P: length 11.2
  TOP w0.108: v2(309.09,103.57) 308.98,103.47 307.81,103.47 RN4801.3
  IN1 w0.076: CON4800.4 314.63,103.66 314.4,103.43 314.22,103.43 314.2,103.45 314.15,103.52 314.08,103.75 314.06,103.92 314.1,104.01 314.17,104.19 314.17,104.48 314.08,104.72 314.08,105 314.15,105.16 314.19,105.2 314.19,105.27
  IN1 w0.083: 314.19,105.27 314.19,105.49 314.19,105.76 314.18,105.77
  IN1 w0.089: v2(309.09,103.57) 309.22,103.44 309.97,103.44 311.31,104.78 312.74,106.2 313.74,106.2 313.82,106.13 314.18,105.77
HDMI_OUT_DATA2_N: length 6.7
  TOP w0.108: v2(309.07,105.72) 308.9,105.89 307.92,105.89 307.71,105.67 RN4802.1
  IN4 w0.089: v2(309.07,105.72) 309.24,105.89 310.96,105.89 312.11,104.74 313.04,104.74 CON4800.3
HDMI_OUT_DATA2_P: length 6.7
  TOP w0.108: RN4802.3 307.69,106.47 307.96,106.2 308.96,106.2 v2(309.09,106.33)
  IN4 w0.089: v2(309.09,106.33) 309.26,106.16 311.07,106.16 312.22,105.01 313.09,105.01 CON4800.1
HDMI_SEL#_TEST_A1: length 4.3
  TOP w0.102: U1301.23 v2(300.08,82.7) v1(300.72,82.7)
  BOTTOM w0.102: v2(300.08,82.7) 301.23,82.7 R1326.2 301.78,81.74 R1327.1
HDMI_TMDSD_CLK_N: length 15.3
  TOP w0.108: 302.14,81.94 299.88,81.94 299.84,81.9 U1301.21 ; 302.14,81.94 302.73,81.94 305.04,84.26 305.04,91.17 305.37,91.5 305.95,91.5 306.12,91.32 RN4803.2 ; 302.14,81.94 v1(302.15,81.72)
HDMI_TMDSD_CLK_P: length 15.3
  TOP w0.108: v1(304.5,86.04) 304.73,86.04 ; 304.73,86.04 304.73,84.39 302.6,82.26 299.88,82.26 299.84,82.3 U1301.22 ; 304.73,86.04 304.73,91.29 305.24,91.81 305.88,91.81 306.19,92.12 RN4803.4
HDMI_TMDSD_DATA0_N: length 17.1
  TOP w0.108: 304.03,91.02 304.03,91.34 304.98,92.3 304.98,94.21 305.29,94.51 306.08,94.51 306.35,94.24 RN4800.2 ; 304.03,91.02 v1(304.25,91.02) ; 304.03,91.02 304.03,84.76 302.4,83.14 299.88,83.14 299.84,83.1 U1301.24
HDMI_TMDSD_DATA0_P: length 17.1
  TOP w0.108: 303.71,87.46 303.71,91.47 304.67,92.43 304.67,94.34 305.16,94.83 306.13,94.83 306.35,95.04 RN4800.4 ; 303.71,87.46 303.71,84.89 302.28,83.46 299.88,83.46 299.84,83.5 U1301.25 ; 303.71,87.46 v1(303.49,87.46)
HDMI_TMDSD_DATA1_N: length 24.2
  TOP w0.108: v1(304.94,99.42) 304.71,99.42 ; 304.71,99.42 304.71,102.73 305.09,103.11 305.83,103.11 RN4801.2 ; 304.71,99.42 304.71,96.88 304.13,96.3 304.13,92.61 302.68,91.17 302.68,85 301.62,83.94 299.88,83.94 299.84,83.9 U1301.26
HDMI_TMDSD_DATA1_P: length 24.2
  TOP w0.108: 303.82,95.87 303.82,92.74 302.37,91.29 302.37,85.13 301.49,84.26 299.88,84.26 299.84,84.3 U1301.27 ; 303.82,95.87 v1(303.59,95.87) ; 303.82,95.87 303.82,96.43 304.4,97.01 304.4,102.86 304.96,103.42 305.73,103.42 305.99,103.68 RN4801.4
HDMI_TMDSD_DATA2_N: length 25.3
  TOP w0.108: U1301.29 299.84,85.1 299.88,85.14 300.62,85.14 301.51,86.04 301.51,91.48 302.81,92.77 302.81,96.25 303.89,97.33 303.89,104.12 ; 303.89,104.12 303.89,104.77 305.07,105.95 305.7,105.95 305.97,105.67 RN4802.2 ; 303.89,104.12 v1(304.11,104.12)
HDMI_TMDSD_DATA2_P: length 25.3
  TOP w0.108: v1(303.35,102.5) 303.57,102.5 ; 303.57,102.5 303.57,97.45 302.49,96.37 302.49,92.9 301.2,91.61 301.2,86.17 300.49,85.46 299.88,85.46 299.84,85.5 U1301.30 ; 303.57,102.5 303.57,104.9 304.94,106.26 305.75,106.26 305.97,106.47 RN4802.4
HDMID_DDI2_AUXN: length 7.9
  TOP w0.108: U1301.39 295.6,86.57 295.54,86.63 295.54,87.89 R1312.2 295.66,88.83 295.66,88.93 294.72,89.87 294.21,89.87 ; v1(294.21,89.65) 294.21,89.87 ; 294.21,89.87 293.63,89.87 293.5,89.75 293.5,89.36 293.45,89.31 R1311.1 292.51,89.31 292.46,89.26 R1306.1
HDMID_DDI2_AUXP: length 7.7
  TOP w0.108: R1307.1 292.46,90.28 292.51,90.23 R1310.1 293.53,90.23 293.57,90.18 294.85,90.18 295.97,89.06 295.97,88.6 R1313.2 295.85,87.88 295.85,86.76 296,86.61 U1301.38
HDMID_DDI2_DATA0_N: length 2.9
  TOP w0.108: U1301.7 294.18,83.1 294.16,83.12 293.5,83.12 292.89,82.5 292.48,82.5 C1306.2
HDMID_DDI2_DATA0_P: length 3
  TOP w0.108: C1311.2 292.49,82.81 292.76,82.81 293.37,83.43 294.17,83.43 294.24,83.5 U1301.6
HDMID_DDI2_DATA1_N: length 3
  TOP w0.108: C1307.2 292.51,84.56 292.72,84.56 293.35,83.93 294.11,83.93 294.14,83.9 U1301.5
HDMID_DDI2_DATA1_P: length 2.9
  TOP w0.108: C1312.2 292.46,84.87 292.84,84.87 293.48,84.24 294.05,84.24 294.11,84.3 U1301.4
HDMID_DDI2_DATA2_N: length 4.1
  TOP w0.108: C1305.2 292.44,87.54 292.61,87.54 292.74,87.41 292.74,86.64 294.28,85.1 U1301.2
HDMID_DDI2_DATA2_P: length 4.1
  TOP w0.108: C1309.2 292.53,87.85 292.74,87.85 293.05,87.54 293.05,86.77 294.32,85.5 U1301.1
HDMID_DDI2_DATA3_N: length 3.7
  TOP w0.108: U1301.10 294.19,81.9 294.14,81.94 293.94,81.94 293.15,81.16 293.15,80.81 292.93,80.59 ; C1310.2 292.51,80.49 292.84,80.49 292.93,80.59 ; 292.93,80.59 v1(293.1,80.42)
HDMID_DDI2_DATA3_P: length 3.7
  TOP w0.108: v1(293.4,82.18) 293.57,82.01 ; 293.57,82.01 293.81,82.25 294.16,82.25 294.21,82.3 U1301.9 ; 293.57,82.01 292.84,81.29 292.84,80.94 292.71,80.8 292.46,80.8 C1308.2
HDMID_IFPE_AUXN: length 21.6
  TOP w0.108: R1309.2 298.43,88.3 v2(298.56,88.17) ; 287.92,87.15 v1(288.14,87.15) ; 287.92,87.15 287.92,85.21 287.52,84.81 287.29,84.81 286.91,84.43 R7227.2 286.91,83.3 286.26,82.66 Q7205.3 ; 287.92,87.15 287.92,87.51 289.97,89.57 290.38,89.57 v2(290.56,89.39) 290.78,89.62 290.92,89.62 R1306.2
  IN1 w0.089: v2(298.56,88.17) 298.79,88.41 298.79,88.6 298.6,88.79 294.84,88.79 293.75,89.89 291.05,89.89 290.99,89.82 290.99,89.44 290.94,89.39 v2(290.56,89.39)
HDMID_IFPE_AUXN_GPU: length 229.6
  TOP w0.108: Q7205.2 284.45,80.95 285.02,81.52 285.02,83.29 R7225.2 ; R7225.2 284.84,84.06 284.97,84.18 R7227.1 ; R7225.2 284.26,84.17 283.95,84.47 283.95,84.69 v2(284.08,84.82)
  IN2 w0.089: v2(136.48,81.72) 136.28,81.51 136.28,80.48 135.56,79.76 135.03,79.76 134.64,79.37 134.64,62.4 135.11,61.93 135.11,56.79 152.31,39.59 152.31,39.29 153.33,38.26 192.9,38.26 193.66,37.5 195.26,37.5 196.02,38.26 225.88,38.26 226.22,37.93 243.32,37.93 243.38,37.99 246.88,37.99 251.51,42.63 253.79,42.63 256.05,44.89 256.55,44.89 261,49.35 261,53.64 264.59,57.22 264.59,59.35 271.66,66.43 273.92,66.43 276.42,68.93 277.42,68.93 279.18,70.69 279.18,75.67 283.69,80.18 283.69,82.41 284.45,83.18 284.45,84.32 284.36,84.41 284.21,84.41 283.98,84.18 283.83,84.18 283.7,84.31 283.7,84.44 v2(284.08,84.82)
  BOTTOM w0.108: v2(136.48,81.72) 136.48,81.49 136.76,81.21 140.49,81.21 141.11,80.6 143.84,80.6 144.06,80.82 144.06,81.24 144.15,81.34 144.61,81.34 144.66,81.29 144.66,81.16 U7000.BL8
HDMID_IFPE_AUXP: length 21.6
  TOP w0.108: 289.09,89.13 289.84,89.88 290.28,89.88 v2(290.56,90.15) 290.78,89.93 290.92,89.93 R1307.2 ; 289.09,89.13 287.6,87.64 287.6,85.34 287.39,85.12 287.2,85.12 286.91,85.42 R7228.2 286.91,87.44 286.48,87.87 Q7204.3 ; 289.09,89.13 v1(288.93,89.29) ; v2(299.19,88.17) 299.32,88.3 R1308.2
  IN1 w0.089: v2(290.56,90.15) 293.86,90.15 294.95,89.06 298.71,89.06 299.06,88.71 299.06,88.3 v2(299.19,88.17)
HDMID_IFPE_AUXP_GPU: length 229.8
  TOP w0.108: v2(284.71,84.82) 284.71,85.12 R7226.2 ; R7226.2 R7228.1 ; R7226.2 284.26,86.01 284.49,86.24 285.54,86.24 285.65,86.35 285.65,86.8 285.54,86.92 Q7204.2
  IN2 w0.089: v2(135.81,81.72) 136.01,81.52 136.01,80.59 135.45,80.03 134.92,80.03 134.37,79.48 134.37,62.29 134.84,61.82 134.84,56.68 152.04,39.48 152.04,39.18 153.22,38 192.79,38 193.55,37.24 195.37,37.24 196.13,38 225.77,38 226.11,37.66 243.43,37.66 243.49,37.73 246.99,37.73 251.62,42.36 253.9,42.36 256.16,44.62 256.66,44.62 261.27,49.24 261.27,53.52 264.85,57.11 264.85,59.24 271.77,66.16 274.03,66.16 276.53,68.66 277.53,68.66 279.44,70.57 279.44,75.56 283.95,80.07 283.95,82.3 284.71,83.07 v2(284.71,84.82)
  BOTTOM w0.108: v2(135.81,81.72) 136.63,80.9 140.36,80.9 140.98,80.29 143.97,80.29 144.27,80.59 144.79,80.59 U7000.BK8
HDMID_IFPE_DATA0_N: length 251.2
  TOP w0.108: C1305.1 290.76,87.23 290.71,87.28 290.71,87.87 290.64,87.94 290.53,87.94 289.78,87.18 289.78,86.64 v2(290.07,86.34)
  IN2 w0.089: v2(290.07,86.34) 289.73,86 289.73,85.16 290.11,84.78 290.11,76.37 283.03,69.28 283.03,68.32 277.73,63.02 277.73,62.01 274.99,59.27 273.97,59.27 266.92,52.22 266.92,50.95 265.06,49.08 265.06,48.68 257.48,41.1 257.36,41.1 256.03,39.78 256.03,39.38 253.96,37.31 251.15,37.31 248.47,34.63 244.71,34.63 243.91,33.83 199.18,33.83 198.9,33.55 192.86,33.55 192.48,33.92 152.07,33.92 131.32,54.67 131.32,82.66 133.93,85.26 133.93,87.6 135.94,89.61 143.02,89.61 144.67,87.95 144.98,87.95 145.07,88.04 146.44,88.04 146.9,87.58 v3(146.9,86.92)
  BOTTOM w0.108: v3(146.9,86.92) 146.92,86.92 U7000.BG17
HDMID_IFPE_DATA0_P: length 251.3
  TOP w0.108: C1309.1 290.4,88.25 289.46,87.31 v2(289.46,86.34)
  IN2 w0.089: v2(289.46,86.34) 289.46,85.05 289.85,84.67 289.85,76.48 282.76,69.39 282.76,68.43 277.46,63.13 277.46,62.12 274.88,59.53 273.86,59.53 266.66,52.33 266.66,51.06 264.79,49.19 264.79,48.79 257.37,41.37 257.25,41.37 255.77,39.89 255.77,39.49 253.85,37.57 251.04,37.57 248.36,34.9 244.6,34.9 243.8,34.09 199.07,34.09 198.79,33.81 192.97,33.81 192.59,34.19 152.18,34.19 131.59,54.78 131.59,82.55 134.19,85.15 134.19,87.48 136.05,89.34 142.91,89.34 144.56,87.69 145.09,87.69 145.18,87.78 146.33,87.78 146.63,87.47 146.63,87.38 146.53,87.28 145.75,87.28 145.65,87.18 145.65,86.98 145.73,86.9 v3(146.21,86.9)
  BOTTOM w0.108: v3(146.21,86.9) 146.21,87.54 146.28,87.61 146.49,87.61 146.55,87.55 U7000.BH17
HDMID_IFPE_DATA1_N: length 247.1
  TOP w0.108: v1(288.55,82.07) 288.33,82.07 ; 288.33,82.07 288.33,83.73 288.62,84.02 290.15,84.02 290.71,84.58 290.87,84.58 C1307.1 ; 288.33,82.07 288.33,81.67 v2(287.89,81.24)
  IN2 w0.089: v2(287.89,81.24) 288.09,81.03 288.25,81.03 288.32,81.11 288.32,81.55 288.37,81.6 288.67,81.6 288.8,81.47 288.8,80.53 287.6,79.32 286.18,79.32 282,75.14 282,70.27 280.9,69.18 280.9,68.66 277.23,64.99 277.23,64.63 276.35,63.74 276.35,63.16 274.7,61.51 273.75,61.51 270.39,58.15 270.39,57.41 264.89,51.92 264.19,51.92 263.57,51.3 263.57,48.68 257.13,42.24 257.03,42.24 254.99,40.2 254.99,39.79 253.67,38.48 250.86,38.48 248.04,35.66 244.28,35.66 243.51,34.88 221.45,34.88 221.12,35.22 196.84,35.22 196.57,34.95 152.51,34.95 150.65,36.81 150.65,37.27 149.68,38.25 149.26,38.25 132.73,54.78 132.73,60.96 132.35,61.33 132.35,82.1 134.96,84.7 134.96,87.08 136.36,88.49 142.31,88.49 145.08,85.72 145.56,85.72 145.65,85.81 147.06,85.81 147.44,86.19 v3(147.61,86.19)
  BOTTOM w0.108: v3(147.61,86.19) U7000.BF15
HDMID_IFPE_DATA1_P: length 247.2
  TOP w0.108: v2(287.89,81.87) 288.02,82 288.02,83.86 288.49,84.34 289.74,84.34 ; 289.74,84.34 290.02,84.34 290.58,84.89 290.96,84.89 C1312.1 ; 289.74,84.34 v1(289.74,84.56)
  IN2 w0.089: v2(287.89,81.87) 288.78,81.87 289.07,81.58 289.07,80.41 287.71,79.05 286.29,79.05 282.26,75.03 282.26,70.16 281.17,69.07 281.17,68.55 277.5,64.88 277.5,64.52 276.61,63.63 276.61,63.05 274.81,61.25 273.86,61.25 270.66,58.04 270.66,57.3 265,51.65 264.3,51.65 263.84,51.19 263.84,48.57 257.24,41.97 257.14,41.97 255.25,40.09 255.25,39.68 253.78,38.21 250.97,38.21 248.15,35.39 244.39,35.39 243.62,34.61 221.34,34.61 221.01,34.95 196.95,34.95 196.68,34.68 152.4,34.68 150.39,36.7 150.39,37.16 149.57,37.98 149.15,37.98 132.46,54.67 132.46,60.85 132.09,61.22 132.09,82.21 134.69,84.81 134.69,87.19 136.25,88.75 142.42,88.75 145.19,85.99 145.45,85.99 145.54,86.08 146.79,86.08 v3(146.9,86.18)
  BOTTOM w0.108: U7000.BG15 146.91,86.18 v3(146.9,86.18)
HDMID_IFPE_DATA2_N: length 243.2
  TOP w0.108: C1306.1 290.76,82.15 290.68,82.23 290.68,82.78 290.6,82.86 290.43,82.86 290.03,82.45 289.29,82.45 v2(288.75,82.99)
  IN2 w0.089: v3(148.25,84.77) 148.52,84.77 148.62,84.87 148.62,85.15 148.42,85.35 145.85,85.35 145.74,85.24 144.47,85.24 141.98,87.73 136.79,87.73 135.72,86.65 135.72,84.34 133.12,81.74 133.12,61.77 133.56,61.32 133.56,55.02 148.36,40.23 149.52,40.23 150.33,39.42 150.33,38.97 151.71,37.59 151.71,36.83 152.83,35.71 196.17,35.71 196.51,36.06 243.6,36.06 243.97,36.42 247.48,36.42 247.56,36.49 247.57,36.49 250.81,39.73 251.52,39.73 252.89,41.1 254.45,41.1 256.71,43.36 257.18,43.36 262.81,48.99 262.81,52.04 264.29,53.52 265.36,53.52 269.63,57.79 269.63,58.76 273.86,62.99 273.86,63.19 274.71,64.04 274.91,64.04 279.15,68.28 279.15,68.5 280.93,70.29 280.93,75.16 286.18,80.41 286.56,80.41 287,80.86 287,81.74 286.84,81.91 286.84,82.67 287.22,83.05 287.83,83.05 288.22,82.66 288.63,82.66 288.75,82.79 v2(288.75,82.99)
  BOTTOM w0.108: U7000.BF14 148.05,85.25 148.22,85.25 148.32,85.16 148.32,84.83 v3(148.25,84.77)
HDMID_IFPE_DATA2_P: length 243.1
  TOP w0.108: v2(289.39,82.99) 289.61,82.76 289.9,82.76 290.3,83.17 C1311.1
  IN2 w0.089: v3(149.01,84.79) 148.89,84.91 148.89,85.26 148.53,85.62 145.74,85.62 145.63,85.51 144.58,85.51 142.09,87.99 136.68,87.99 135.45,86.76 135.45,84.45 132.85,81.85 132.85,61.66 133.29,61.21 133.29,54.91 148.24,39.96 149.41,39.96 150.06,39.31 150.06,39.08 150.06,39.08 150.06,38.86 151.45,37.48 151.45,36.86 151.45,36.72 152.72,35.45 196.28,35.45 196.62,35.79 243.71,35.79 244.08,36.15 247.59,36.15 247.67,36.23 247.68,36.23 250.92,39.47 251.63,39.47 253,40.84 254.56,40.84 256.82,43.1 257.29,43.1 263.07,48.88 263.07,51.93 264.4,53.26 265.47,53.26 269.89,57.68 269.89,58.65 274.12,62.88 274.12,63.08 274.82,63.77 275.02,63.77 279.41,68.17 279.41,68.39 281.2,70.17 281.2,75.05 286.29,80.14 286.67,80.14 287.27,80.75 287.27,81.85 287.1,82.02 287.1,82.56 287.33,82.79 287.72,82.79 288.11,82.39 288.79,82.39 v2(289.39,82.99)
  BOTTOM w0.108: U7000.BE14 v3(149.01,84.79)
HDMID_IFPE_DATA3_N: length 244.3
  TOP w0.108: 288.07,79.88 289.54,79.88 290.18,80.52 290.87,80.52 C1310.1 ; 288.07,79.88 287.71,79.88 287.42,80.17 285.93,80.17 285.58,80.52 285.58,80.72 v2(285.37,80.93) ; 288.07,79.88 v1(288.07,79.66)
  IN2 w0.089: v3(146.9,84.82) 146.55,85.16 145.94,85.16 145.78,85 144.17,85 142.6,86.57 138.79,86.57 133.61,81.39 133.61,61.97 134.08,61.5 134.08,55.5 135.53,54.05 135.99,54.05 136.49,53.54 136.49,53.07 137.69,51.87 138.16,51.87 139.67,50.37 139.67,49.83 140.87,48.63 141.82,48.63 145.16,45.29 145.16,45.16 144.91,44.92 144.91,44.58 145.3,44.19 145.64,44.19 145.88,44.44 146.01,44.44 146.23,44.21 146.23,44.09 145.99,43.84 145.99,43.5 146.37,43.12 146.72,43.12 146.96,43.36 147.09,43.36 147.31,43.13 147.31,43.01 147.07,42.77 147.07,42.42 147.45,42.04 147.8,42.04 148.04,42.28 148.17,42.28 148.39,42.06 148.39,41.93 148.22,41.75 148.22,41.41 148.6,41.03 148.95,41.03 149.12,41.2 149.24,41.2 150.83,39.62 150.83,39.18 152.21,37.79 152.21,37.5 153.37,36.34 187.26,36.34 188.11,37.19 192.51,37.19 193.23,36.48 195.93,36.48 196.37,36.91 206.64,36.91 207,36.55 243.4,36.55 243.76,36.92 247.28,36.92 251.96,41.6 254.23,41.6 256.5,43.86 256.97,43.86 262.31,49.2 262.31,52.25 264.32,54.26 265.16,54.26 267.9,57 267.9,59.52 268.09,59.71 268.62,59.71 269.14,60.23 269.14,62.14 269.69,62.68 270.14,62.68 271.08,61.75 271.42,61.75 271.8,62.13 271.8,62.47 270.87,63.41 270.87,64.17 271.92,65.22 274.61,65.22 277.28,67.89 277.83,67.89 280.4,70.45 280.4,75.42 284.71,79.74 284.71,80.5 285.14,80.93 v2(285.37,80.93)
  BOTTOM w0.108: v3(146.9,84.82) 147.04,84.95 147.05,84.95 U7000.BG14
