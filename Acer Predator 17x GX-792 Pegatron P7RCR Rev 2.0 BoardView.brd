# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1P2V_CPU on BOTTOM (solid shape): 97.08,106.7 97.06,106.67 97.04,106.63 97.01,106.54 97.01,106.09 97.03,106.04 97.02,105.93 96.96,105.84 96.68,105.84 96.39,105.99 96.1,105.84 95.9,105.84 95.79,105.96 95.79,106.26 95.88,106.36 95.91,106.35 96.23,106.42 96.3,106.74 96.29,106.77 96.45,106.93 96.86,106.93
+1P2V_CPU on BOTTOM (solid shape): 90.59,107.37 90.59,106.87 90.24,106.51 90.02,106.51 89.97,106.56 89.88,106.61 89.75,106.63 89.66,106.61 89.53,106.61 89.17,106.26 89.17,106.26 89.1,106.2 89.04,106.13 89.04,106.12 88.99,106.08 88.71,106.08 88.68,106.15 88.63,106.21 88.63,106.37 88.69,106.42 88.74,106.48 88.79,106.53 88.79,106.92 88.89,107.02 89.37,107.02 89.37,107.02 89.49,106.99 89.61,107.02 89.62,107.02 89.83,107.02 90.12,107.31 90.2,107.37 90.26,107.45 90.52,107.45
+1P2V_CPU on BOTTOM (solid shape): 110.77,106.55 110.78,106.54 110.81,106.47 110.86,106.41 110.86,106.21 110.81,106.15 110.77,106.06 110.76,106.05 110.61,106.05 110.55,106 110.54,105.99 110.43,105.93 110.36,105.83 110.34,105.8 110.13,105.8 109.64,106.28 109.5,106.28 109.43,106.29 109.32,106.27 109.21,106.2 109.14,106.09 109.14,106.08 109.08,106.03 108.87,106.03 108.83,106.07 108.7,106.25 108.47,106.28 108.42,106.33 108.42,106.74 108.51,106.82 110.5,106.82
+1P2V_CPU on BOTTOM (solid shape): 88.27,111.11 88.58,110.88 88.89,111.11 88.89,111.12 88.92,111.15 89.13,111.15 89.17,111.11 89.17,111.01 89.27,110.88 89.34,110.88 89.49,110.73 89.58,110.7 89.58,110.47 89.5,110.39 89.42,110.36 89.34,110.41 88.95,110.57 88.68,110.25 88.68,110.23 88.64,110.2 88.62,110.2 88.52,110.2 88.42,110.16 88.41,110.15 88.09,110.15 88,110.25 88,110.54 88,110.55 88,110.99 88.16,111.15 88.26,111.15
+1P2V_CPU on BOTTOM (solid shape): 86.45,107.92 86.48,107.8 86.57,107.7 86.61,107.62 86.57,107.54 86.48,107.15 86.86,107.01 86.95,107 87,106.92 87,106.64 86.89,106.54 85.9,106.54 85.83,106.61 85.83,106.76 85.88,106.84 85.9,106.94 85.9,106.96 85.93,107.01 85.95,107.01 86.14,107.25 86.02,107.54 85.98,107.62 86.02,107.7 86.1,107.8 86.14,107.92 86.14,107.97 86.44,107.97
+1P2V_CPU on BOTTOM (solid shape): 105.2,106.82 105.26,106.81 105.41,106.69 105.35,106.5 105.3,106.43 105.28,106.35 105.28,106.34 105.24,106.29 105.22,106.28 104.99,106.05 105.1,105.74 105.14,105.66 105.1,105.58 105.05,105.53 105.01,105.47 105,105.44 104.79,105.44 104.68,105.53 104.65,105.66 104.66,105.74 104.69,105.81 104.72,105.85 104.72,106.08 104.67,106.13 104.61,106.2 104.52,106.28 104.41,106.29 104.35,106.32 104.32,106.38 104.28,106.48 104.22,106.57 104.22,106.57 104.2,106.61 104.23,106.68 104.28,106.77 104.38,106.81 104.44,106.82 104.51,106.89 104.67,106.89 104.75,106.91 104.82,106.95 105.07,106.95
+1P2V_CPU on IN2 (solid shape): outline of 7450 points within 77.32,88.96 122.89,111.49
+1P2V_DUAL on TOP (solid shape): 74.45,66.94 74.45,66.03 74.31,65.89 70.87,65.89 70.53,66.23 70.53,66.96 70.69,67.12 74.27,67.12
+1P2V_DUAL on TOP (solid shape): 99.62,67.3 99.62,66.4 99.52,66.3 99.15,66.3 98.44,67.01 98.21,67.01 98.01,67.21 98.01,67.79 98.37,68.15 98.78,68.15
+1P2V_DUAL on TOP (solid shape): 65.71,68.42 65.77,68.41 65.83,68.42 66.33,68.42 66.62,68.13 66.62,67.35 66.54,67.27 65.6,67.27 65.5,67.37 65.5,68.26 65.65,68.42
+1P2V_DUAL on TOP (solid shape): 56.44,69.03 58.44,69.03 58.78,68.69 58.78,67.48 58.71,67.4 49.79,67.4 49.66,67.53 46.1,67.53 46.08,67.51 45.58,67.51 45.34,67.75 45.34,68.31 46.83,69.8 55.67,69.8
+1P2V_DUAL on TOP (solid shape): 76.6,67.27 76.74,67.24 76.88,67.27 84.5,67.27 84.64,67.13 84.64,66.08 84.58,66.01 76.66,66.01 76.35,66.32 76.35,67.09 76.53,67.27
+1P2V_DUAL on TOP (solid shape): 103.84,55 104.02,54.95 104.21,55 104.86,55 104.91,54.95 104.91,54.44 104.83,54.36 103.21,54.36 103.16,54.41 103.16,54.95 103.21,55
+1P2V_DUAL on TOP (solid shape): 58.91,111.74 58.91,109.61 58.82,109.15 59.25,108.96 59.28,108.96 59.52,108.72 59.52,104.12 59.26,103.87 56.11,103.87 55.1,102.85 55.1,99.93 54.59,99.42 53.44,99.42 51.95,101.11 49.77,101.65 49.38,102.04 49.38,111.74 49.64,112 58.65,112
+1P2V_DUAL on TOP (solid shape): outline of 130 points within 69.16,53.86 85.32,55.57
+1P2V_DUAL on TOP (solid shape): outline of 268 points within 69.84,41.77 85.45,43.55
+1P2V_DUAL on BOTTOM (solid shape): 97.42,43.17 97.42,42.77 97.33,42.68 97.33,41.86 97.24,41.78 96.06,41.78 96.06,42.37 96.93,43.24 97.35,43.24
+1P2V_DUAL on BOTTOM (solid shape): 54.01,45.43 54.01,43.46 54.39,43.08 54.39,42.02 54.32,41.95 53.2,41.95 53.16,41.99 53.16,42.88 53.23,42.94 53.54,42.94 53.73,43.13 53.73,45.46 53.74,45.47 53.97,45.47
+1P2V_DUAL on BOTTOM (solid shape): 69.25,67.9 69.25,67.68 69.11,67.54 68.98,67.56 68.85,67.53 68.71,67.53 68.58,67.41 68.58,67.08 68.59,67.08 68.59,66.1 68.44,65.96 67.94,65.96 67.77,66.13 67.77,68.18 67.89,68.29 68.86,68.29
+1P2V_DUAL on BOTTOM (solid shape): 91.33,67.67 91.33,67 91.79,66.55 91.82,66.55 91.98,66.51 92.15,66.55 92.18,66.55 92.28,66.45 92.28,65.99 92.24,65.95 91.53,65.95 90.88,66.6 89.61,66.6 89.41,66.8 89.41,67.68 89.5,67.78 91.22,67.78
+1P2V_DUAL on BOTTOM (solid shape): outline of 144 points within 62.92,40.11 82.87,43.44
+1P2V_DUAL on BOTTOM (solid shape): outline of 239 points within 67.94,53.83 83.21,55.49
+1P2V_DUAL on BOTTOM (solid shape): outline of 1192 points within 37.62,65.87 98.87,109.46
+1P2V_DUAL on IN1 (solid shape): 59.42,105.39 59.42,103.87 59.15,103.6 58.91,103.6 58.87,103.61 58.49,103.74 58.13,103.55 58.06,103.59 57.98,103.61 57.6,103.74 57.24,103.55 57.22,103.53 57.16,103.53 57.15,103.55 56.38,103.58 56.46,102.82 56.52,102.74 56.59,102.68 56.59,100.95 54.44,98.79 52.18,98.79 50.4,100.57 50.4,102.22 53.96,105.77 59.04,105.77
+1P2V_DUAL on IN1 (solid shape): outline of 3899 points within 42.84,41.38 65.77,56.37
+1P2V_DUAL on IN2 (solid shape): outline of 22705 points within 41.27,40.9 114.66,106.08
+1P2V_DUAL on IN3 (solid shape): outline of 18638 points within 41.24,36.1 114.03,106.08
+1P2V_DUAL on IN4 (solid shape): outline of 1845 points within 53.32,41.13 107.92,46.9
+2P5_3VS_DIM on TOP (solid shape): 108.26,43.09 109.71,41.64 109.71,41.38 109.45,41.13 108.06,41.13 107.93,41.26 107.93,41.71 107.37,42.27 107.37,43.06 107.98,43.67 107.98,45.45 108.26,45.45
+2P5_3VS_DIM on TOP (solid shape): outline of 541 points within 79.86,11.69 109.84,43.24
+2P5_3VS_DIM on BOTTOM (solid shape): 101.71,74.78 101.71,73.9 101.45,73.64 100.06,73.64 99.93,73.77 99.93,74.78 100.18,75.04 101.45,75.04
+2P5_3VS_DIM on BOTTOM (solid shape): 100.62,42.38 100.62,41.51 101.15,40.98 107.42,40.98 107.58,41.13 107.78,41.21 107.91,41.39 107.97,41.44 107.97,41.52 108.18,41.74 113.37,41.74 113.37,39.86 112.98,39.47 91.69,39.47 90.1,41.06 90.1,41.64 90.18,41.72 91.09,41.72 91.22,41.85 91.22,42.38 91.32,42.48 91.78,42.48 91.86,42.41 91.86,41.82 92.11,41.57 93.05,41.57 93.51,42.03 93.51,42.47 93.57,42.52 93.95,42.52 94.04,42.44 94.04,41.92 94.39,41.57 99.37,41.57 99.68,41.87 99.68,42.46 99.75,42.53 100.46,42.53
+2P5_3VS_DIM on IN3 (solid shape): outline of 1207 points within 102.99,41.19 121.32,70.58
+2P5VPP on TOP (solid shape): outline of 1504 points within 81.86,8.87 120,64.23
+2P5VPP on BOTTOM (solid shape): 114.19,66.29 114.19,62.76 113.99,62.56 112.92,62.56 112.8,62.69 112.8,63.62 112.96,63.78 113.23,63.78 113.35,63.91 113.35,65.45 113.17,65.63 111.95,65.63 108.71,62.39 107.17,62.39 106.41,63.15 106.41,63.79 106.48,63.86 106.48,65.51 106.76,65.51 106.76,63.61 106.81,63.56 107.37,63.56 107.4,63.58 107.4,63.94 107.37,63.96 106.99,63.96 106.99,65.62 107.02,65.64 109.71,65.64 110.8,66.73 113.75,66.73
+2P5VPP on BOTTOM (solid shape): 114.27,55.31 114.27,52.26 114.1,52.1 113.25,52.1 113.03,52.31 113.03,53.92 112.85,54.1 112.23,54.1 109.97,51.84 108.32,51.84 107.98,51.49 107.98,51.01 107.78,50.81 106.74,50.81 106.48,51.06 106.48,53.65 106.51,53.68 106.74,53.68 106.76,53.65 106.76,51.7 106.79,51.67 107.37,51.67 107.4,51.7 107.4,51.92 107.35,51.98 106.99,51.98 106.99,53.58 107.04,53.63 108.03,53.63 109.12,54.72 110.72,54.72 111.44,55.43 114.15,55.43
+2P5VPP on IN3 (solid shape): outline of 152 points within 109.35,52.26 113.78,63.86
+A/D_DOCK_IN on TOP (solid shape): 8.83,82.71 8.83,82.03 8.01,81.2 8.01,73.08 8.08,73.01 8.08,69.22 7.93,69.07 2.5,69.07 1.63,69.93 1.63,78.88 1.94,79.2 2.35,79.54 2.49,80.06 2.52,80.14 2.59,80.17 3.25,80.45 3.48,81.13 4.02,81.67 5.72,81.67 6.83,82.77 8.77,82.77
+A/D_DOCK_IN_CON on TOP (solid shape): 16.83,67.01 16.83,64.99 16.18,64.34 12.53,64.34 12.02,63.84 9.28,63.84 8.54,63.09 5.2,63.09 5.11,63.19 3.55,63.19 2.67,64.07 2.67,68.03 2.83,68.18 15.65,68.18
+A/D_DOCK_IN_CON on BOTTOM (solid shape): 10.66,70.57 17.36,70.57 18.91,69.02 18.91,66.36 18.84,66.29 14.77,66.29 13.72,65.23 10.82,65.23 10.64,65.05 10.64,63.7 9.91,62.97 9.52,62.97 8.97,63.2 8.43,62.97 4.38,62.97 4.3,63 4.22,63.03 4.04,63.2 4.04,70.77 4.43,71.15 10.08,71.15
+A/D_DOCK_IN_Q on TOP (solid shape): 13.94,79.93 14.32,79.56 17.72,79.56 17.82,79.46 17.82,78.37 17.81,78.37 17.81,77.57 17.64,77.34 17.68,77.06 17.68,76.71 17.61,76.64 9.43,76.64 9.28,76.79 9.28,79.81 9.35,79.89 10.19,79.89 10.47,80.17 10.47,80.38 10.64,80.55 13.33,80.55
+A/D_DOCK_IN_Q_Q on TOP (solid shape): 23.6,84.06 23.6,82.66 23.35,82.4 19.76,82.4 19.23,81.88 19.23,81.48 19.24,80.41 19.11,80.28 15.04,80.28 14.7,80.62 14.7,84.19 15.11,84.6 15.11,84.61 15.14,84.64 16.65,84.64 17,84.56 17.35,84.64 17.58,84.64 17.66,84.73 18.04,84.73 18.17,84.72 18.3,84.73 19.96,84.73 20.18,84.94 22.71,84.94
+AC_BAT_SYS on TOP (solid shape): 55.86,192.26 55.86,190.61 55.73,190.48 55.23,190.48 55.1,190.61 55.1,192.26 55.23,192.39 55.73,192.39
+AC_BAT_SYS on TOP (solid shape): 61.78,174.75 61.78,173.81 62.06,173.53 62.06,172.14 62.34,171.86 62.34,170.92 62.46,170.8 63.73,170.8 63.86,170.67 63.86,169.78 63.73,169.65 60.05,169.65 59.8,169.91 59.8,175.24 59.95,175.4 61.13,175.4
+AC_BAT_SYS on TOP (solid shape): 56.22,177.27 56.22,173.74 56.47,173.49 56.47,171.66 55.99,171.18 55.99,169.91 55.86,169.78 55.1,169.78 54.97,169.65 54.97,168.38 54.84,168.26 53.96,168.26 53.83,168.38 53.83,177.27 54.08,177.53 55.96,177.53
+AC_BAT_SYS on TOP (solid shape): 121.98,59.72 121.98,58.62 122.23,58.37 122.23,58 123.58,56.65 123.58,51.76 122.74,50.92 121.73,50.92 121.52,51.13 121.52,54.36 120.85,55.03 120.85,57.69 121.78,58.62 121.78,59.71 121.8,59.73 121.97,59.73
+AC_BAT_SYS on TOP (solid shape): 21.71,80.88 22.71,80.88 22.98,81.15 23.97,81.15 24.11,81.01 24.11,67.93 23.98,67.8 20.94,67.8 20.55,68.18 19.28,68.18 19.28,74.05 19.54,74.3 19.54,76.16 19.62,76.24 19.8,76.24 20.61,77.05 20.61,79.1 20.87,79.36 20.87,80.52 20.6,80.79 20.6,80.96 20.79,81.15 21.44,81.15
+AC_BAT_SYS on TOP (solid shape): 295.39,18.87 295.39,16.14 295.39,14.48 295.29,14.38 295.11,14.38 295.04,14.38 294.72,14.38 294.67,14.34 291.32,14.34 291.1,14.55 291.1,15.34 290.94,15.5 288.35,15.5 287.95,15.1 287.95,13.48 287.66,13.19 282.05,13.19 281.41,13.82 281.41,18.9 282.17,18.9 282.56,19.29 294.98,19.29
+AC_BAT_SYS on TOP (solid shape): 228.17,14.16 228.17,10.62 228.28,10.52 230.36,10.52 230.59,10.29 230.59,8.02 230.17,7.6 227,7.6 226.37,8.23 226.37,12.3 225.78,12.9 225.78,13.74 225.55,13.96 223.47,13.96 223.45,13.98 223.45,14.2 223.46,14.21 225.94,14.21 226.47,14.74 227.6,14.74
+AC_BAT_SYS on TOP (solid shape): 91.04,16.87 91.04,13.84 90.64,13.44 89.38,13.44 87.92,11.97 87.92,7.07 88.53,6.45 89.8,6.45 89.82,6.43 89.82,6.28 89.8,6.26 88.73,6.26 88.2,5.72 87.26,5.72 86.98,5.44 83.7,5.44 83.42,5.17 83.42,4.41 83.04,4.02 83.04,3.03 82.78,2.78 80.5,2.78 80.24,3.03 80.24,5.06 82.02,6.84 82.02,10.49 87.1,15.57 87.1,16.87 87.23,17 90.91,17
+AC_BAT_SYS on TOP (solid shape): outline of 764 points within 67.8,160.38 97.97,182.18
+AC_BAT_SYS on BOTTOM (solid shape): 45.57,192.13 45.57,189.59 45.32,189.34 43.92,189.34 43.54,189.72 43.54,192.13 43.8,192.39 45.32,192.39
+AC_BAT_SYS on BOTTOM (solid shape): 100.8,191.72 100.8,190.64 100.76,190.61 98.31,190.61 98.15,190.76 98.15,191.48 98.25,191.57 98.65,191.57 98.9,191.82 100.69,191.82
+AC_BAT_SYS on BOTTOM (solid shape): 91.19,173.49 91.19,170.72 90.94,170.47 89.52,170.47 89.28,170.71 89.28,173.27 88.37,174.17 88.37,174.56 88.55,174.73 89.95,174.73
+AC_BAT_SYS on BOTTOM (solid shape): 91.29,17.38 91.29,14.64 90.89,14.23 89.72,14.23 89.13,14.81 89.13,17.38 89.52,17.76 90.91,17.76
+AC_BAT_SYS on BOTTOM (solid shape): 117.99,154.58 117.99,150.47 118.05,150.42 118.05,148.93 118.02,148.9 117.89,148.9 117.84,148.95 117.84,149.95 117.56,150.23 116.53,150.23 115.2,151.56 115.2,153.11 116.77,154.68 117.89,154.68
+AC_BAT_SYS on BOTTOM (solid shape): 24.24,80.87 24.24,77.96 23.86,77.58 23.86,74.91 22.71,73.77 20.17,73.77 19.79,74.15 19.79,76.31 20.17,76.69 20.17,80.84 20.47,81.14 23.97,81.14
+AC_BAT_SYS on BOTTOM (solid shape): 122.66,52.92 122.66,50.78 122.53,50.66 122.51,50.65 122.26,50.6 122.03,50.46 120.82,50.46 120.38,50.89 120.38,52.19 120.39,52.2 120.39,53 120.61,53.22 122.36,53.22
+AC_BAT_SYS on BOTTOM (solid shape): 103.92,167.89 103.92,167.69 103.85,167.62 101.8,167.62 101.4,167.23 101.4,165.48 100.87,164.95 100.44,164.95 100.27,164.77 100.27,164.25 99.62,163.61 99.62,162.51 99.09,161.98 99.09,161.96 97.27,160.14 91.04,160.14 90.66,160.52 90.66,167.62 90.99,167.96 103.85,167.96
+AC_BAT_SYS on BOTTOM (solid shape): 89.64,181.06 89.64,180.06 89.5,179.91 89.36,179.91 89.04,179.59 88.82,179.44 88.67,179.23 87.97,178.52 79.36,178.52 79.23,178.65 79.23,179.41 79.48,179.66 80.75,179.66 80.88,179.79 80.88,180.55 81.03,180.7 81.55,180.7 81.91,180.26 82.47,180.19 83.05,180.19 84.09,181.24 89.47,181.24
+AC_BAT_SYS on BOTTOM (solid shape): outline of 2088 points within 40.37,148.06 70.99,177.52
+AC_BAT_SYS on BOTTOM (solid shape): outline of 2971 points within 257.99,13.19 287.43,68.71
+AC_BAT_SYS on IN1 (solid shape): 31.98,9.13 31.98,6.26 31.55,5.82 29.44,5.82 29.06,6.2 29.06,9.13 29.32,9.38 31.73,9.38
+AC_BAT_SYS on IN1 (solid shape): 236.31,9.33 236.31,7.82 235.96,7.47 221.54,7.47 221.21,7.8 221.21,9.11 221.48,9.38 236.26,9.38
+AC_BAT_SYS on IN1 (solid shape): 99.95,191.37 99.95,190.92 99.6,190.57 97.55,190.57 97.41,190.72 97.41,191.38 97.53,191.5 98.28,191.5 98.3,191.52 99.8,191.52
+AC_BAT_SYS on IN1 (solid shape): 55.86,192.26 55.86,191.5 55.73,191.37 43.8,191.37 43.67,191.5 43.67,192.26 43.8,192.39 55.73,192.39
+AC_BAT_SYS on IN1 (solid shape): 287.5,16.31 287.5,15.59 287.52,15.57 287.52,13.4 287.5,13.37 287.32,13.19 281.67,13.19 281.41,13.44 281.41,16.87 281.67,17.13 286.69,17.13
+AC_BAT_SYS on IN1 (solid shape): 19.96,45.47 19.96,43.05 20.17,42.83 20.17,41.64 18.4,41.64 18.26,41.78 18.26,44.35 17.6,45.01 17.6,45.34 18.21,45.95 19.48,45.95
+AC_BAT_SYS on IN1 (solid shape): 82.91,4.76 82.91,3.21 82.96,3.16 83.14,3.16 83.17,3.13 83.17,1.38 83.04,1.25 80.37,1.25 80.12,1.51 80.12,4.76 80.3,4.93 82.73,4.93
+AC_BAT_SYS on IN1 (solid shape): 24.12,81.5 24.12,75.85 24.09,75.82 24.09,75.15 22.71,73.77 20.17,73.77 19.67,74.28 19.67,76 20.05,76.38 20.05,76.79 20.06,76.93 20.05,77.07 20.05,81.39 21.5,81.39 21.85,81.74 23.88,81.74
+AC_BAT_SYS on IN1 (solid shape): outline of 3246 points within 40.37,154.92 94.57,179.81
+AC_BAT_SYS on GND2 (solid shape): outline of 223 points within 1.25,1.25 287.51,160.89
+AC_BAT_SYS on IN2 (solid shape): 31.98,9.13 31.98,6.26 31.55,5.82 29.44,5.82 29.06,6.2 29.06,9.13 29.32,9.38 31.73,9.38
+AC_BAT_SYS on IN2 (solid shape): 287.52,15.57 287.52,13.4 287.32,13.19 281.67,13.19 281.41,13.44 281.41,16.87 281.67,17.13 285.97,17.13
+AC_BAT_SYS on IN2 (solid shape): 44.91,160.67 44.91,155.52 44.43,155.05 40.87,155.05 40.37,155.56 40.37,160.64 40.87,161.14 44.43,161.14
+AC_BAT_SYS on IN2 (solid shape): 236.31,9.33 236.31,7.82 235.96,7.47 221.54,7.47 221.21,7.8 221.21,9.11 221.48,9.38 236.26,9.38
+AC_BAT_SYS on IN2 (solid shape): 19.96,45.47 19.96,43.05 20.17,42.83 20.17,41.64 18.4,41.64 18.26,41.78 18.26,44.35 17.6,45.01 17.6,45.34 18.21,45.95 19.48,45.95
+AC_BAT_SYS on IN2 (solid shape): 82.91,4.76 82.91,3.21 82.96,3.16 83.14,3.16 83.17,3.13 83.17,1.38 83.04,1.25 80.37,1.25 80.12,1.51 80.12,4.76 80.3,4.93 82.73,4.93
+AC_BAT_SYS on IN2 (solid shape): 24.12,81.5 24.12,75.85 24.09,75.82 24.09,75.15 22.71,73.77 20.05,73.77 19.54,74.28 19.54,75.93 20.05,76.44 20.05,76.79 20.06,76.93 20.05,77.07 20.05,81.39 21.5,81.39 21.85,81.74 23.88,81.74
+AC_BAT_SYS on GND3 (solid shape): outline of 223 points within 1.25,1.25 287.51,160.89
+AC_BAT_SYS on VCC1 (solid shape): 87.84,179.56 87.84,178.77 87.85,178.72 87.88,178.68 88.36,178.2 88.4,178.17 88.45,178.16 89.01,178.16 90.43,176.74 90.43,175.37 90.44,175.32 90.47,175.28 91.09,174.66 91.09,170.37 90.71,169.98 69.53,169.98 68.84,170.67 68.84,177.22 69.35,177.73 78.54,177.73 78.59,177.74 78.63,177.77 80.63,179.76 87.63,179.76
+AC_BAT_SYS on VCC1 (solid shape): outline of 223 points within 1.25,1.25 287.51,160.89
+AC_BAT_SYS on VCC2 (solid shape): 87.84,179.56 87.84,178.77 87.85,178.72 87.88,178.68 88.36,178.2 88.4,178.17 88.45,178.16 89.01,178.16 90.43,176.74 90.43,175.37 90.44,175.32 90.47,175.28 91.09,174.66 91.09,170.37 90.71,169.98 69.53,169.98 68.84,170.67 68.84,177.22 69.35,177.73 78.54,177.73 78.59,177.74 78.63,177.77 80.63,179.76 87.63,179.76
+AC_BAT_SYS on VCC2 (solid shape): outline of 223 points within 1.25,1.25 287.51,160.89
+AC_BAT_SYS on GND4 (solid shape): outline of 223 points within 1.25,1.25 287.51,160.89
+AC_BAT_SYS on IN3 (solid shape): 31.98,9.13 31.98,6.26 31.55,5.82 29.44,5.82 29.06,6.2 29.06,9.13 29.32,9.38 31.73,9.38
+AC_BAT_SYS on IN3 (solid shape): 44.94,160.64 44.94,155.56 44.43,155.05 40.87,155.05 40.37,155.56 40.37,160.64 40.87,161.14 44.43,161.14
+AC_BAT_SYS on IN3 (solid shape): 287.52,15.57 287.52,13.4 287.32,13.19 281.67,13.19 281.41,13.44 281.41,16.87 281.67,17.13 285.97,17.13
+AC_BAT_SYS on IN3 (solid shape): 236.31,9.33 236.31,7.82 235.96,7.47 221.54,7.47 221.21,7.8 221.21,9.11 221.48,9.38 236.26,9.38
+AC_BAT_SYS on IN3 (solid shape): 99.95,191.37 99.95,190.92 99.6,190.57 97.55,190.57 97.41,190.72 97.41,191.38 97.53,191.5 98.28,191.5 98.3,191.52 99.8,191.52
+AC_BAT_SYS on IN3 (solid shape): 55.86,192.26 55.86,191.5 55.73,191.37 43.8,191.37 43.67,191.5 43.67,192.26 43.8,192.39 55.73,192.39
+AC_BAT_SYS on IN3 (solid shape): 19.96,45.47 19.96,43.05 20.17,42.83 20.17,41.64 18.4,41.64 18.26,41.78 18.26,44.35 18.25,44.36 18.25,44.64 17.66,45.22 17.66,45.41 18.21,45.95 19.48,45.95
+AC_BAT_SYS on IN3 (solid shape): 82.91,4.76 82.91,3.21 82.96,3.16 83.14,3.16 83.17,3.13 83.17,1.38 83.04,1.25 80.37,1.25 80.12,1.51 80.12,4.76 80.3,4.93 82.73,4.93
+AC_BAT_SYS on IN3 (solid shape): 24.12,81.5 24.12,75.85 24.09,75.82 24.09,75.15 22.71,73.77 20.17,73.77 19.67,74.28 19.67,76 20.05,76.38 20.05,76.79 20.06,76.93 20.05,77.07 20.05,81.39 21.5,81.39 21.85,81.74 23.88,81.74
+AC_BAT_SYS on IN3 (solid shape): outline of 942 points within 83.27,160.01 102.78,181.06
+AC_BAT_SYS on GND5 (solid shape): outline of 92 points within 1.25,43.54 53.07,160.89
+AC_BAT_SYS on GND5 (solid shape): 286.24,16.82 286.25,16.79 287.51,15.55 287.51,13.37 287.33,13.19 242.75,13.19 242.72,13.15 241.7,12.14 241.66,12.1 241.66,9.31 239.96,7.6 180.25,7.6 178.12,9.72 178.09,9.76 161.47,9.76 161.44,9.72 160.29,8.58 160.25,8.54 160.25,2.83 158.68,1.25 74.2,1.25 66.24,9.22 66.2,9.25 54.41,9.25 54.23,9.07 52.93,9.97 53.83,8.67 50.98,5.82 29.06,5.82 29.06,9.2 29.37,9.51 31.68,9.51 31.98,9.2 31.98,7.73 49.69,7.73 49.73,7.77 50.24,8.27 50.27,8.31 50.27,10.47 52.23,12.43 54.79,12.43 56.15,11.07 56.19,11.03 66.98,11.03 74.82,3.19 74.86,3.16 80.04,3.16 80.12,3.23 80.12,4.76 80.3,4.93 82.73,4.93 82.91,4.76 82.91,3.23 82.99,3.16 157.89,3.16 158.35,3.61 158.35,9.33 160.69,11.67 179,11.67 181.12,9.54 181.16,9.51 238.67,9.51 238.7,9.54 239.59,10.43 239.63,10.47 239.63,12.76 241.97,15.09 280.83,15.09 280.87,15.13 281.38,15.64 281.41,15.68 281.41,16.82 281.72,17.13 285.93,17.13
+AC_BAT_SYS on IN4 (solid shape): 31.98,9.13 31.98,6.26 31.55,5.82 29.44,5.82 29.06,6.2 29.06,9.13 29.32,9.38 31.73,9.38
+AC_BAT_SYS on IN4 (solid shape): 44.94,160.64 44.94,155.56 44.43,155.05 40.87,155.05 40.37,155.56 40.37,160.64 40.87,161.14 44.43,161.14
+AC_BAT_SYS on IN4 (solid shape): 72.02,160.81 72.02,154.26 71.66,153.91 68.18,153.91 67.49,154.59 67.49,161.22 67.7,161.42 71.41,161.42
+AC_BAT_SYS on IN4 (solid shape): 287.52,15.57 287.52,13.4 287.32,13.19 281.67,13.19 281.41,13.44 281.41,16.87 281.67,17.13 285.97,17.13
+AC_BAT_SYS on IN4 (solid shape): 236.31,9.33 236.31,7.82 235.96,7.47 221.54,7.47 221.21,7.8 221.21,9.11 221.48,9.38 236.26,9.38
+AC_BAT_SYS on IN4 (solid shape): 55.86,192.26 55.86,191.5 55.73,191.37 43.8,191.37 43.67,191.5 43.67,192.26 43.8,192.39 55.73,192.39
+AC_BAT_SYS on IN4 (solid shape): 99.95,191.37 99.95,190.92 99.6,190.57 97.55,190.57 97.41,190.72 97.41,191.38 97.53,191.5 98.28,191.5 98.3,191.52 99.8,191.52
+AC_BAT_SYS on IN4 (solid shape): 19.96,45.47 19.96,44.7 19.96,43.89 19.74,43.67 18.56,43.67 18.26,43.98 18.26,44.35 17.6,45.01 17.6,45.34 18.21,45.95 19.48,45.95
+AC_BAT_SYS on IN4 (solid shape): 116.26,153.22 116.26,151.86 116.1,151.7 115.18,151.7 114.12,152.76 114.12,153.81 114.22,153.91 114.42,153.95 114.6,154.03 115.45,154.03
+AC_BAT_SYS on IN4 (solid shape): 82.91,4.76 82.91,3.21 82.96,3.16 83.14,3.16 83.17,3.13 83.17,1.38 83.04,1.25 80.37,1.25 80.12,1.51 80.12,4.76 80.3,4.93 82.73,4.93
+AC_BAT_SYS on IN4 (solid shape): 24.12,81.5 24.12,76.67 22.89,75.44 22.89,74.07 22.59,73.77 20.3,73.77 19.69,74.38 19.69,76.03 20.05,76.38 20.05,76.79 20.06,76.93 20.05,77.07 20.05,81.39 21.5,81.39 21.85,81.74 23.88,81.74
+AC_BAT_SYS_FBVDDQ on TOP (solid shape): 188.19,184.51 188.19,182.23 187.94,181.97 184.51,181.97 184.26,182.23 184.26,184.51 184.51,184.77 187.94,184.77
+AC_BAT_SYS_FBVDDQ on TOP (solid shape): 231.47,97.22 232.37,96.77 233.28,96.35 233.28,93.92 233.91,93.29 238.18,93.29 238.6,93.71 241.53,93.71 241.79,93.45 241.79,92.56 238.84,92.56 237.93,91.65 237.93,86.99 237.8,86.86 234.73,86.86 234.44,86.57 227.31,86.57 226.73,87.15 226.73,96.15 226.9,96.32 230.78,96.32 230.94,96.48 230.94,97.01 231.16,97.22
+AC_BAT_SYS_FBVDDQ on TOP (solid shape): outline of 291 points within 98.66,164.64 117.91,176.52
+AC_BAT_SYS_FBVDDQ on BOTTOM (solid shape): 118.07,176.59 118.07,172.5 118.01,172.45 113.39,172.45 111.7,174.14 111.7,176.3 112.35,176.94 115.9,176.94 115.91,176.94 117.71,176.94
+AC_BAT_SYS_FBVDDQ on IN2 (solid shape): 213.47,116.44 214.23,114.56 214.23,112.37 213.41,111.74 211.94,111.74 211.82,111.87 211.82,116.57 212.07,116.82 213.28,116.82
+AC_BAT_SYS_FBVDDQ on IN2 (solid shape): 223.63,102.15 223.63,101.2 222.87,100.44 218.55,100.44 218.29,100.69 218.29,101.98 218.98,102.26 219.63,102.63 223.15,102.63
+AC_BAT_SYS_FBVDDQ on IN2 (solid shape): 231.3,97.31 232.34,96.79 233.41,96.29 233.41,94.98 233.28,94.85 233.28,94.52 233.1,94.34 230.16,94.34 228.18,96.32 229.11,96.32 229.11,96.65 229.21,96.76 230.69,96.76 231.16,97.22 231.21,97.22
+AC_BAT_SYS_FBVDDQ on IN2 (solid shape): outline of 5309 points within 90.23,168.89 192.89,192.51
+AC_BAT_SYS_FBVDDQ on GND3 (solid shape): outline of 96 points within 184.26,94.34 233.28,184.77
+AC_BAT_SYS_FBVDDQ on VCC1 (solid shape): outline of 96 points within 184.26,94.34 233.28,184.77
+AC_BAT_SYS_FBVDDQ on VCC2 (solid shape): outline of 95 points within 184.26,94.34 233.28,184.77
+AC_BAT_SYS_NVVDD on TOP (solid shape): outline of 131 points within 121.13,172.09 182.35,189.34
+AC_BAT_SYS_NVVDD on BOTTOM (solid shape): 168.26,187.56 168.26,184.64 168.13,184.51 165.33,184.51 164.83,185.02 164.83,187.33 165.35,187.86 167.96,187.86
+AC_BAT_SYS_NVVDD on BOTTOM (solid shape): 179.56,187.43 179.56,184.77 179.3,184.51 176.64,184.51 176.38,184.77 176.38,187.43 176.39,187.44 176.39,187.58 176.64,187.84 179.15,187.84
+AC_BAT_SYS_NVVDD on BOTTOM (solid shape): 157.21,187.31 157.21,184.64 156.95,184.39 153.69,184.39 152.35,185.72 152.35,186.61 153.3,187.56 156.95,187.56
+AC_BAT_SYS_NVVDD on BOTTOM (solid shape): 146.03,187.31 146.03,184.64 145.78,184.39 143.11,184.39 142.09,185.41 142.09,186.54 143.11,187.56 145.78,187.56
+AC_BAT_SYS_NVVDD on BOTTOM (solid shape): 127.27,178.73 127.27,171.72 126.76,171.21 123.18,171.21 122.67,171.72 122.5,171.96 122.27,172.13 121.95,172.45 119.11,172.45 118.93,172.63 118.93,176.67 121.2,178.95 127.05,178.95
+AC_BAT_SYS_NVVDD on GND1 (solid shape): 158.77,188.74 158.81,188.71 158.86,188.7 181.79,188.7 182.35,188.14 182.35,182.66 181.79,182.1 160.18,182.1 159.2,183.08 159.16,183.11 159.11,183.12 154.97,183.12 153.49,184.6 153.45,184.63 153.4,184.64 147.68,184.64 147.63,184.63 147.59,184.6 146.96,183.97 146.93,183.93 146.92,183.88 146.92,181.39 145.05,179.52 145.02,179.48 145.01,179.43 145.01,177.96 142.8,175.75 127.74,175.75 127.69,175.74 127.65,175.71 127.02,175.08 126.99,175.04 126.98,174.99 126.98,173.64 126.8,173.46 121.57,173.46 121.14,173.9 121.14,178.62 121.57,179.05 124.57,179.05 124.62,179.06 124.66,179.09 127.41,181.85 139.81,181.85 139.86,181.86 139.9,181.88 141.17,183.15 141.2,183.19 141.2,183.24 141.2,188.4 142.15,189.34 158.17,189.34
+AC_BAT_SYS_NVVDD on IN1 (solid shape): outline of 102 points within 121.18,173.46 182.35,189.35
+AC_BAT_SYS_NVVDDS on TOP (solid shape): 122.35,171.48 122.35,170.07 121.32,169.04 119.14,169.04 118.73,169.45 118.73,172.5 118.85,172.62 121.21,172.62
+AC_BAT_SYS_NVVDDS on TOP (solid shape): 193.78,184.64 193.79,184.63 193.98,184.3 194.3,184.11 194.31,184.11 194.81,183.61 195.05,183.61 195.31,183.35 196.13,182.97 196.77,183.61 199.29,183.61 200.78,182.13 206.31,182.13 206.38,182.05 206.38,175.38 206.3,175.29 205.11,175.29 205.03,175.38 205.03,176.01 204.49,176.54 193.43,176.54 193.15,176.26 193.15,175.39 192.86,175.1 191.71,175.1 191.41,175.4 191.41,180.07 191.03,180.45 188.83,180.45 188.7,180.58 188.7,185.27 188.83,185.4 193.02,185.4
+AC_BAT_SYS_NVVDDS on IN3 (solid shape): outline of 3348 points within 119.56,170.06 195.56,192.51
+BAT on TOP (solid shape): outline of 134 points within 300.59,15.73 308.21,25.51
+BAT_CON on TOP (solid shape): 313.42,26.02 313.42,13.82 312.91,13.32 309.19,13.32 308.72,13.78 308.72,25.13 310.11,26.52 312.91,26.52
+BAT_CON on BOTTOM (solid shape): 291.4,25.05 291.4,22.71 291.7,22.41 304.52,22.41 306.43,23.22 312.91,23.22 313.54,22.59 313.54,14.08 313.29,13.82 308.92,13.82 308.59,14.16 289.72,14.16 284.51,19.36 296.58,19.36 296.58,19.33 296.58,19.28 296.6,19.23 296.62,19.17 296.66,19.13 296.69,19.09 296.74,19.05 296.78,19.02 296.83,19 296.89,18.99 296.94,18.98 297,18.98 297.05,18.99 297.11,19.01 297.16,19.04 297.2,19.07 297.24,19.11 297.28,19.15 297.3,19.2 297.32,19.25 297.34,19.31 297.34,19.36 297.34,19.38 305.27,19.38 305.27,17.16 305.57,16.86 306.09,16.86 306.29,17.06 307.87,17.06 307.98,17.16 307.98,19.68 305.58,19.68 305.27,19.38 297.34,19.38 297.34,19.42 297.32,19.47 297.3,19.52 297.28,19.57 297.24,19.62 297.2,19.66 297.16,19.69 297.11,19.71 297.05,19.73 297,19.74 296.94,19.74 296.89,19.74 296.83,19.72 296.78,19.7 296.74,19.67 296.69,19.64 296.66,19.6 296.62,19.55 296.6,19.5 296.58,19.45 296.58,19.39 296.58,19.36 284.51,19.36 283.85,20.03 283.83,25.39 284.4,25.95 287.17,25.95 287.48,26.26 290.19,26.26
+BAT_R on TOP (solid shape): 298.56,24.87 298.56,22.97 299.9,21.62 299.9,15.59 299.32,15.01 299.32,14.35 298.98,14.01 298.98,13.17 298.9,13.09 298.45,13.09 298.43,13.11 298.43,14.03 298.25,14.21 296.25,14.21 295.93,14.52 295.93,19.44 296.48,19.44 296.48,18.35 296.58,18.35 296.58,18.34 297.35,18.34 297.35,18.35 297.44,18.35 297.44,18.43 297.45,18.44 297.45,19.4 297.27,19.58 297.26,19.6 297.23,19.63 297.19,19.66 297.1,19.75 296.79,19.75 296.49,19.45 296.48,19.44 295.93,19.44 295.93,19.54 294.75,20.73 294.75,24.87 295,25.13 298.3,25.13
+FBVDDQ on TOP (solid shape): outline of 48799 points within 136.51,42.65 220.86,143.42
+FBVDDQ on BOTTOM (solid shape): 155.5,105.59 155.61,105.59 156.11,105.08 156.04,104.97 155.97,104.71 156.1,104.47 156.13,104.4 156.1,104.32 156.05,104.27 155.9,104.27 154.8,105.37 154.8,105.52 154.87,105.6 155.5,105.6
+FBVDDQ on BOTTOM (solid shape): 170.32,105.67 170.4,105.57 170.53,105.5 170.61,105.47 170.7,105.47 170.75,105.43 170.75,105.4 170.75,104.98 170.67,104.75 170.75,104.52 170.75,104.32 170.65,104.23 168.86,104.23 168.86,104.28 168.87,104.33 168.92,104.37 168.92,104.37 169.28,104.57 169.25,104.97 169.18,105.09 169.18,105.25 169.21,105.3 169.24,105.37 169.33,105.45 169.35,105.46 169.52,105.51 169.64,105.65 169.66,105.67
+FBVDDQ on BOTTOM (solid shape): 172.16,103.1 172.41,102.97 172.67,103.04 172.76,103.1 172.98,103.1 173.03,103.07 173.09,103.05 173.15,103.02 173.18,102.95 173.22,102.78 173.35,102.66 173.35,101.92 173.32,101.9 173.21,101.83 173.14,101.72 173.12,101.69 173.11,101.64 172.95,101.48 172.79,101.48 172.66,101.56 172.62,101.64 172.65,101.72 172.66,101.73 172.66,102.16 172.23,102.16 172.2,102.13 171.96,102.05 171.9,102.05 171.9,103 172,103.1
+FBVDDQ on BOTTOM (solid shape): 170.82,83.52 170.82,83.35 170.68,83.11 170.74,82.83 170.82,82.71 170.82,82.55 170.79,82.51 170.75,82.44 170.48,82.31 170.41,82.22 169.61,82.22 169.5,82.29 169.38,82.32 169.35,82.33 169.24,82.43 169.21,82.5 169.18,82.55 169.18,82.71 169.26,82.83 168.95,83.43 168.64,82.83 168.72,82.71 168.72,82.55 168.7,82.53 168.49,82.32 168.33,82.22 167.51,82.22 167.42,82.29 167.32,82.32 167.3,82.32 167.09,82.53 167.08,82.55 167.08,82.71 167.16,82.84 167.24,82.88 167.32,82.85 167.33,82.83 167.76,82.83 167.76,83.26 167.73,83.3 167.65,83.54 167.65,83.6 170.75,83.6
+FBVDDQ on BOTTOM (solid shape): 166.83,83.6 166.91,83.56 166.93,83.47 166.88,83.43 166.86,83.43 166.51,83.23 166.54,82.83 166.62,82.71 166.62,82.55 166.6,82.53 166.39,82.32 166.24,82.23 166.2,82.2 165.27,82.2 165.04,82.43 165.01,82.5 164.98,82.55 164.98,82.71 165.06,82.83 164.75,83.43 164.44,82.83 164.52,82.71 164.52,82.55 164.5,82.52 164.47,82.47 164.19,82.29 164.12,82.18 164.11,82.15 163.38,82.15 163.32,82.22 163.23,82.27 163.15,82.31 163.06,82.33 163.04,82.33 162.94,82.43 162.91,82.5 162.88,82.55 162.88,82.71 162.96,82.83 162.98,83.23 162.64,83.43 162.62,83.43 162.57,83.47 162.59,83.56 162.67,83.6
+FBVDDQ on BOTTOM (solid shape): 161.85,83.54 161.77,83.3 161.73,83.26 161.73,82.83 162.16,82.83 162.18,82.85 162.26,82.88 162.34,82.84 162.42,82.71 162.42,82.55 162.4,82.52 162.37,82.47 162.23,82.33 162.21,82.33 162.15,82.31 162.09,82.28 161.99,82.22 161.92,82.12 161.24,82.12 161.22,82.16 161.13,82.3 160.97,82.38 160.92,82.4 160.78,82.55 160.78,82.71 160.86,82.83 160.55,83.43 160.24,82.83 160.32,82.71 160.32,82.55 160.2,82.42 159.92,82.25 159.85,82.15 159.14,82.15 159.11,82.19 159.03,82.27 158.92,82.32 158.91,82.32 158.69,82.53 158.68,82.55 158.68,82.71 158.76,82.83 158.82,83.11 158.67,83.35 158.67,83.55 158.72,83.6 161.85,83.6
+FBVDDQ on BOTTOM (solid shape): 166.16,105.7 166.26,105.57 166.41,105.5 166.42,105.5 166.56,105.37 166.59,105.3 166.62,105.25 166.62,105.09 166.54,104.97 166.85,104.37 167.15,104.97 167.08,105.09 167.08,105.25 167.11,105.29 167.13,105.34 167.24,105.44 167.24,105.51 167.4,105.67 168.15,105.67 168.36,105.47 168.36,105.47 168.43,105.39 168.56,105.39 168.72,105.23 168.72,105.09 168.64,104.96 168.56,104.92 168.48,104.95 168.46,104.96 168.03,104.96 168.03,104.53 168.07,104.5 168.14,104.28 168.14,104.23 162.56,104.23 162.56,104.28 162.57,104.33 162.59,104.36 162.62,104.37 162.98,104.57 162.95,104.97 162.88,105.09 162.88,105.25 162.91,105.29 162.93,105.34 163.04,105.45 163.28,105.58 163.36,105.67 163.91,105.67 164.27,105.32 164.48,105.32 164.5,105.28 164.52,105.25 164.52,105.09 164.44,104.97 164.75,104.37 165.05,104.97 164.98,105.09 164.98,105.25 165.01,105.29 165.04,105.35 165.07,105.38 165.25,105.49 165.36,105.57 165.42,105.67 165.44,105.7
+FBVDDQ on BOTTOM (solid shape): 157.99,105.39 157.99,105.34 158.22,105.11 158.22,105.09 158.14,104.97 158.45,104.37 158.75,104.97 158.68,105.09 158.68,105.25 158.71,105.29 158.73,105.34 158.96,105.57 159.02,105.6 159.06,105.63 159.08,105.65 159.89,105.65 159.9,105.62 160.02,105.49 160.2,105.43 160.22,105.43 160.25,105.4 160.25,105.39 160.28,105.31 160.32,105.25 160.32,105.09 160.24,104.97 160.55,104.37 160.85,104.97 160.78,105.09 160.78,105.25 160.81,105.29 160.83,105.34 160.98,105.48 161.04,105.48 161.09,105.53 161.11,105.53 161.2,105.62 162.05,105.62 162.11,105.56 162.18,105.51 162.32,105.39 162.37,105.34 162.39,105.29 162.42,105.25 162.42,105.09 162.34,104.96 162.26,104.92 162.18,104.95 162.16,104.96 161.73,104.96 161.73,104.53 161.77,104.5 161.84,104.28 161.84,104.23 157.8,104.23 157.35,104.67 157.35,104.75 157.17,105.03 156.84,104.97 156.77,104.94 156.7,104.97 156.6,105.07 156.6,105.28 156.63,105.33 156.7,105.4 156.85,105.49 156.96,105.57 157.03,105.69 157.04,105.72 157.66,105.72
+FBVDDQ on BOTTOM (solid shape): 172.95,101.02 173,100.99 173.07,100.96 173.16,100.87 173.16,100.85 173.21,100.7 173.32,100.59 173.32,99.83 173.24,99.76 173.06,99.48 172.98,99.4 172.95,99.38 172.79,99.38 172.67,99.46 172.07,99.15 172.67,98.84 172.79,98.92 172.95,98.92 172.97,98.9 173.2,98.67 173.25,98.56 173.32,98.48 173.32,97.74 173.21,97.63 173.15,97.47 173.15,97.45 173.03,97.33 172.98,97.3 172.95,97.28 172.79,97.28 172.67,97.36 172.07,97.05 172.67,96.74 172.79,96.82 172.95,96.82 172.97,96.8 173.15,96.62 173.16,96.61 173.22,96.45 173.35,96.35 173.35,95.66 173.24,95.56 173.18,95.42 173.17,95.37 173.03,95.23 172.98,95.2 172.95,95.18 172.79,95.18 172.66,95.26 172.62,95.34 172.65,95.42 172.66,95.43 172.66,95.86 172.23,95.86 172.2,95.83 171.96,95.75 171.9,95.75 171.9,100.89 171.98,100.97 172.19,100.97 172.43,100.87 172.67,100.94 172.79,101.02
+FBVDDQ on BOTTOM (solid shape): outline of 106 points within 171.89,84.67 173.35,94.72
+FBVDDQ on BOTTOM (solid shape): outline of 629 points within 139.33,135.16 149.34,143.44
+FBVDDQ on BOTTOM (solid shape): outline of 3428 points within 154.41,44.81 210.4,77.55
+FBVDDQ on BOTTOM (solid shape): outline of 6551 points within 150.35,78.12 235.62,145.14
+FBVDDQ on IN1 (solid shape): outline of 153 points within 194.17,125.26 209.45,139.89
+FBVDDQ on IN1 (solid shape): outline of 1757 points within 155.39,81.74 173.54,105.64
+FBVDDQ on VCC1 (solid shape): 208.9,126.25 208.9,126.19 209.94,121.74 209.95,121.73 211.31,117.14 211.31,112.3 209.96,110.35 209.31,108.07 209.3,108.04 210.29,103.47 213.85,100.43 213.85,98.21 213.25,97.61 213.22,97.57 213.21,97.52 213.21,70.77 212.15,69.7 211.29,69.7 210.1,70.89 210.06,70.92 210.01,70.93 206.36,70.93 206.31,70.92 206.27,70.89 205.2,69.82 205.17,69.78 205.16,69.73 205.16,64.24 194.24,53.32 193.66,53.32 193.61,53.31 193.57,53.28 189.88,49.6 189.86,49.56 189.85,49.51 189.85,48.93 185.86,44.94 154.72,44.94 154.54,45.12 154.54,65.51 178.42,65.51 178.46,65.52 178.51,65.55 190.32,77.36 190.34,77.4 190.35,77.45 190.35,133.46 208.9,133.46
+FBVDDQ on VCC2 (solid shape): 208.9,126.25 208.9,126.19 209.94,121.74 209.95,121.73 211.31,117.14 211.31,112.3 209.95,110.33 209.3,108.04 210.29,103.47 213.85,100.43 213.85,98.21 213.25,97.61 213.22,97.57 213.21,97.52 213.21,70.77 212.14,69.7 211.27,69.7 210.06,70.9 210.02,70.93 209.97,70.94 206.36,70.94 206.31,70.93 206.27,70.9 205.19,69.83 205.17,69.78 205.16,69.74 205.16,64.24 194.24,53.32 193.66,53.32 193.61,53.31 193.57,53.28 189.88,49.6 189.86,49.56 189.85,49.51 189.85,48.93 185.86,44.94 154.72,44.94 154.54,45.12 154.54,65.51 178.42,65.51 178.46,65.52 178.51,65.55 190.32,77.36 190.34,77.4 190.35,77.45 190.35,133.46 208.9,133.46
+FBVDDQ on IN3 (solid shape): outline of 60556 points within 140.98,45.96 214.99,144.01
+FBVDDQ on IN4 (solid shape): outline of 246 points within 171.95,95.2 173.45,101.37
+FBVDDQ on IN4 (solid shape): outline of 387 points within 158.69,81.75 167.01,83.7
+FBVDDQ on IN4 (solid shape): outline of 620 points within 167.09,81.75 173.75,95.07
+FBVDDQ on IN4 (solid shape): outline of 923 points within 155.7,101.26 173.75,106.05
+LX on TOP (solid shape): 282.25,98.15 282.25,97.76 282.45,97.57 283.7,97.57 284.03,97.9 285.12,97.9 285.6,97.42 285.6,95.97 285.51,95.88 283.25,95.88 283.25,95.88 282.75,95.88 282.35,96.27 282.35,96.78 281.59,97.54 281.59,98.25 281.61,98.28 282.12,98.28
+NVVDD on TOP (solid shape): 134.59,146.55 134.59,144.5 133.46,143.36 131.32,143.36 131.1,143.58 131.1,147.62 131.3,147.81 133.33,147.81
+NVVDD on TOP (solid shape): 169.56,99.72 169.56,95.8 169.44,95.68 169.1,95.68 169,95.78 169,96.32 168.85,96.48 168.85,97.13 168.95,97.23 168.95,97.31 168.96,97.41 168.95,97.51 168.95,97.59 168.8,97.75 168.8,98.4 168.92,98.53 168.92,98.64 168.93,98.65 168.96,98.8 168.93,98.94 168.92,98.95 168.92,99.02 168.85,99.09 168.85,99.74 168.9,99.79 169.49,99.79
+NVVDD on TOP (solid shape): 179.68,161.25 183.99,161.25 185.23,160.02 185.23,154.77 185.12,154.67 179.97,154.67 179.7,154.39 179.7,144.33 179.36,143.99 178.87,143.99 178.59,143.71 169.98,143.71 169.78,143.91 169.78,157.52 169.59,157.71 156.26,157.71 156.06,157.5 156.06,151.5 156.33,151.23 156.33,144.04 156.24,143.95 155.1,143.95 155,144.05 143.59,144.05 143.08,144.56 142.72,144.56 142.44,144.84 142.44,159.92 144.26,161.74 179.19,161.74
+NVVDD on TOP (solid shape): 154.24,92 154.24,91.88 154.24,91.83 154.24,91.72 154.24,91.49 154.34,91.39 154.34,90.66 154.3,90.61 154.27,90.56 154.24,90.53 154.24,90.48 154.23,90.41 154.24,90.33 154.24,90.25 154.42,90.07 154.42,89.36 154.24,89.19 154.24,89.07 154.23,88.99 154.24,88.92 154.24,88.83 154.42,88.65 154.42,88.09 154.38,88.05 153.8,88.05 153.66,88.19 153.66,91.93 153.76,92.03 154.22,92.03
+NVVDD on TOP (solid shape): 163.34,99.81 163.4,99.9 163.51,99.88 163.54,99.88 163.55,99.87 163.71,99.83 163.87,99.87 163.88,99.88 163.9,99.88 163.91,99.89 163.96,99.9 164,99.85 164,95.89 163.85,95.74 163.56,95.74 163.39,95.92 163.39,97.49 163.34,97.54 163.34,97.55 163.34,98.7 163.35,98.81 163.34,98.93
+NVVDD on TOP (solid shape): 158.44,92.45 158.46,92.38 158.46,91.92 158.46,91.91 158.44,91.79 158.46,91.67 158.46,91.66 158.46,90.53 158.46,90.52 158.44,90.4 158.46,90.28 158.46,90.27 158.46,89.12 158.46,89.11 158.43,88.99 158.46,88.87 158.46,88.86 158.46,87.75 158.46,87.74 158.43,87.6 158.46,87.46 158.46,87.45 158.46,86.44 158.38,86.37 158.38,85.37 158.31,85.3 157.98,85.3 157.77,85.5 157.77,88.07 157.77,92.64 157.85,92.71 158.18,92.71
+NVVDD on TOP (solid shape): 159.98,91.29 159.98,90.68 159.85,90.4 159.98,90.13 159.98,89.3 159.83,89 159.98,88.71 159.98,88.12 160.29,87.81 160.31,87.8 160.43,87.58 160.28,87.38 160.22,87.36 160.06,87.36 159.87,87.55 159.87,87.71 159.82,87.76 159.81,87.76 159.74,87.86 159.65,87.93 159.63,87.94 159.52,87.96 159.43,87.96 159.3,88.09 159.3,88.86 159.27,88.91 159.27,89.09 159.3,89.14 159.3,90.26 159.27,90.31 159.27,90.49 159.3,90.54 159.3,91.34 159.37,91.42 159.86,91.42
+NVVDD on TOP (solid shape): 162.65,96.07 162.64,96.04 162.64,95.98 162.65,95.91 162.65,95.38 162.64,95.31 162.65,95.24 162.55,95.14 162.55,92.61 162.64,92.52 162.64,92.46 162.65,92.4 162.65,91.88 162.64,91.82 162.65,91.75 162.52,91.62 162.12,91.62 161.96,91.78 161.96,92.74 162.19,92.96 162.19,93.65 161.95,93.88 161.94,93.96 161.92,94.04 161.91,94.05 161.91,94.09 161.74,94.26 161.45,94.26 161.2,94.01 161.2,93.81 161.06,93.67 160.78,93.67 160.69,93.76 160.69,94.13 160.76,94.2 160.76,95.07 160.75,95.07 160.55,95.28 160.55,95.31 160.51,95.46 160.4,95.58 160.38,95.64 160.4,95.69 160.51,95.81 160.56,95.96 160.56,95.98 160.77,96.19 161.05,96.19 161.23,96.01 161.23,95.89 161.29,95.83 161.33,95.76 161.39,95.71 161.41,95.65 161.39,95.59 161.31,95.52 161.26,95.43 161.45,94.96 161.92,95.15 161.94,95.4 161.8,95.59 161.8,95.66 161.83,95.71 161.88,95.76 161.92,95.81 162.3,96.19 162.52,96.19
+NVVDD on TOP (solid shape): outline of 181 points within 154.98,84.59 157.01,92.74
+NVVDD on TOP (solid shape): outline of 766 points within 135.47,93.69 161.32,121
+NVVDD on TOP (solid shape): outline of 894 points within 161.74,84.56 169.66,103.25
+NVVDD on BOTTOM (solid shape): 156.76,99.44 156.76,99.04 156.8,99.02 156.81,99.01 156.85,98.95 156.91,98.91 156.93,98.79 156.88,98.67 156.84,98.63 156.76,98.58 156.76,97.62 156.83,97.58 156.86,97.55 156.89,97.52 156.93,97.41 156.9,97.29 156.85,97.25 156.81,97.19 156.76,97.16 156.76,96.22 156.82,96.19 156.86,96.15 156.89,96.12 156.93,96.01 156.9,95.89 156.87,95.87 156.85,95.84 156.77,95.77 156.71,95.77 156.65,95.77 156.59,95.79 156.55,95.84 156.49,95.89 156.47,95.93 156.46,95.93 156.4,95.96 156.37,96.02 156.36,96.13 156.28,96.24 156.21,96.29 156.2,96.37 156.22,96.43 156.24,96.46 156.24,96.94 156.22,96.97 156.2,97.04 156.22,97.12 156.23,97.15 156.23,97.65 156.22,97.68 156.2,97.75 156.22,97.83 156.24,97.86 156.24,98.34 156.22,98.37 156.2,98.44 156.21,98.52 156.23,98.55 156.23,99.05 156.21,99.08 156.2,99.14 156.2,99.2 156.21,99.21 156.21,99.48 156.29,99.57 156.63,99.57
+NVVDD on BOTTOM (solid shape): outline of 146 points within 131.4,143.76 184.43,167.14
+NVVDD on BOTTOM (solid shape): 156.81,92 156.85,91.95 156.9,91.91 156.93,91.8 156.89,91.68 156.86,91.65 156.82,91.61 156.76,91.57 156.76,90.64 156.81,90.61 156.85,90.55 156.9,90.51 156.93,90.39 156.89,90.28 156.86,90.25 156.82,90.21 156.76,90.17 156.76,89.24 156.81,89.21 156.85,89.15 156.9,89.11 156.93,88.99 156.89,88.88 156.86,88.85 156.83,88.82 156.76,88.78 156.76,88.44 156.64,88.32 156.33,88.32 156.23,88.42 156.23,88.55 156.22,88.58 156.2,88.65 156.22,88.72 156.25,88.75 156.3,88.8 156.3,88.81 156.33,88.85 156.34,89 156.33,89.15 156.26,89.22 156.23,89.26 156.2,89.34 156.22,89.42 156.23,89.45 156.23,89.95 156.22,89.98 156.2,90.04 156.21,90.11 156.25,90.14 156.29,90.19 156.36,90.23 156.36,90.57 156.28,90.61 156.25,90.65 156.22,90.68 156.2,90.75 156.22,90.83 156.23,90.85 156.23,91.34 156.22,91.37 156.2,91.46 156.22,91.54 156.33,91.62 156.33,91.72 156.34,91.78 156.38,91.84 156.44,91.87 156.47,91.87 156.5,91.91 156.55,91.96 156.59,92 156.63,92.02 156.68,92.03 156.77,92.04
+NVVDD on BOTTOM (solid shape): 159.21,91.59 159.25,91.55 159.29,91.51 159.33,91.45 159.49,91.45 159.57,91.37 159.57,90.78 159.57,90.63 159.61,90.6 159.65,90.55 159.69,90.52 159.72,90.39 159.68,90.27 159.65,90.25 159.63,90.22 159.57,90.18 159.57,90.02 159.57,89.38 159.57,89.23 159.61,89.21 159.65,89.15 159.69,89.12 159.72,88.99 159.67,88.87 159.57,88.78 159.57,88.36 159.46,88.24 159.09,88.24 159.03,88.31 159.03,88.56 159.01,88.58 159,88.65 159.01,88.72 159.05,88.75 159.09,88.79 159.15,88.82 159.15,88.91 159.16,89.01 159.15,89.11 159.15,89.18 159.11,89.2 159.06,89.26 159,89.31 159,89.36 159.01,89.41 159.02,89.43 159.02,89.97 159.01,89.99 159,90.05 159.01,90.11 159.05,90.15 159.09,90.19 159.15,90.22 159.15,90.31 159.16,90.41 159.15,90.5 159.15,90.58 159.11,90.6 159.06,90.66 159.01,90.7 159,90.76 159.02,90.82 159.03,90.85 159.03,91.35 159.02,91.38 159,91.44 159.01,91.51 159.05,91.54 159.1,91.59 159.14,91.62
+NVVDD on BOTTOM (solid shape): 169.33,92.03 169.37,92.02 169.41,92 169.45,91.95 169.51,91.91 169.53,91.87 169.57,91.87 169.63,91.84 169.65,91.78 169.66,91.73 169.67,91.69 169.67,91.62 169.73,91.58 169.76,91.55 169.78,91.53 169.8,91.46 169.79,91.39 169.78,91.37 169.78,90.83 169.79,90.81 169.8,90.74 169.78,90.67 169.76,90.65 169.73,90.62 169.67,90.58 169.67,90.51 169.67,90.51 169.65,90.4 169.67,90.29 169.67,90.29 169.67,90.22 169.73,90.18 169.76,90.15 169.78,90.13 169.8,90.06 169.79,90 169.78,89.97 169.78,89.43 169.79,89.4 169.8,89.34 169.78,89.27 169.76,89.25 169.73,89.22 169.67,89.18 169.67,89.11 169.67,89.11 169.65,89 169.67,88.89 169.67,88.89 169.67,88.82 169.73,88.78 169.76,88.75 169.78,88.73 169.8,88.67 169.8,88.61 169.79,88.59 169.79,88.31 169.72,88.24 169.32,88.24 169.22,88.33 169.22,88.59 169.23,88.65 169.22,88.71 169.22,89.29 169.23,89.35 169.23,90.05 169.22,90.11 169.22,90.69 169.23,90.75 169.23,91.45 169.22,91.58 169.18,91.61 169.15,91.65 169.11,91.68 169.08,91.8 169.11,91.92 169.15,91.95 169.18,91.99 169.24,92.04
+NVVDD on BOTTOM (solid shape): outline of 85 points within 166.27,88.26 167,92.04
+NVVDD on BOTTOM (solid shape): 154,99.71 154.05,99.66 154.1,99.61 154.13,99.5 154.11,99.39 154.06,99.35 154.01,99.3 153.95,99.26 153.95,96.24 154.01,96.2 154.05,96.15 154.09,96.12 154.12,95.99 154.07,95.87 154,95.8 153.99,95.77 153.91,95.78 153.84,95.78 153.78,95.81 153.75,95.85 153.7,95.89 153.67,95.93 153.64,95.93 153.58,95.96 153.56,96.02 153.55,96.08 153.52,96.15 153.52,96.19 153.49,96.21 153.45,96.25 153.41,96.29 153.4,96.39 153.46,96.48 153.52,96.51 153.52,96.89 153.46,96.92 153.4,97.01 153.41,97.11 153.45,97.15 153.49,97.19 153.52,97.21 153.52,97.25 153.53,97.26 153.56,97.4 153.53,97.54 153.52,97.55 153.52,97.59 153.49,97.61 153.45,97.65 153.41,97.69 153.4,97.79 153.46,97.88 153.52,97.91 153.52,98.29 153.46,98.32 153.4,98.41 153.42,98.52 153.44,98.55 153.47,98.58 153.52,98.61 153.52,98.67 153.52,98.68 153.54,98.8 153.52,98.91 153.52,98.92 153.52,98.99 153.43,99.06 153.4,99.17 153.46,99.28 153.52,99.31 153.52,99.52 153.57,99.57 153.68,99.57 153.71,99.62 153.75,99.66 153.78,99.69 153.85,99.72 153.92,99.73 153.99,99.73
+NVVDD on BOTTOM (solid shape): 154.07,91.94 154.12,91.81 154.09,91.68 154.05,91.65 154.01,91.6 153.95,91.56 153.95,90.64 154.01,90.6 154.05,90.55 154.1,90.52 154.13,90.4 154.09,90.28 154.06,90.25 154.02,90.21 153.95,90.17 153.95,89.24 154,89.22 154.01,89.2 154.05,89.15 154.11,89.11 154.13,88.99 154.1,88.88 154.06,88.86 154.02,88.81 153.95,88.77 153.95,88.61 153.83,88.49 153.52,88.49 153.46,88.52 153.4,88.6 153.41,88.7 153.45,88.74 153.49,88.79 153.52,88.81 153.52,88.85 153.52,88.86 153.55,88.99 153.52,89.12 153.52,89.13 153.52,89.19 153.43,89.26 153.4,89.38 153.46,89.48 153.52,89.51 153.52,89.89 153.46,89.92 153.4,90.02 153.42,90.13 153.47,90.18 153.52,90.21 153.52,90.26 153.52,90.27 153.55,90.41 153.52,90.54 153.52,90.55 153.52,90.59 153.49,90.61 153.45,90.65 153.41,90.69 153.4,90.79 153.46,90.88 153.52,90.91 153.52,91.29 153.46,91.32 153.4,91.41 153.41,91.51 153.45,91.55 153.49,91.59 153.52,91.61 153.52,91.65 153.55,91.72 153.56,91.78 153.58,91.84 153.64,91.87 153.67,91.87 153.69,91.91 153.75,91.95 153.78,91.99 153.82,92.01 153.94,92.03
+NVVDD on BOTTOM (solid shape): 159.57,99.51 159.57,99.03 159.61,99.01 159.66,98.95 159.71,98.91 159.73,98.8 159.71,98.69 159.66,98.65 159.61,98.6 159.57,98.57 159.57,98.33 159.62,98.29 159.65,98.25 159.69,98.22 159.72,98.1 159.68,97.97 159.65,97.95 159.62,97.91 159.57,97.88 159.57,97.62 159.67,97.53 159.72,97.41 159.69,97.28 159.65,97.25 159.61,97.19 159.57,97.17 159.57,97.02 159.57,96.44 159.54,96.38 159.48,96.35 159.41,96.34 159.32,96.34 159.29,96.28 159.24,96.25 159.21,96.21 159.13,96.19 159.09,96.21 159.05,96.25 159.01,96.29 159,96.35 159.02,96.42 159.03,96.45 159.03,96.95 159.02,96.98 159,97.04 159,97.09 159.06,97.14 159.11,97.2 159.15,97.22 159.15,97.29 159.16,97.39 159.15,97.49 159.15,97.58 159.09,97.61 159.05,97.65 159.01,97.68 159,97.75 159.02,97.82 159.03,97.85 159.03,98.35 159.02,98.38 159,98.43 159,98.49 159.06,98.54 159.11,98.6 159.15,98.62 159.15,98.69 159.16,98.79 159.15,98.89 159.15,98.98 159.09,99.01 159.05,99.05 159.01,99.08 159,99.15 159.01,99.22 159.03,99.24 159.03,99.5 159.1,99.57 159.51,99.57
+NVVDD on BOTTOM (solid shape): outline of 94 points within 169.08,95.77 169.8,99.56
+NVVDD on BOTTOM (solid shape): outline of 89 points within 163.47,95.76 164.2,99.58
+NVVDD on BOTTOM (solid shape): outline of 90 points within 166.27,95.77 167,99.57
+NVVDD on BOTTOM (solid shape): outline of 112 points within 163.47,88.06 164.2,92.03
+NVVDD on BOTTOM (solid shape): outline of 199 points within 161.71,89.87 162.8,100.01
+NVVDD on BOTTOM (solid shape): outline of 4051 points within 130.52,83.75 171.7,148.74
+NVVDD on IN1 (solid shape): outline of 1449 points within 128.12,141.84 184.42,161.02
+NVVDD on GND2 (solid shape): 184.38,160.84 184.38,156.88 180.23,152.73 180.2,152.68 180.19,152.64 180.19,145.96 178.11,143.87 141.08,143.87 141.03,143.86 140.99,143.84 139.88,142.73 138.16,142.73 138.11,142.72 138.07,142.69 137.81,142.44 137.79,142.4 137.78,142.35 137.78,141.84 137.79,141.79 137.81,141.75 138.07,141.5 138.11,141.47 138.16,141.46 139.88,141.46 140.06,141.28 140.06,127.36 140.07,127.31 140.1,127.27 140.82,126.55 140.82,119.11 140.83,119.06 140.86,119.02 149.97,109.91 149.97,109.2 149.98,109.15 150.01,109.11 150.89,108.22 150.94,108.2 150.98,108.19 151.82,108.19 152.13,107.88 152.13,107.55 152.14,107.5 152.16,107.46 156.36,103.27 156.4,103.24 156.44,103.23 170.36,103.23 171.05,102.55 171.05,85.63 170.36,84.94 152.81,84.94 152.38,85.38 152.38,90.79 152.37,90.84 152.34,90.88 151.58,91.64 151.54,91.67 151.49,91.68 144.31,91.68 140.91,95.07 140.87,95.1 140.82,95.1 135.03,95.1 131.17,98.97 131.17,131.68 131.16,131.73 131.13,131.77 128.25,134.65 128.25,148.27 131.1,151.11 133.2,151.11 133.25,151.12 133.29,151.15 134.18,152.04 134.21,152.08 134.22,152.13 134.22,158.68 136.56,161.02 184.21,161.02
+NVVDD on IN2 (solid shape): outline of 13342 points within 127.88,84.94 184.42,161.02
+NVVDD on GND3 (solid shape): 184.38,160.84 184.38,156.88 180.23,152.73 180.2,152.68 180.19,152.64 180.19,145.96 178.11,143.87 142.35,143.87 142.3,143.86 142.26,143.84 140.1,141.68 140.07,141.64 140.06,141.59 140.06,127.36 140.07,127.31 140.1,127.27 140.82,126.55 140.82,119.11 140.83,119.06 140.86,119.02 149.97,109.91 149.97,109.2 149.98,109.15 150.01,109.11 150.89,108.22 150.94,108.2 150.98,108.19 151.82,108.19 152.13,107.88 152.13,107.55 152.14,107.5 152.16,107.46 156.36,103.27 156.4,103.24 156.44,103.23 170.36,103.23 171.05,102.55 171.05,85.63 170.36,84.94 152.81,84.94 152.38,85.38 152.38,90.79 152.37,90.84 152.34,90.88 151.58,91.64 151.54,91.67 151.49,91.68 144.31,91.68 140.91,95.07 140.87,95.1 140.82,95.1 135.03,95.1 131.17,98.97 131.17,131.68 131.16,131.73 131.13,131.77 127.87,135.04 127.87,146.74 128.21,147.08 128.24,147.13 128.25,147.17 128.25,148.27 128.98,148.99 129,149.03 129.01,149.08 129.01,157.41 132.62,161.02 184.21,161.02
+NVVDD on VCC1 (solid shape): 187.94,158.04 187.94,150.98 187.95,150.94 187.98,150.89 190.1,148.77 190.1,77.5 178.36,65.77 136.05,65.77 124.44,77.38 124.44,122.79 124.43,122.84 124.4,122.88 120.85,126.44 120.81,126.46 120.76,126.47 120.05,126.47 119.87,126.65 119.87,129.72 120.59,130.45 120.62,130.49 120.63,130.54 120.63,133.97 120.62,134.02 120.59,134.06 120.12,134.53 120.12,134.8 120.59,135.27 120.62,135.32 120.63,135.36 120.63,153.4 129.39,153.4 129.44,153.41 129.48,153.43 137.07,161.02 184.97,161.02
