# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.0VS: length 314.7
  TOP w0.508: v2(191.19,32.16) 191.19,33.36 190.25,34.3 190.25,38.72 191.78,40.24 T9102.1
  IN2 w0.508: 118.32,125.58 117.25,124.52 113.65,124.52 112.38,123.25 110.06,123.25 109.74,123.57 v3(108.89,123.57) ; 119.28,125.58 119.87,125 123.7,125 124.67,124.04 124.67,120.86 124.23,120.42 124.23,101.37 122.92,100.06 122.92,99.17 122.05,98.31 122.05,97.37 122.22,97.2 122.22,84.88 121.93,84.59 121.93,76.76 123.53,75.17 125.96,75.17 128.38,72.75 128.38,71.44 128.99,70.83 128.99,53.7 128.28,52.99 128.28,46.85 142.93,32.2 145.92,32.2 146.47,32.76 160.8,32.76 161.75,31.81 165.28,31.81 165.81,31.27 167.11,31.27 167.53,31.69 190.72,31.69 v2(191.19,32.16)
  IN2 w1.016: v4(68.38,128.94) 69.35,128.94 69.86,129.44 69.86,130.23 69.12,130.97 69.12,132.42 72.12,135.41 72.12,142.58 73.87,144.33 73.87,150.45 75.24,151.82 75.24,156.63 75.95,157.34 75.95,170.44 76.43,170.92 76.43,173.34 77.1,174 87.05,174 88.35,172.7 88.35,170.11 89.21,169.25 91.07,169.25 92.79,167.52 104.68,167.52 106.53,165.67 106.53,161.83 110.52,157.84 114.03,157.84 117.51,154.36 117.51,146.13 116.31,144.94 116.31,137.01 119.14,134.19 119.14,130.37 118.62,129.85 118.62,127.44
  BOTTOM w0.203: U0300.G30 110.74,124.66 110.74,124.52 U0300.H29 110.15,123.93 109.68,123.93 109.32,123.57 v3(108.89,123.57)
  BOTTOM w0.381: R0706.2 68.38,128.16 v4(68.38,128.94)
+1.0VSUS: length 355.8
  TOP w0.254: v3(72.17,124.52) 72.17,124.56 71.95,124.78 71.95,124.99 R80147.1 ; R80148.1 v3(71.76,126.93) R80149.1
  TOP w0.508: v2(53.09,133.51) 53.27,133.33 54.03,133.33 54.5,133.8 SR4402.1 SR4401.1 ; v2(230.92,61.62) 230.46,61.62 230.07,62.02 L2603.1 230.07,62.39 R2607.1
  IN1 w0.508: v2(40.79,89.55) 40.79,83.54 37.45,80.19 37.45,47.53 33.33,43.41 33.33,39.66 35.1,37.89 35.1,35.89 39.58,31.4 43.39,31.4 46.88,27.91 59.61,27.91 60.44,28.73 108.31,28.73 115.67,36.09 128.22,36.09 128.5,36.37 138.09,36.37 138.79,35.67 140.57,35.67 144.36,31.88 166.5,31.88 166.5,31.88 174.87,31.88 175.2,31.55 195.08,31.55 196.6,33.07 196.6,34.74 197.52,35.66 199.28,35.66 200.78,37.15 200.78,38.9 205.33,43.45 205.33,45.26 209.67,49.6 209.67,58.97 ; v2(40.79,99.93) 40.79,101.39 51.57,112.17 51.57,117.38 56.14,121.95 v2(57.87,121.95) ; v3(71.76,126.93) 71.76,125.33 72.17,124.92 v3(72.17,124.52)
  IN1 w0.635: v2(57.87,121.95) 57.87,122.45 60.8,125.38 64.99,125.38 67.02,127.41 68.53,127.41 68.91,127.79 70.01,127.79 70.64,127.16 71.53,127.16 v3(71.76,126.93)
  IN3 w0.508: v2(57.87,121.95) 56.98,122.84 56.98,129.13 53.09,133.02 v2(53.09,133.51)
  BOTTOM w0.254: U2000.V17 v2(225.48,61.66) ; R2512.2 v2(211.97,70.21)
  BOTTOM w0.381: v3(71.76,126.93) 71.76,126.02 71.44,125.7 70.02,125.7 69.73,125.99 C80134.1 69.73,126.63 69.75,126.65 R80150.1 ; R4410.1 56.72,123.1 v2(57.87,121.95)
  BOTTOM w0.508: v2(40.79,99.93) v2(40.79,89.55)
  BOTTOM w0.635: v2(214.61,53.25) 213.65,53.25 212.68,52.28 212.68,51.4 211.94,50.67 211.94,50.61 211.6,50.26
  vias: v2(209.3,59.54) v2(209.53,60.69) v2(209.91,59.54) v2(210.55,59.54) v2(223.32,62.51) v2(223.63,61.31) v2(224.39,61.31) v2(224.62,60.14) v2(225.55,58.57) v2(225.55,57.8) v2(225.55,57.02) v4(219.27,74.76)
+1.0VSUS_PWRGD: length 90.8
  TOP w0.102: v2(223,12.4) U8200.12 ; v2(192.16,44.18) 186.52,44.18 T9210.1 185.6,43.26 181.12,43.26 179.97,44.41 178.64,44.41 177.91,43.67 168.61,43.67 167.23,42.28 SR9210.1
  IN4 w0.102: v2(193.27,13.44) 195.43,11.28 221.47,11.28 222.59,12.4 v2(223,12.4)
  BOTTOM w0.102: v2(192.16,44.18) 192.34,44 192.34,41.03 193.58,39.78 193.58,17.56 193.27,17.26 v2(193.27,13.44)
+1.2VO_DDR: length 28
  TOP w1.016: 32.19,80.68 32.19,77 34.45,74.73 34.45,60.87 29.83,56.24 29.14,56.24
+1.5VO: length 1.4
  TOP w0.381: 218.45,25.28 R8401.2 218.95,24.81 ; 219.87,24.81 C8400.1
+1.5VS: length 260.2
  TOP w0.508: v2(22.31,40.04) 22.1,40.04 v1(21.27,40.87) 21.27,45.68 18.95,47.99 10.88,47.99 10.62,47.73 3.41,47.73 1.47,45.79 L3600.1
  IN2 w0.508: 25.97,17.81 25.96,17.81 24.36,17.81 23.37,18.8 23.37,20.48 23.96,21.06 23.96,23.88 23.37,24.47 23.37,30.87 24.49,31.99 24.49,35.92 23.86,36.56 23.86,38.08 22.31,39.63 v2(22.31,40.04)
  IN2 w1.016: 57.56,34.7 100.36,34.7 101.56,35.9 103.38,35.9 103.74,35.54 108.05,35.54 108.35,35.85 112.34,35.85 113.41,36.91 120.61,36.91 123.35,39.66 130.54,39.66 134.04,36.15 134.04,34.4 135.06,33.38 139.66,33.38 142.32,30.73 146.75,30.73 147.31,31.28 157.3,31.28 159.16,29.42 171.23,29.42 171.63,29.83 197.86,29.83 199.52,31.48 202.95,31.48 203.92,30.51 211.59,30.51 212.35,31.27 214.1,31.27 ; 27.54,17 28.55,18.01 32.37,18.01 33.13,17.25 36.73,17.25 39.55,20.07 47.86,20.07
  BOTTOM w1.016: 49.03,21.85 49.03,23.63 52.43,27.03 53.4,27.03 56.29,29.93 56.29,32.52 56.24,32.57
  vias: v2(48.72,21.09) v2(49.33,21.09) v2(56.5,33.51) v2(57.13,33.51) v2(215.12,31.86) v2(215.75,31.86)
+1.8VO_VGA: length 140.9
  TOP w0.254: R9714.2 89.29,177.05 88.37,177.96 88.37,181.21 88.5,181.34 R9719.2 88.83,182.02 88.68,182.17 R9712.2 88.93,183.09 v2(89.31,183.09)
  IN1 w0.254: v2(123.15,77.55) 122.23,77.55 121.32,78.47 121.32,83.11 123.46,85.26 123.46,98.02 124.26,98.82 124.26,103.15 123.99,103.43 123.99,131.2 123.61,131.58 123.61,134.27 124.86,135.52 124.86,145.22 124.01,146.06 121.41,146.06 118.42,149.05 118.42,153.65 118.07,154 118.07,154.59 114.66,158 109.05,158 103.92,163.13 103.92,166.07 101.87,168.12 101.87,177.55 99.85,179.56 98.05,179.56 96.15,181.46 94.34,181.46 93.91,181.9 90.51,181.9 v2(89.31,183.09)
+1.8VO_VGA_PWRGD: length 164.2
  TOP w0.102: v2(114.59,19.44) 114.59,23.39 114.93,23.73 116.82,23.73 121.27,28.18 122.77,28.18 123.43,27.52 123.77,27.52 124.91,28.66 124.91,29.38 129.31,33.78 129.31,35.05 123.93,40.42 R7469.1 124.36,49.33 126.3,51.26 126.3,55.05 126.09,55.25 126.09,55.68 126.4,55.99 126.4,59.29 125.65,60.03 U8601.4 ; T9213.1 214.23,22.46 R9216.1 213.67,22 v2(213.19,21.52)
  IN2 w0.102: v2(213.19,21.52) 212.78,21.93 209.43,21.93 208.64,21.14 208.64,19.31 207.42,18.09 197.26,18.09 195.56,19.79 193.73,19.79 192.41,21.11 188.57,21.11 187.88,20.43 175.12,20.43 174.92,20.63 173.08,20.63 172.39,19.95 163.19,19.95 162.29,19.04 153.18,19.04 152.48,18.35 144.92,18.35 143.67,17.09 143.67,17.03 143.41,16.77 138.08,16.77 137.78,17.08 116.95,17.08 v2(114.59,19.44)
+1V8_AON: length 625
  TOP w0.254: v2(147.33,64.17) 147.68,64.17 147.89,64.37 R7450.1 148.14,64.24 148.49,63.89 149.43,63.89 151.06,65.51 v2(151.52,65.51) ; 145.2,68.12 145.46,68.12 146.06,67.52 v2(146.41,67.52) ; 145.2,68.12 145.78,68.69 R7444.1 R7423.1 144.46,68.76 144.15,69.07 R7205.1 ; 145.2,68.12 v2(145.13,68.12) ; v2(243.26,80.52) 243.45,80.32 244.25,80.32 244.93,79.64 245.5,79.64 245.99,79.15 246.57,79.15 248.16,77.57 249.14,77.57 250.04,78.47 R8902.1 ; 148.44,76.69 148.44,76.31 147.94,75.8 147.48,75.8 147.12,76.16 147.12,77.6 146.44,78.29 146.44,79.81 R74107.2
  TOP w0.3: v5(143.33,126.23) 143.34,126.23 143.49,126.38 C7662.1 144,126.88 143.85,127.03 143.85,127.7 v5(143.67,127.88) ; C7602.1 168.03,142.39 168.1,142.31 C7634.1 168.5,141.42 v5(168.93,140.99) ; v2(170.62,124.35) 169.74,124.35 169.14,124.95 C7635.1 169.14,127.6 v5(168.97,127.77) ; v2(178.42,124.52) 179.25,125.36 C7736.1 178.32,126.64 v5(178.32,127.93) ; v5(195.58,103.31) 195.52,103.37 194.53,103.37 194.14,103.77 C7837.1
  TOP w0.432: 148.65,77.5 148.65,78.16 148.95,78.47 R74108.2 ; C7837.1 194.11,104.43 v5(194.34,104.43) ; R74103.1 v2(188.35,162.87) ; v5(195.62,113.15) 195.48,113.29 193.62,113.29 C7761.1 ; v2(207.37,188.98) 207.14,189.21 R9701.1 R9724.1
  TOP w0.508: v2(139.12,60.23) 138.79,60.56 138.79,62.01 139.17,62.39 v2(139.4,62.39) ; v2(139.12,60.23) 139.48,59.87 139.48,55.66 137.95,54.13 v2(137.95,52.61) ; v2(139.12,60.23) 138.72,59.82 135.57,59.82 133.84,61.55 133.84,69.73 134.47,70.37 v2(135.24,70.37) ; 137.65,143.36 136.73,143.36 135.95,142.58 127.49,142.58 124.15,139.24 R5735.2 R5734.2 ; 151.09,81.92 151.09,79.36 151.19,79.26 151.19,77.4 150.48,76.69 148.44,76.69
  TOP w0.599: v2(189.07,51.83) 188.3,51.06 188.3,46.82 187.81,46.34 187.13,46.34 186.14,45.35 184.31,45.35
  TOP w2.54: 127.69,120.78 129.88,122.97 129.88,130.13 136.12,136.38 136.12,139.45 139.15,142.48
  IN1 w0.254: v2(140.37,72.08) 141.68,72.08 142.55,72.96 v3(143.41,72.96) ; v5(208.81,113.06) 208.81,110.77
  IN1 w0.3: v5(143.67,127.88) 142.91,127.12 142.91,126.66 v5(143.33,126.23)
  IN1 w0.508: 151.1,82 151.21,81.9 151.21,81.76 151.22,81.75 151.22,79.65 151.57,79.3 151.57,76.87 152.46,75.98 152.46,74.63 v3(151.57,73.74) ; 174.99,141.08 174.99,125.56 176.02,124.52 v2(178.42,124.52) ; v5(194.34,104.43) 194.16,104.6 194.16,105.59 194.67,106.1 206.15,106.1 207.55,107.5 v2(208.62,107.5) ; 140.85,141.48 140.85,127.59 142.47,125.97 143.06,125.97 v5(143.33,126.23)
  IN1 w0.6: v5(158.72,46.94) 158.6,46.81 156.53,46.81 155.11,48.23 155.11,62.14 155.79,62.83 v2(158.54,62.83)
  IN1 w1.524: 126.06,115.85 126.06,98.07 125.3,97.32 125.3,82.48 124.34,81.52
  IN2 w0.102: 206.97,105.19 206.97,105.75 ; 148.67,140.77 148.06,140.77 ; 148.95,140.8 149.43,140.8 ; 207.96,110.67 207.96,110.01
  IN2 w1.016: 125.53,119.13 125.09,118.69 125.09,99.08 124.19,98.18 124.19,81.69
  IN3 w0.254: v2(210.42,78.42) 210.55,78.54 212.68,78.54 214.97,80.83 242.94,80.83 v2(243.26,80.52)
  IN3 w0.508: v2(137.95,52.61) 137.95,52.76 136.56,54.16 135.06,54.16 v2(132.06,57.16) ; v5(158.72,46.94) 158.72,46.77 v5(159.35,46.15) 159.72,45.78 170.45,45.78 170.82,45.4 182.88,45.4 v5(183.94,46.46) ; v2(142.55,56.73) 142.55,57.11 ; 142.55,57.11 142.27,57.39 141,57.39 139.12,59.27 v2(139.12,60.23) ; 142.55,57.11 143.28,57.84 145.32,57.84 v2(146.81,56.36) ; v2(188.35,162.87) 188.35,157.11 187.43,156.19 187.43,145.06 189.67,142.83 v2(193.86,142.83) 195.94,144.91 206.28,144.91 207.02,144.18 207.02,143.31 207.45,142.88 208.95,142.88 210.42,144.35 210.42,170.64 207.37,173.69 v2(207.37,188.98)
  IN3 w0.599: v2(192.11,60.67) 192.11,54.87 v2(189.07,51.83)
  IN4 w0.102: 204.12,75.93 204.32,75.85 ; 207.65,96.65 207.65,97.04
  IN4 w0.254: v5(178.75,140.73) 178.75,141.39 ; v5(144.25,140.61) 144.25,141.46 144.25,141.46 ; v5(208,103.34) 208.5,103.34
  IN4 w0.4: 172.55,131.1 172.11,130.65 171.73,130.65 171.4,130.32 171.4,125.13 v2(170.62,124.35)
  IN4 w0.508: v5(195.47,78.18) 194.26,78.18 193.27,77.2 ; v2(192.23,77.07) 192.23,75.45 v2(196.27,71.41) 199.42,74.56 204.53,74.56 204.93,74.96 208.7,74.96 209.84,76.1 209.84,77.07 v2(210.42,77.65) ; 134.07,76.61 134.07,84.34 ; v5(195.62,113.15) 194.57,113.15 194,112.58 194,110.59 195.21,109.38 207.47,109.38 v2(208.62,108.24) ; 134.07,73.46 134.07,72.19
  IN4 w0.6: v2(172.8,141.97) 172.55,141.72 172.55,131.1
  BOTTOM w0.2: U7901.W3 183.68,47.79 183.68,46.71 v5(183.94,46.46) ; v5(178.75,140.73) 178.75,140.06 U7701.W3 ; v5(144.25,140.61) 144.25,140.16 U7601.W3 ; v5(208,103.34) 207.96,103.34
  BOTTOM w0.25: U7000.BC14 150.36,84.84 150.38,84.84 150.4,84.82 v3(150.4,84.82) ; 207.96,103.34 U7801.W3 ; U7900.W3 158.5,60.08 v5(158.6,60.18) ; U7000.BB14 151.01,84.89 v3(151.16,84.89)
  BOTTOM w0.254: R7419.1 144.89,68.26 145.03,68.12 v2(145.13,68.12) ; R7439.1 146.54,72.58 v3(146.41,72.7) ; R7466.1 137.85,52.89 137.95,52.79 v2(137.95,52.61) ; v2(140.37,72.08) 141.16,72.08 R7414.1 R7438.1 ; v2(151.52,65.51) R7477.1 ; SR7401.1 SR7402.1 134.85,70.37 v2(135.24,70.37) ; R7445.1 146.89,68.16 146.89,67.95 146.46,67.52 v2(146.41,67.52) 146.84,67.09 R7437.1 ; v2(144.94,62.92) 144.43,62.92 144.23,62.72 R7497.1 145.04,62.39 R7449.1 ; v3(143.41,72.96) 143.14,72.68 143.14,71.94 R7443.1 R7457.1 ; U7000.BA10 151.1,82 ; v2(146.81,56.36) 146.88,56.43 146.88,58.92 146.6,59.2 145.49,59.2 145,58.72 U7412.5
  BOTTOM w0.28: U7700.W3 196.07,113.15 v5(195.62,113.15)
  BOTTOM w0.3: v5(184.11,59.92) 183.91,59.72 U7901.A3 ; v5(195.47,78.18) 195.73,78.18 U7800.W3 ; v5(143.33,126.23) 142.91,126.66 142.91,127.12 v5(143.67,127.88) U7601.A3 ; v5(168.97,127.77) 168.97,128.03 U7600.W3 ; U7600.A3 169.15,140.77 v5(168.93,140.99) ; 158.63,47.03 158.5,47.16 U7900.A3 ; U7700.A3 v5(208.81,113.06) ; v5(195.58,103.31) U7801.A3 ; U7701.A3 178.65,128.25 v5(178.32,127.93)
  BOTTOM w0.305: v2(210.42,78.42) 209.28,78.42 208.87,78.01 U7800.A3
  BOTTOM w0.356: 139.83,63.58 140.34,63.58 140.7,63.94 U7417.2 ; U7413.5 142.77,56.5 v2(142.55,56.73)
  BOTTOM w0.406: v2(144.94,62.92) 144.94,64.14 144.58,64.5 143.8,64.5 143.6,64.29 143.14,64.29 142.84,64 U7003.5 ; v4(132.67,94.27) 133.56,93.38 R7001.1 131.26,93.13 130.59,92.46 130.59,90.74 131.53,89.8 131.53,88.75 131.77,88.51 U7002.5 ; v3(151.57,73.74) R7475.1
  BOTTOM w0.432: v2(132.06,57.16) 132.06,57.18 131.93,57.31 R74101.1 ; v2(139.4,62.39) 139.4,63.15 139.83,63.58 139.4,64.02 R7440.2 ; v2(148.22,56.13) 148.22,56.57 R7460.1 ; 158.63,47.03 v5(158.72,46.94) ; R7458.1 v2(139.12,60.23)
  BOTTOM w0.457: R7208.2 135.4,76.55 135.34,76.61 v2(135.11,76.61)
  vias: v2(122.71,82.04) v2(122.71,81.43) v2(122.71,80.8) v2(122.71,80.19) v2(123.32,82.07) v2(123.32,81.46) v2(123.32,80.83) v2(123.32,80.22) v2(143.97,142.81) v2(144.74,142.81) v2(168.21,142.93) v2(178.54,142.78) v2(210.93,113.77) v3(150.85,84.42) v3(151.1,83.53) v4(125.96,120.61) v4(125.96,119.23) v4(132.65,95.13)
+1V8_MAIN: length 66.7
  TOP w0.254: Q9107.2 131.31,78.63 130.95,78.27 130.95,77.39 v2(129.98,76.42)
  IN1 w0.508: v4(147.77,60.28) 147.94,60.11 147.94,58.05 147.43,57.54 147.43,56.04 147.99,55.48 v2(148.11,55.48)
  IN3 w1.524: 133.28,66.33 128.73,70.87 128.73,74.43 126.45,76.72 126.45,84.72
  BOTTOM w0.254: R7462.1 R7463.1 129.77,71.03 ; v3(150.41,94.61) U7000.BC27 ; U7000.BB32 v3(151.11,97.39) ; U7000.BC32 v3(150.4,97.4) ; U7000.BD30 v3(149.7,96.7) ; U7000.BB27 v3(151.12,94.62) 151.12,95.28 U7000.BB29 ; U7000.BC30 v3(150.4,96.7) ; U7000.BC26 v3(150.41,93.19) ; U7000.BD27 v3(149.69,94.59)
  BOTTOM w0.3: U7000.BC29 150.45,95.25 150.45,94.65 v3(150.41,94.61) ; v3(151.09,93.21) U7000.BB26
  BOTTOM w0.356: U7001.2 131.58,91.93 131.22,91.57 v2(131.22,90.94)
  BOTTOM w0.432: R74100.1 130.56,58.1 130.26,58.4 ; R7488.1 148.57,55.05 T9115.1 148.65,55.48 v2(148.11,55.48)
  BOTTOM w0.508: v2(129.98,76.42) 129.55,76.42 129.27,76.13 129.27,71.53 129.77,71.03 128.94,70.19 128.94,68.1 129.9,67.14 129.9,65.72 130.26,65.36 130.26,58.4 ; R5739.2 R5738.2 127.91,88.33 127.69,88.12 v2(127.69,87.15)
  vias: v2(127.69,86.54) v2(127.69,85.94) v2(127.69,85.33) v2(147.05,60.51) v2(147.1,61.12) v4(136.12,93.35) v4(136.98,93.17) v4(137.34,92.34)
+1V_DCPDSW: length 8.5
  TOP w0.254: v2(235.27,55.56) 235.94,55.56 v1(236.15,55.35) 236.26,55.46 238.29,55.46 239.02,54.73 240.33,54.73 240.41,54.65 240.65,54.65 C2622.1
  BOTTOM w0.178: v2(235.27,55.56) 236.38,55.56 236.83,56 U2000.BA29
+1V_PRIM_W12MIL: length 1.5
  BOTTOM w0.254: U2000.AD15 228.2,62.1 U2000.AC17 227.82,61.67 v2(227.82,61.65)
  vias: v1(212.35,62.8) v2(213.11,61.68) v2(213.72,62.29) v2(213.72,61.68) v2(214.33,62.29) v2(214.33,61.68) v2(214.94,62.29) v2(214.94,61.68) v2(215.55,62.29) v2(227.03,58.59) v2(227.09,57.79) v2(227.1,57.02) v2(227.82,57.8) v2(227.82,56.98) v2(228.58,59.35) v2(228.58,58.57) v2(228.6,57.82) v2(228.58,57.05) v2(230.87,59.34) v2(230.86,58.57) v2(231.81,58.96)
+2.5V_PWRGD: length 133.7
  TOP w0.102: v2(156.2,30.33) 159.68,33.81 160.69,33.81 161.14,34.27 163.76,34.27 164.34,34.85 164.34,37.63 164.15,37.83 164.03,37.83 162.9,38.96 162.9,39.16 162.77,39.28 162.77,39.64 162.63,39.78 SR9207.1 162.63,41.09 T9200.1 ; v2(105.56,6) 104.26,4.71 103.41,4.71 100.26,1.56 91.45,1.56 90.13,2.87 U9500.4
  IN3 w0.102: v2(156.2,30.33) 155.5,31.03 147.23,31.03 144.12,34.14 138.02,34.14 137.26,34.91 134.74,34.91 131.69,31.86 126.73,31.86 126.12,32.47 126.12,32.65 125.78,32.99 125.18,32.99 124.15,31.96 120.92,31.96 116.17,27.21 104.72,27.21 101.19,23.68 v2(100.84,23.68)
  BOTTOM w0.102: v2(105.56,6) 105.56,8.55 104.76,9.35 104.76,11.4 103.6,12.56 95.34,12.56 95.05,12.28 92.01,12.28 91.78,12.51 91.78,14.31 100.84,23.38 v2(100.84,23.68)
+3V: length 256
  TOP w0.432: v2(163.71,14.26) 162.69,14.26 162.21,13.77 156.37,13.77 153.68,11.08 144.18,11.08 143.72,10.62 143.72,9.71 143.36,9.35 142.5,9.35 142.3,9.15 C4400.1 142.3,7.93 v2(142.25,7.88)
  IN1 w0.508: v2(282.55,88.35) 282.68,88.48 285.45,88.48 286.85,87.08 286.85,83.9 290.73,80.02 290.73,73.08 291.52,72.3 291.52,71.23 v2(291.95,70.8) ; v2(163.71,14.26) 164.57,13.39 180.55,13.39 181.97,11.97 209.77,11.97 210.56,11.18 232.65,11.18 234.86,13.4 235.94,13.4 239.71,17.17 239.71,20.89 241.18,22.36 v2(244.02,22.36)
  IN2 w0.508: v2(282.55,88.35) 282.55,88.35 281.03,88.35 279.97,87.28 279.97,86.95 278.87,85.86 276.78,85.86 275.99,86.65 270.89,86.65 268.37,89.16 265.96,89.16 265.44,88.65 262.71,88.65 257,82.94 v2(256.67,82.94) ; v2(291.95,65.92) 291.95,58.99 291.14,58.17 289.82,58.17 288.91,57.26 288.91,56.29 288.35,55.73 286.7,55.73 286.3,56.13 284.81,56.13 281.39,52.71 279.27,52.71 278.23,51.67 278.23,46.68 278.73,46.18 278.73,44.82 277.02,43.11 277.02,40.42 276.21,39.61 276.21,38.71 270.32,32.82 v2(268.99,32.82)
  IN4 w0.508: v2(244.02,22.36) 244.02,25.43 249.08,30.49 258.88,30.49 262.26,33.87 267.95,33.87 v2(268.99,32.82)
  BOTTOM w0.305: CON4400.12 141.25,8.19 141.56,7.88 v2(142.25,7.88) CON4400.10
  BOTTOM w0.508: v2(291.95,70.8) v2(291.95,65.92)
+3V3_FLASH: length 75.7
  TOP w0.203: C1206.1 294.22,53.76 294.22,55.18 294.49,55.45 U1201.G1
  TOP w0.254: U1103.8 275.32,61.14 274.99,61.48 274.99,62.44 275.19,62.64 R1103.2 R1106.2 276.43,63.08 276.84,63.48 R1223.1 ; R1225.1 R1224.1 288.25,56.9 v2(288.09,57.06) ; R1104.2 276.54,51.29 276.26,51.57 274.93,51.57 274.44,52.06 274.44,53.31 273.08,54.67 273.08,57.36 273.28,57.56 R1105.2
  TOP w0.432: U1103.8 275.32,58.88 275.09,58.66 C1129.1 R1105.2 275.42,57.56 v2(277.13,55.86)
  TOP w0.508: C1206.1 293.46,53 v2(293.22,53)
  IN1 w0.508: v2(293.22,53) 292.73,53.5 291.48,53.5 290.95,54.03 290.95,55.37 290.52,55.8 289.89,55.8 288.62,57.06 v2(288.09,57.06)
  IN3 w0.508: v2(277.13,55.86) 277.13,53.01 278.26,51.87 278.26,51.2 278.57,50.9 278.57,45.73 279.18,45.12 282.66,45.12 283.47,44.3 283.47,42.55 v2(281.27,40.36)
  IN4 w0.254: v2(281.27,40.36) 283.66,40.36 284.82,39.2 v2(284.82,36.99)
  IN4 w0.508: v2(277.13,55.86) 277.13,55.92 278.72,57.51 280.63,57.51 280.69,57.45 287.76,57.45 288.09,57.11 v2(288.09,57.06)
  BOTTOM w0.254: R1155.2 285.11,37.28 v2(284.82,36.99)
+3V3_MAIN: length 728.2
  TOP w0.254: R9707.2 88.73,180.35 88.73,178.12 89.32,177.53 91.04,177.53 91.42,177.91 91.42,178 91.55,178.13 v2(91.55,178.65)
  TOP w0.305: C9719.1 95.61,181.29 95.52,181.2 U9702.4 ; v2(94.72,178.16) 94.44,178.45 U9702.16
  TOP w0.432: v2(122.59,149.66) 122.7,149.66 123.71,148.65 124.59,148.65 124.73,148.51 126.04,148.51 126.64,149.11 127.51,149.11 128.24,149.83 133.09,149.83 134.17,150.91 134.17,155.89 134.4,156.12 R8702.1 R8701.1 134.4,159.18 133.87,159.71 ; 133.87,159.71 134.25,160.08 134.25,164.83 v2(133.97,165.11) ; 133.87,159.71 R8703.1 ; R7218.1 R7216.1 R7217.1 286.98,122.32 287.29,122 v2(287.65,122) ; R7230.1 283.95,114.41 v2(283.7,114.66) ; Q7205.1 283.71,82.85 283.39,83.17 R7225.1 282.89,84.06 282.61,84.34 282.61,85.38 282.81,85.58 R7226.1 283.39,86.01 283.06,86.34 283.06,86.85
  TOP w0.457: v2(207.99,133.98) 208.4,133.98 208.9,134.47 R7495.2
  TOP w0.508: v2(101.07,179.94) 100.59,179.46 99.07,179.46 98.28,180.24 v2(98.07,180.24) C9716.1 97.02,181.29 C9719.1 ; v4(284.97,87.74) 284.97,88.03 Q7204.1 283.62,88.26 283.62,87.89 283.06,87.33 283.06,86.85 ; v2(265.34,38.13) 267.77,38.13 269.38,39.74 R1408.1 ; v2(133.46,31.1) 133.03,31.53 133.03,42.83 133.46,43.26 134.69,43.26 134.93,43.02 136.36,43.02 139.93,46.59 139.93,48.02 140.73,48.82 141.39,48.82 144.99,52.42 144.99,54.21 v2(145.8,55.02)
  IN1 w0.432: v2(287.65,122) 287.65,119.63 285.1,117.08 285.1,116.06 v2(283.7,114.66)
  IN1 w0.508: 262.19,38.67 262.74,38.67 263.27,38.13 v2(265.34,38.13) ; v2(207.99,133.98) 207.73,133.71 203.21,133.71 202.75,134.17 202.75,137.93 196.21,144.47 193.29,144.47 186.9,150.86 186.9,167.27 185.53,168.64 185.53,170.87 183.45,172.96 136.23,172.96 133.97,170.7 v2(133.97,165.11) ; v2(101.07,179.94) 107.4,173.62 107.4,164.6 107.13,164.33 107.13,162.77 109.26,160.64 120.38,160.64 121.67,159.34 121.67,153.93 123.42,152.18 123.42,150.1 122.99,149.66 v2(122.59,149.66)
  IN1 w0.762: 261.17,39.18 261.17,39.68 260.28,40.58 257.77,40.58 255.06,43.29 255.06,46.74 254.18,47.62 254.18,60.1 254.67,60.59 v4(254.67,65.97) ; 261.65,38.13 261.65,37.07 261.09,36.51 259.37,36.51 v4(258.32,35.47)
  IN2 w0.762: v2(132.57,21.34) 136.1,21.34 138.78,18.66 141.17,18.66 144.56,22.05 157.54,22.05 158.66,23.18 161.12,23.18 163.17,25.22 166.23,25.22 166.38,25.37 176.79,25.37 176.91,25.49 184.13,25.49 184.4,25.76 191.74,25.76 192.09,25.42 202.33,25.42 204.28,27.36 219.61,27.36 220.09,26.88 226.24,26.88 227.39,28.02 233.84,28.02 234.55,27.31 v4(234.55,26.4) ; v4(270.62,84.89) 270.54,84.82 261.98,84.82 260.65,83.49 260.65,80.06 261.58,79.13 261.58,74.86 261.35,74.63 261.35,71.15 259.53,69.32 258.65,69.32 257.79,68.46 257.79,67.41 256.35,65.97 v4(254.67,65.97)
  IN3 w0.508: v2(145.8,55.02) 144.94,54.16 141.44,54.16 129.23,66.38 127.79,66.38 126.58,67.59 126.58,72.11 123.93,74.76 123.93,98.05 122.82,99.17 122.82,102.07 123.27,102.52 123.27,110.71 119.04,114.94 119.04,122.76 118.45,123.35 118.45,130.13 118.7,130.38 119.19,130.88 119.19,132.57 118.51,133.26 v3(118.19,133.26) ; v2(140.39,77.96) 140.7,77.96 141.05,77.6 141.05,75.48 142.45,74.08 142.45,72.67 143.58,71.53 148.33,71.53 149.3,70.56 149.3,68.56 148.82,68.08 148.82,65.8 v2(150.86,63.77)
  IN3 w0.762: v4(284.97,87.74) 291.14,87.74 292.92,89.52 293.86,89.52 294.56,90.22 v4(294.56,90.72)
  IN4 w0.508: v2(150.86,63.77) 151.25,63.77 151.54,63.48 151.54,62.86 149.41,60.73 149.41,60.46 145.8,56.85 v2(145.8,55.02) ; v3(118.19,133.26) 118.19,135.41 116.66,136.94 116.66,144.55 118.18,146.06 120.2,146.06 121.9,147.76 121.9,148.97 v2(122.59,149.66)
  IN4 w0.762: v4(258.32,35.47) 253.96,35.47 252.87,34.38 251.42,34.38 250.27,33.23 248.34,33.23 243.14,28.02 235.31,28.02 234.55,27.26 v4(234.55,26.4)
  BOTTOM w0.254: R7411.1 151.7,62.01 151.49,62.21 151.49,63.21 150.93,63.77 v2(150.86,63.77)
  BOTTOM w0.406: R7407.2 R7408.2 R7406.2 R7405.2 138.89,80.22 139.4,79.71 139.4,78.95 v2(140.39,77.96) ; v4(234.55,26.4) 234.17,26.02 233.03,26.02 R5719.1
  BOTTOM w0.432: SR7417.1 144.79,52.81 145.23,53.25 145.23,54.45 v2(145.8,55.02) ; R7410.2 133.99,75.24 133.65,75.58 Q7402.1 132.56,75.58 132.31,75.83 132.31,77.55 132.59,77.83 133.05,77.83 133.33,78.11 Q7401.1 132.72,79.39 R7409.2 132.72,80.47 132.9,80.65 134.32,80.65 135.06,79.92 135.72,79.92 136.03,80.22 R7407.2
  BOTTOM w0.508: 283.14,86.09 283.52,85.71 R1301.1 ; v2(283.7,114.66) 284.03,114.33 284.03,110.62 289.43,105.22 293.01,105.22 295.1,103.13 295.1,100.59 294.95,100.44 294.95,91.12 v4(294.56,90.72) ; v2(133.46,31.1) 133.46,24.44 132.19,23.17 132.19,21.72 v2(132.57,21.34) ; v2(98.07,180.24) 97.49,180.24 95.41,178.16 v2(94.72,178.16) 93.96,178.16 93.2,178.92 91.83,178.92 v2(91.55,178.65)
  BOTTOM w0.762: v4(270.62,84.89) 270.64,84.89 271.43,85.68 282.73,85.68 283.14,86.09 283.14,86.39 284.49,87.74 v4(284.97,87.74)
+3V3_MAIN_EN: length 143.8
  TOP w0.102: v2(134.79,43.87) 134.8,43.87 143.49,52.56 R74110.2 144.08,55.3 144.25,55.48 144.89,55.48 145.65,56.24 145.65,56.75 146.67,57.77 146.67,59.89 146.44,60.12 146.44,61.81 146.17,62.07 U7414.4 ; v2(240.34,31.96) 240.34,31.05 241.12,30.27 SR9104.1
  IN2 w0.102: v2(240.34,31.96) 232.87,31.96 232.14,32.7 199.22,32.7 198.88,32.35 193.28,32.35 192.21,33.42 143.97,33.42 134.79,42.6 v2(134.79,43.87)
  BOTTOM w0.102: v2(240.34,31.96) 240.42,31.88 240.42,28.73 v1(240.14,28.45) 240.02,28.34 SR5706.1
+3V3_MAIN_PG: length 10.6
  BOTTOM w0.102: SR7417.2 142.95,52.81 D7405.1 142.3,54 141.2,55.1 141.2,55.94 140.43,56.71 U7416.1 ; SR7417.2 143.58,52.5 143.68,52.39 144.93,52.39 145.88,53.34 v1(145.88,53.78) ; SR7417.2 C7410.1
+3V3_TBTA_SX: length 6.5
  TOP w0.076: 294.82,54.72 294.82,54.97 295.19,55.34 295.19,55.47 295.24,55.51 295.24,55.94 U1201.H2
  TOP w0.102: 294.82,54.72 295.38,54.16 295.84,54.16 296.4,53.6 C1205.1 296.6,53.25 296.86,52.99 296.86,51.47 v1(296.65,51.26)
+3V_WLAN: length 10.3
  TOP w0.254: R5354.2 v2(301.86,98.03) 301.86,98.39 R5300.1 R5308.1 302.34,99.02 302.98,99.65 302.98,101.23 302.8,101.4 R5349.2
  TOP w0.432: v2(300.59,95.66) 301,95.25 R5306.2 ; v2(305.34,98) 305.42,97.92 305.42,97.52 305.29,97.39
  IN2 w0.508: v2(300.59,95.66) 300.59,96.76
  vias: v1(290.43,100.31) v2(287.89,100.34) v2(288.5,100.31) v2(305.39,100.41) v2(306.08,100.41)
+3VA: length 878.5
  TOP w0.254: v2(279.99,29.88) 279.63,29.52 R8811.2 ; v2(87.13,182.96) 87.13,184.11 87.53,184.51 88.75,184.51 89.03,184.23 94.49,184.23 94.71,184.02 97.32,184.02 97.62,184.31 97.62,186.95 97.01,187.56 R4592.1 ; SR8102.2 255.35,64.62
  TOP w0.432: v2(52.81,128.3) 53.27,128.3 57.64,123.93 v2(60.31,123.93) ; v2(128.29,149.04) 127.82,148.57 R5740.1 126.8,148.47 126.3,147.97 125.61,147.97 125.18,147.54 R5736.1 ; v2(17.68,58.94) 17.51,59.11 R5712.1
  TOP w0.508: v2(257.33,77.23) 256.52,78.04 256.52,78.98 JP9301.1 256.22,79.36 255.58,78.72 255.58,78.7 JP9302.1 254.97,78.19 254.74,78.42 254.74,83.6 254.62,83.73 254.62,85.63 254.22,86.02 254.22,87.2 253.37,88.05 v2(253.37,89.67) ; v2(137.24,31.25) 139.12,33.13 140.41,33.13 SR3001.1 ; v2(256.36,52.47) 256.2,52.47 255.23,53.45 JP8106.2 255.23,57.26 254.31,58.17 254.31,59.74 255.43,60.85 255.43,63.53 254.95,64.02 254.95,64.78 ; R5704.1 209.28,139.17 209.91,138.54 209.91,134.6 208.26,132.95 v2(207.3,132.95) R5707.1 ; JP9300.1 60.26,187.25 60.26,186.39 v2(59.95,186.09) ; 254.97,64.8 254.97,65.01 255.4,65.44 255.4,66.43 256.27,67.29 256.27,67.47 255.84,67.9 v2(255.45,67.9)
  IN1 w0.254: v2(281.11,64.29) 278.34,61.53 267.04,61.53 264.74,59.23 262.34,59.23 258.4,63.16 258.4,65.34 255.84,67.9 v2(255.45,67.9)
  IN1 w0.508: v2(291.75,27.57) 289.36,29.96 282.93,29.96 282.19,30.69 280.5,30.69 279.99,30.18 v2(279.99,29.88) ; v2(128.35,168.56) 127.51,168.56 126.5,167.55 126.5,160.03 128.29,158.24 v2(128.29,149.04)
  IN2 w0.508: v2(59.95,186.09) 54.08,180.22 54.08,178.8 53.46,178.18 48.95,178.18 46.28,175.5 46.28,156.91 49.56,153.62 52.24,153.62 53.4,152.46 53.4,147.33 54.82,145.9 54.82,132.16 52.81,130.16 52.81,128.3 v2(52.81,128.3)
  IN3 w0.508: v2(255.45,67.9) 256.01,68.46 256.01,70.97 255.63,71.36 255.63,73.92 256.6,74.89 256.6,76.5 v2(257.33,77.23) ; v2(59.95,186.09) 68.15,186.09 69.22,185.02 71.1,185.02 72.12,184 85.2,184 86.24,182.96 v2(87.13,182.96) 87.66,182.43 90.15,182.43 90.58,182 93.5,182 94.34,182.84 94.34,182.89 94.85,183.4 96.32,183.4 98.08,181.64 100.77,181.64 104.45,177.96 106.03,177.96 111.41,172.57 116.49,172.57 119.77,169.3 127.01,169.3 127.74,168.56 v2(128.35,168.56) ; v2(258.1,39.02) 257.14,39.02 256.26,38.15 251.12,38.15 249.45,39.82 v2(248.01,39.82) 248.01,39.29 246.36,37.65 244.43,37.65 242.37,35.59 238.66,35.59 237.94,34.87 230.62,34.87 229.56,33.81 225.64,33.81 225.43,33.61 222.71,33.61 219.87,30.77 205.99,30.77 205.23,30.01 200.13,30.01 196.2,26.09 190.73,26.09 190.19,25.55 186.61,25.55 185.8,26.36 168.7,26.36 168.11,25.77 147.15,25.77 146.55,26.37 141.1,26.37 137.65,29.83 137.65,30.84 v2(137.24,31.25) 133.5,27.5 129.36,27.5 128.73,26.88 122.99,26.88 122.23,27.64 120.38,27.64 116.85,24.11 116.8,24.11 116.75,24.06 112.22,24.06 108.92,20.76 95.66,20.76 95.21,20.3 62.52,20.3 60.51,18.3 41.08,18.3 40.98,18.4 33.39,18.4 30.61,21.18 30.61,21.55 27.03,25.13 27.03,30.56 27.54,31.07 28.48,31.07 28.99,31.58 28.99,43.01 27.74,44.25 27.74,44.86 26.9,45.7 24.75,45.7 23.3,47.15 23.3,48.22 22.21,49.31 22.21,52.69 17.68,57.21 v2(17.68,58.94) 17.68,60.54 21.49,64.35 21.49,68.23 24.42,71.15 30.97,71.15 37.24,77.42 37.24,79.14 44.84,86.74 44.84,87.87 42.93,89.77 42.93,114.92 44.28,116.26 44.28,117.36 43.34,118.3 43.34,124.31 48.57,129.55 51.57,129.55 v2(52.81,128.3)
  IN4 w0.508: v2(253.37,89.67) 253.3,89.59 244.51,89.59 240.26,93.83 239.12,93.83 238.74,94.22 231.63,94.22 227.82,98.03 227.13,98.03 225.1,100.06 224.77,100.06 223.37,101.45 213.98,101.45 210.93,104.5 210.93,109.66 212.5,111.23 212.5,118.47 211.72,119.26 211.72,121.17 211.19,121.69 211.19,123.31 210.5,124.01 210.5,129.75 v2(207.3,132.95) ; v2(258.1,39.02) 258.27,38.84 263.38,38.84 264.09,38.13 264.38,38.13 265.61,36.9 265.61,36.25 266.28,35.59 269.55,35.59 275.9,29.24 279.36,29.24 v2(279.99,29.88)
  BOTTOM w0.254: v2(248.01,39.82) 248.01,38.15 242.69,32.82 240.47,32.82 239.5,31.86 239.5,30.06 239.3,29.85 R5723.1 236.84,29.14 236.28,28.58 236.28,27.19 235.92,26.83 R5727.1 ; R5715.1 280.79,64.89 280.79,64.61 v2(281.11,64.29)
  BOTTOM w0.279: CON5602.20 91.25,183.61 90.18,182.53 88.55,182.53 88.14,182.94 87.15,182.94 v2(87.13,182.96)
  BOTTOM w0.381: R6001.1 291.5,27.31 v2(291.75,27.57)
  BOTTOM w0.432: v2(128.35,168.56) 128.35,167.95 127.97,167.57 R5744.1 ; R4412.1 60.18,124.06 v2(60.31,123.93)
  BOTTOM w0.508: v2(137.24,31.25) 137.24,31.25 137.28,31.25 137.89,31.86 R5709.1 ; R2619.2 245.64,47.31 246.36,46.59 246.36,46.29 247.66,44.99 247.66,40.17 v2(248.01,39.82) ; v2(258.1,39.02) 257.94,39.17 257.94,39.76 258.27,40.09 258.27,51.46 257.92,51.82 256.82,51.82 256.36,52.28 v2(256.36,52.47) ; D6006.2 284.78,33.06 284.4,32.69 284.4,31.54 283.7,30.84 ; 283.7,30.84 283.01,30.84 281.44,29.27 280.6,29.27 v2(279.99,29.88) ; 283.7,30.84 284.78,29.76 D6005.2
+3VA_EC: length 177.5
  TOP w0.178: U3002.114 163.26,27.91 163.46,27.71 163.46,27.34 163.66,27.14 164.66,27.14 C3004.1 ; C3024.1 150.86,36.74 U3002.26 ; C3003.1 145.19,26.71 U3002.50
  TOP w0.191: C3023.1 159.62,18.36 159.26,18.71 U3002.92 ; U3002.127 163.25,33.11 163.67,33.53 C3025.1 ; U3002.121 163.25,30.71 163.48,30.94 163.48,31.28 164.04,31.84 164.59,31.84 165.95,30.49 C3002.1
  TOP w0.203: R3001.1 166.74,19.92 167.04,19.62 167.47,19.62 167.75,19.9 167.75,20.54 v2(167.61,20.68)
  TOP w0.254: R3070.1 168.08,26.88 v2(167.4,27.56) ; 167.87,25.24 167.39,24.76 167.39,24.27 v2(167.1,23.97) ; v2(141.33,38.75) 141.33,39.17 R3061.1 R5004.1 140.67,38.95 140.67,37.95 140.44,37.73 R5014.2 138.61,38.46 137.61,38.46 D5004.1 ; C3002.1 167.27,31 168.54,31 R30101.1 169.7,30.79 170.59,30.79 v2(170.92,30.46) ; v2(167.47,32.49) 167.11,32.49 R3065.1 165.93,32.15 165.93,32.96 C3025.1
  TOP w0.305: R3005.1 167.4,35.44 170.03,32.81 v2(170.03,32.49) ; v2(144.99,27.52) C3003.1 ; C3004.1 165.59,28.07 166.99,28.07 167.4,27.67 v2(167.4,27.56) ; R3031.1 163.05,37.99 163.05,38.13 R3027.1 162.41,39.41 v2(162.36,39.46)
  TOP w0.406: C3023.1 161.43,17.94 161.52,18.03 v2(161.54,18.03)
  TOP w0.432: C3000.1 148.6,37.97 C3001.1 C3024.1
  TOP w0.508: SR3013.1 149.3,15.19 149.28,15.17 C3020.1 148.96,14.71 C3019.1 v2(147.94,14.71) ; v2(143.24,37.62) 143.76,38.15 145.33,38.15 145.69,37.79 SR3001.2 146.28,37.07 146.42,36.93 C3000.1
  IN1 w0.508: v2(161.54,18.03) 159.86,18.03 158.5,16.67 148.96,16.67 147.94,15.64 v2(147.94,14.71)
  IN2 w0.508: v2(167.47,32.49) 166.85,31.88 166.07,31.88 v2(165.45,32.49)
  BOTTOM w0.432: R3010.1 162.83,21.73 161.86,20.76 R3042.1 161.86,18.34 v2(161.54,18.03) ; R3010.1 163.73,22.03 164.17,21.6 ; R3010.1 R3025.1 ; 154.49,33.66 R3053.1
  BOTTOM w0.508: v2(170.92,30.46) 170.26,30.46 168.97,31.76 167.95,31.76 167.47,32.24 v2(167.47,32.49) ; v2(170.92,30.46) 170.92,31.21 170.03,32.1 v2(170.03,32.49) ; v2(170.92,30.46) 170.92,29.57 170.47,29.12 168.46,29.12 167.4,28.05 v2(167.4,27.56) 167.42,27.53 167.42,26.58 167.1,26.25 v1(167.1,25.12) v2(167.1,23.97) 167.1,23.88 166.31,23.1 163.63,23.1 163.58,23.15 R3025.1 ; v2(143.24,37.62) 143.24,35.21 144.99,33.46 v2(144.99,27.52) ; v2(143.24,37.62) 144.02,38.41 153.57,38.41 154.49,37.5 154.49,33.66 ; v2(143.24,37.62) 142.45,37.62 v2(141.33,38.75) 142.65,40.06 161.76,40.06 v2(162.36,39.46) 162.36,35.58 v2(165.45,32.49) ; v2(167.61,20.68) 166.69,21.6 164.17,21.6
+3VACC: length 4.4
  TOP w0.178: U3002.74 152.06,18.61 151.79,18.34 151.79,18.11 C3021.1
  TOP w0.381: v1(150.55,17.1) 151.03,17.58 151.26,17.58 C3021.1
  TOP w0.508: v1(150.55,17.1) 150.64,17.02 SR3013.2
+3VAPLL: length 13.3
  TOP w0.178: R3017.1 168.03,23.53 166.89,23.53 166.66,23.76 166.02,23.76 v2(165.72,24.06) 165.36,24.06 164.48,24.94 163.62,24.94 163.39,24.71 U3002.106
  BOTTOM w0.305: v2(165.72,24.06) 165.72,24.67 165.36,25.03 v1(164.5,25.03) 164.22,24.75 161.98,24.75 C3005.1 161.42,24.04 161.49,23.97 R3025.2
+3VO: length 491.8
  TOP w0.254: R7453.1 141.63,74.62 140.43,75.81 v2(140.2,75.81)
  TOP w0.406: U7415.5 145.41,64.33 145.96,63.78 U7414.5 146.27,63.37 146.72,62.92 147.83,62.92 v2(148.29,63.38)
  TOP w0.432: v2(124.03,50.83) 123.93,50.73 R7469.2 ; SR8200.1 226.63,18.4 227.18,18.96 ; R8203.2 v2(220,11.92)
  TOP w0.508: 227.18,18.96 227.18,20.63 225.79,22.03 225.79,25.89
  TOP w0.762: 242.14,21.67 236.1,21.67 233.33,24.44 227.87,24.44 225.66,26.65
  IN1 w0.508: v2(103.61,172.65) 103.61,172.12 105.34,170.39 105.34,164.12 v2(105.14,163.91) 105.14,163.3 109.76,158.68 114.95,158.68 118.75,154.88 118.75,154.29 121.77,151.27 121.77,147.79 122.82,146.74 124.3,146.74 125.54,145.5 125.54,135.23 124.29,133.98 124.29,131.87 124.67,131.49 124.67,103.71 124.95,103.44 124.95,98.54 124.15,97.74 124.15,83.65 123.2,82.71 122.45,82.71 122.09,82.36 122.09,79.6 123.24,78.46 123.39,78.46 125.94,75.91 125.94,63.38 127.13,62.19 127.13,53.07 v2(123.01,48.94) ; 120.59,7.67 118.95,9.3 118.37,9.3 115.27,12.4 115.27,16.24 ; v2(148.14,66.71) 148.57,66.28 148.57,63.66 v2(148.29,63.38) 148.29,61.86 148.86,61.28 150.9,61.28 v2(151.11,61.07) 151.36,60.81 151.36,59.95 151.7,59.62 151.7,55.13 151.34,54.77 v2(151.01,54.77)
  IN1 w1.016: 255.35,51.59 255.35,56.47 255.63,56.75 255.63,58.73
  IN2 w0.508: v2(220,11.92) 220,10.65
  IN2 w1.016: 257.69,71.03 256.77,70.11 256.77,67.8 256.01,67.04 253.32,67.04 252.96,66.68 249.84,66.68 249.33,66.18 249.33,62.54 249.84,62.03 251.62,62.03 253.22,60.43 254.34,60.43
  IN2 w1.524: 171.68,12.94 160.13,12.94 152.08,4.88 123.86,4.88 ; 179.3,13.44 181.01,11.74 208.42,11.74 209.51,10.65 233.69,10.65 239.56,16.52
  IN3 w0.508: v2(124.03,50.83) 124.36,51.16 133.62,51.16 135.3,49.49 138.93,49.49 139.51,50.07 139.51,50.49 140.09,51.06 146.8,51.06 v2(147.76,52.03)
  IN4 w0.254: v2(140.2,75.81) 141.43,77.05 141.43,78.43 142.41,79.41 144.95,79.41 145.45,79.9 148.7,79.9 149.85,81.06 150.61,81.06 151.2,80.46 151.2,74.54 150.62,73.96 150.62,71.05 149.26,69.69 149.26,67.83 v2(148.14,66.71)
  IN4 w0.508: v2(151.01,54.77) 150.09,53.86 148.32,53.86 147.76,53.3 v2(147.76,52.03)
  BOTTOM w0.254: R7455.1 148.75,66.1 v2(148.14,66.71) ; U7411.5 144.23,50.32 R7491.1 144.76,50.81 144.91,50.96 147.02,50.96 147.6,51.54 147.6,51.86 v2(147.76,52.03) 147.76,52.51 147.05,53.22 147.05,55.23 147.3,55.48 147.3,55.66 R7442.1 ; U7411.5 143.2,50.16 143.2,51.56 R7490.1 ; U7411.5 143.63,49.26 143.15,48.77 142.12,48.77 141.73,49.16 141.73,50.17 141.6,50.3 141.6,52.33 141.26,52.68 141.26,54.29 140.43,55.11 U7416.5 ; v2(151.01,54.77) 152.16,53.62 152.16,52.72 151.82,52.38 R7487.1 151.36,49.12 150.62,48.37 R7485.1
  BOTTOM w0.432: v2(105.14,163.91) 105.39,164.17 R9404.2 ; R7448.1 150.91,61.27 v2(151.11,61.07)
  BOTTOM w0.508: v2(124.03,50.83) 124.03,49.97 v2(123.01,48.94) 122.59,48.53 122.59,47.62 120.93,45.96 120.93,42.89 121.19,42.62 121.19,36.58 120.56,35.94 120.56,27.21 118.93,25.58 118.93,23.68
  BOTTOM w0.762: 254.39,38.72 257.44,41.76 257.44,47.45 256.9,47.99
  BOTTOM w1.524: 255.23,58.38 255.23,50.83
  vias: v2(118.45,21.32) v2(119.72,22.03) v2(245.47,20.76) v2(245.83,17.84) v2(250.15,27.31) v2(252.8,39.99) v2(253.4,39.67) v2(253.49,39.06) v2(255.5,49.69) v2(255.48,49.05) v2(255.66,60.13) v2(255.66,59.52) v2(255.96,50.12) v2(256.01,48.69) v4(118.98,21.85) v4(121.55,7.78) v4(122.41,7.78) v4(250.15,26.45) v4(250.09,25.58) v4(251.01,27.24) v4(251.01,26.37) v4(251.01,25.48) v4(251.97,27.21) v4(252,26.27) v4(252,25.38) v4(252.71,39.25) v4(252.84,27.24) v4(252.89,26.27) v4(252.89,25.38) v4(253.47,24.59) v4(253.73,27.24) v4(253.78,26.27) v4(253.78,25.41) v4(255.12,17.63) v4(255.12,16.75) v4(256.01,17.63) v4(256.01,16.75) v4(256.9,17.63) v4(256.9,16.75) v4(257.49,78.47) v4(257.82,79.31) v4(258.3,17.63) v4(258.3,16.75) v4(258.71,79.31) v4(259.19,17.63) v4(259.19,16.75)
+3VS: length 633.7
  TOP w0.102: U5800.7 303.25,135.87 303.46,136.07 C5802.1
  TOP w0.178: U3002.11 156.86,36.04 157.21,36.38 157.21,37.32 157.46,37.57 157.78,37.57 C3009.1
  TOP w0.203: U3600.36 6.54,32.86 6.25,33.15 6.25,33.42 C3602.1
  TOP w0.254: R2247.1 R2246.1 R6113.1 218.93,39.71 v2(218.99,39.65) 219.66,39.65 219.82,39.81 R6117.1 ; R3081.1 167.4,34.35 168.78,32.96 168.78,32.52 v2(168.77,32.51) ; U2401.5 226.96,27.84 C2403.1 227.44,27.82 227.66,28.04 227.66,30.3 228.16,30.81 SR6202.1 ; C3009.1 158.35,37.89 158.35,37.65 157.73,37.03 v2(157.65,37.03) ; v2(165.39,43.03) 165.51,42.91 R9200.1 ; R1502.1 49.18,10.7 49.05,10.83 R1501.1 50.12,12.48 v2(50.12,12.91) ; C1517.2 39.99,12.07 40.77,12.07 40.95,11.9 U1501.16 ; R5008.1 264.47,84.97 264.78,85.27 R5007.1 265.46,84.92 265.79,84.59 269.45,84.59 271.46,86.6 274.83,86.6 275.84,87.6 SR1301.1 275.84,89.73 275.89,89.78 275.89,92.51 272.25,96.15 v2(264.39,96.15) 262.87,94.62 260.31,94.62 259.9,94.22 259.19,94.22 258.63,93.66 R5013.1 ; R5011.1 v2(291.45,129.12) ; C1504.1 35.66,11.75 R1506.1 36.18,11.95 v2(36.63,12.4) 36.18,12.86 R1503.1 ; R2206.1 R2203.1 241.85,64.04 v2(241.62,63.81) ; R2251.1 246.11,59.38 v2(246.11,59.06) ; SR3104.2 184.18,12.13 185.53,13.47 T9104.1 186.14,14.92 v2(186.14,15.55) 186.14,17.79 v2(188.86,20.5) ; R2364.1 234.96,39.12 v2(234.75,38.92) ; v2(124.47,29.95) 124.89,30.37 124.89,37.76 123.02,39.63 123.02,47.27 120.05,50.24 120.05,53.59 119.54,54.11 v2(119.54,54.11) ; R3147.1 R3145.1 R3143.1 R3141.1 179.56,21.32 179.39,21.49 179.39,22.21 179.59,22.41 v2(180.6,22.41) ; v2(246.9,66.96) 246.67,67.19 R2202.1 ; R2365.1 224.42,39.83 v2(224.21,39.63) ; R2209.1 v2(219.82,44.35) ; R9203.1 177.12,40.07 177.12,39.47 v2(177.13,39.45) ; v2(182.92,15.54) 182.72,15.54 R3172.2
  TOP w0.279: v2(46.59,16.62) 46.59,16.52 46.06,15.98 C1516.2 44.61,15.98 44.33,16.26 43.82,16.26 43.53,15.97 U1501.6
  TOP w0.356: R2380.1 233.82,49.16 U2301.2 233.82,47.47 v2(233.6,47.25) ; v2(234.52,44.48) 234.51,44.48 233.82,45.18 U2301.5 ; R5001.1 294.04,135.44 293.81,135.67 R5002.1 289.98,135.67 288.55,134.24 C5000.2 289.1,133.65 289.58,133.16 U5000.1
  TOP w0.432: v2(48.67,124.7) R3111.1 48.67,123.48 48.37,123.17 47.61,123.17 v2(47.22,123.55) 46.87,123.2 44.02,123.2 43.75,123.48 R3107.2 v2(42.73,124.06) 42.73,126.78 43.82,127.87 R3109.1 R3102.2 ; R5603.1 v2(91.95,186.95) 92.13,187.13 R4593.1 93.2,187.13 R4518.1 ; v2(303.23,128.73) R5808.1 C5801.1 303.89,129.34 305.39,129.34 306.94,130.89 306.94,131.47 308.93,133.47 308.93,134.74 308.72,134.96 308.72,136.23 305.34,139.61 303.56,139.61 303.22,139.27 C5803.1 ; R2379.1 234.73,44.28 v2(234.52,44.48) ; v2(297.87,135.11) R5806.2 296.93,134.47 296.55,134.86 R5001.1 ; R5022.1 126.42,29.45 125.48,28.51 v2(125.48,27.77) ; SR2607.2 229.72,72.28 229.96,72.52 C2620.1 231.15,72.52 232.07,73.44 232.07,75.5 232.23,75.66 232.23,75.67 232.56,76 232.56,76 232.67,76.11 235.98,76.11 236.14,75.96 238.27,75.96 v2(238.83,75.39) ; R1243.1 v2(284.53,67.04) ; v2(89.9,185.63) 90.28,185.25 C5600.1 ; R3632.1 17.2,19.54 17.25,19.49 v2(17.71,19.49) ; v2(15.86,25.13) 16.03,25.31 R3603.2 ; R5012.1 45.12,119.69 v2(45.19,119.62) ; R3604.1 R3608.1 18.65,22.46 v2(18.27,22.84) ; C1517.2 39.48,12.43 39.27,12.63 v2(39.27,12.99) ; R5801.2 v2(300.21,128.73)
  TOP w0.508: v2(11.79,17.58) 12.03,17.58 12.26,17.81 SR3602.1 ; v2(5.57,33.1) 5.57,33.6 C3602.1 ; SR6202.1 v2(227.21,31.86) ; v2(297.87,135.11) 297.87,137.22 299.5,138.84 C5803.1 303.22,138.35 303.46,138.11 C5802.1 ; 78.59,11.79 78.59,10.65 80.3,8.95 R5019.1 R5021.1 ; v2(282.15,112.25) 282.15,109.79 v2(281.08,108.72) ; R1409.1 269.38,43 269.17,43.21 v2(268.79,43.21)
  IN1 w0.508: 285.98,66.91 287.95,66.91 290.91,69.87 290.91,71.94 290.13,72.73 290.13,78.65 289.21,79.56 288.45,79.56 287.28,80.73 287.28,81.39 286.24,82.43 v2(286.24,86.82) ; v2(297.87,135.11) 297.44,135.11 v2(291.45,129.12) 291.45,127.18 296.02,122.61 296.58,122.61 297.8,121.39 297.8,118.09 294.62,114.92 293.29,114.92 292.16,113.78 292.16,109.79 v2(290.43,108.06) ; v2(281.08,108.72) 280.12,108.72 278.44,107.04 278.44,106.68 267.91,96.15 v2(264.39,96.15) ; v2(61.7,115.55) 61.07,116.19 61.07,116.41 60.56,116.92 59.01,116.92 50.91,108.82 49.89,108.82 v2(46.21,105.14)
  IN2 w0.508: v2(282.15,112.25) 285.45,108.95 289.79,108.95 290.43,108.31 v2(290.43,108.06) ; v2(42.73,124.06) 42.73,122.08 v2(45.19,119.62) ; 5.95,25.25 4.55,23.86 4.55,17.86 v2(5.75,16.67) 10.88,16.67 v2(11.79,17.58) 15.81,17.58 v2(17.71,19.49) 17.15,20.05 17.15,21.72 v2(18.27,22.84) 18.27,23.6 17.84,24.04 16.69,24.04 15.86,24.87 v2(15.86,25.13) ; v2(238.83,75.39) 238.91,75.32 239.5,75.32 240.55,76.36 245.39,76.36 246.56,75.19 246.56,74.68 245.69,73.81 244.35,73.81 243.82,73.28 243.82,71.91 244.1,71.64 244.1,70.39 241.61,67.9 241.61,65.23 241.62,65.22 v2(241.62,63.81)
  IN2 w0.889: 301.07,88.91 301.45,89.29
  IN2 w1.27: 302.75,91.42 304.63,91.42 308.74,95.54 308.74,99.52 307.35,100.92 307.35,103.82 307.35,103.82
  IN2 w1.524: 292.72,51.49 287,51.49 ; 297.57,52.53 297.57,51.11 300.62,48.06 304.7,48.06
  IN3 w0.508: v2(234.52,44.48) 233.6,45.41 v2(233.6,47.25) ; v2(18.27,22.84) 18.12,22.99 18.12,30.97 16.16,32.93 16.16,35.03 15.68,35.52 14.26,35.52 13.44,36.33 13.44,40.01 14.74,41.31 15.4,41.31 16.41,42.32 16.41,45.64 15.51,46.54 10.65,46.54 8.16,49.03 5.95,49.03 v2(4.68,50.3) ; v2(303.23,128.73) 302.62,129.34 300.59,129.34 300.21,128.96 v2(300.21,128.73) ; v2(61.7,115.55) 61.7,114.13 60.81,113.24 60.81,111.69 61.09,111.42 v2(61.45,111.42) ; 111.23,189.97 112.5,191.24 116.19,191.24 116.82,190.61 122.69,190.61 v2(122.84,190.76)
  IN4 w0.508: v4(294.37,102.72) 290.43,106.66 v2(290.43,108.06) ; v2(182.92,15.54) 182.92,15.43 183.42,14.93 185.75,14.93 186.14,15.31 v2(186.14,15.55) ; v2(17.71,19.49) 17.71,19.24 19.44,17.51 22.84,17.51 24.24,16.11 30.49,16.11 v2(31.21,16.83)
  BOTTOM w0.254: R2106.1 228.34,39.74 228.43,39.66 v2(228.43,39.61) ; R6101.1 219.19,39.86 v2(218.99,39.65) 218.78,39.86 R6103.1 218.04,39.86 R6121.1 216.85,39.86 216.72,39.98 R6123.1 R6119.1 215.37,39.4 215.42,39.35 215.42,38.73 215.13,38.44 214.71,38.44 214.41,38.73 214.41,39.55 214.48,39.63 R2249.1 214.36,40.11 R2204.1 R2210.1 R6115.1 R2244.1 R2245.1 ; R1504.1 47.73,16.09 v2(47.2,16.62) 47.2,16.67 R1514.1 ; v2(249.76,56.24) 249.6,56.24 R2405.2 R2449.2 ; R1505.1 35.49,15.78 35.97,15.3 v2(37.6,15.3) ; R2205.1 213.65,42.48 v2(213.31,42.15) ; v2(119.54,54.11) 118.99,54.66 118.99,59.33 116.99,61.34 116.99,66.54 116.9,66.63 116.9,71.56 117.68,72.35 123.08,72.35 124.21,73.48 R7007.1 ; R2207.1 220.96,41.74 220.71,41.99 v2(220.71,42.32) R2208.1 ; R4526.1 109.58,184.13 ; R4517.2 R4501.1 122.92,190.68 v2(122.84,190.76) ; v2(251.9,40.7) 252.1,40.9 R2497.1 ; R2318.1 236.84,40.04 R2316.1 236.15,39.81 236.4,39.55 v2(236.4,39.43) ; v2(168.77,32.51) 168.77,36 168,36.76 168,40.42 v2(165.39,43.03) ; R2320.1 R2314.1 233.58,39.33 233.43,39.17 v2(233.43,38.41) 233.05,38.03 R2324.1
  BOTTOM w0.279: CON5602.18 90.25,185.28 v2(89.9,185.63)
  BOTTOM w0.432: v2(234.52,44.48) 234.47,44.43 R2360.1 ; SR4503.1 C4536.1 109.51,187.99 ; R5003.1 60.47,111.42 v2(61.45,111.42) 62.2,111.42 R5000.1 63.1,110.52 63.1,105.24 65.44,102.9 R0704.1 ; v2(238.83,75.39) 238.92,75.31 238.92,74.78 ; v2(110.34,191.24) 110.27,191.32 R4587.2 ; v2(281.08,108.72) 280.47,108.11 R5018.1 ; U5003.5 283.15,111.01 283.18,111.04 C5007.2 283.18,111.9 282.82,112.25 v2(282.15,112.25) ; SR4501.1 107.83,186.87
  BOTTOM w0.508: R1304.1 285.95,87.11 285.98,87.09 285.98,87.07 286.12,86.93 286.14,86.93 v2(286.24,86.82) ; v2(276.03,49.77) 276.21,49.77 276.33,49.89 R3170.2
  vias: v2(29.01,24.02) v2(32.21,32.11) v2(109.02,180.7) v2(109.05,180.09) v2(109.68,180.7) v2(109.68,180.09) v2(236.68,16.95) v2(283.83,67.67) v2(283.83,67.04) v2(285.86,50.76) v2(286.49,66.05) v2(286.47,50.76) v2(304.45,107.55) v2(305.09,107.55) v2(307.45,109.46) v2(308.11,109.46) v4(28.58,24.62) v4(29.47,24.61) v4(32.95,31.93) v4(33.81,31.93) v4(41.26,172.57) v4(41.26,171.69) v4(42.27,171.69) v4(61.83,16.36) v4(62.52,17.43) v4(62.85,16.62) v4(78.47,21.19) v4(79.36,21.19) v4(80.24,21.19) v4(81.13,21.19) v4(235.95,20.43) v4(236.84,20.43) v4(237.42,17) v4(237.72,20.17) v4(238.28,17) v4(238.61,20.17) v4(285.14,52.91) v4(294.37,101.84) v4(308.67,42.25) v4(309.08,41.32)
+3VS_CAM: length 3.7
  TOP w0.254: v2(107.11,189.28) 107.25,189.15 CON4500.31
  BOTTOM w0.432: SR4501.2 C4539.1 106.99,188.86 107.11,188.98 v2(107.11,189.28) 107.52,189.69 T4508.1
+3VS_DMIC: length 8.8
  TOP w0.254: CON4500.27 109.25,190.31 108.44,191.12 107.55,191.12 v2(107.04,190.61)
  BOTTOM w0.432: SR4503.2 109.28,190.52 108.81,191 108.81,191.26 T4507.1 108.01,191.83 107.5,191.32 C4545.1 v2(107.04,190.61)
+3VS_DPOUT: length 2.2
  TOP w0.102: 310.24,118.12 308.21,118.12 v1(308.11,118.02)
+3VS_DPSW: length 57.5
  TOP w0.178: v2(268.01,52.6) 268.19,52.6 268.76,52.03 268.76,51.59 268.21,51.04 267.29,51.04 267.02,50.76 U1401.25
  TOP w0.254: R1407.1 257.88,51.95 257.55,51.95 v2(257.03,52.47) ; R1415.1 R1414.1 267.96,52.66 v2(268.01,52.6) ; R1402.1 258.31,48.8 258.8,49.28 v2(258.89,49.28) ; 264.27,42.45 264.02,42.7 U1401.6
  TOP w0.279: U1401.1 261.52,43.09 261.24,42.81 260.79,42.81 260.03,42.04 260.03,41.94 C1414.2 ; U1401.36 261.22,50.54 v2(260.57,50.54) ; v2(264.28,51.02) 263.77,51.02 263.52,50.77 U1401.32
  TOP w0.406: 264.27,39.07 264.41,38.94 264.44,38.94 264.83,39.33 264.83,41.25 264.47,41.61 C1413.1 264.27,42.45
  TOP w0.432: C1414.2 259.39,41.48 258.63,40.72 v1(258.63,40.44) 258.63,40.24 260.55,38.32 261.37,38.32 R1405.1 R1403.1 264.18,38.98 264.27,39.07 v2(264.27,39.22)
  IN1 w0.508: v2(264.27,39.22) 259.42,44.07 259.42,48.74 v2(258.89,49.28)
  IN2 w0.508: v2(264.27,39.22) v2(266.3,39.22)
  IN3 w0.508: v2(257.03,52.47) 257.03,52.31 258.79,50.54 v2(260.57,50.54) ; v2(260.57,50.54) 261.05,51.02 v2(264.28,51.02) 265.06,51.8 267.21,51.8 v2(268.01,52.6) ; v2(260.57,50.54) 260.57,49.93 259.96,49.32 258.97,49.32 258.93,49.28 v2(258.89,49.28)
+3VS_EDP: length 26.4
  TOP w0.254: v2(91.93,189.85) 91.93,190.99 92.23,191.29 R4525.1
  IN1 w0.254: v4(113.01,189.77) 112.81,189.97 109.96,189.97 108.53,191.41 101.87,191.41 99.42,188.96 92.82,188.96 v2(91.93,189.85)
  BOTTOM w0.432: R4523.1 113.49,188.17
  vias: v4(113.9,189.77)
+3VS_GSENSOR: length 5.9
  TOP w0.102: U5800.3 302.75,130.69 R5808.2 302.8,130.21 302.71,130.12 302.71,128.65 v1(303.28,128.07)
+3VS_HDMI: length 47.8
  TOP w0.203: v2(296.4,86.85) 296.4,86.72 296.4,86.72 U1301.37 ; C1316.1 293.49,79.15 293.82,79.49 293.82,79.62 295.2,81 U1301.11
  TOP w0.381: R1313.1 296.4,87.31 v2(296.4,86.85) ; v2(295.13,86.85) R1312.1
  TOP w0.432: v2(293.86,81.06) 293.86,80.25 292.97,79.36 C1316.1 v2(292.26,79.15)
  BOTTOM w0.254: R1324.1 293.35,76.26 v2(293.35,77.66) 294.07,77.66 294.65,78.24 295.03,78.24 295.76,78.98 297.41,78.98 298.81,80.37 299.57,80.37 300.21,81.01 300.21,81.52 300.84,82.15 R1326.1 ; v2(296.4,86.85) 296.91,87.36 296.91,87.99 297.21,88.3 R1330.1
  BOTTOM w0.381: v2(295.13,86.85) v2(296.4,86.85) 295.81,87.43 R1312.1 293.81,87.43 293.48,87.1 288.47,87.1 287.84,87.74 R1304.2
  BOTTOM w0.432: R1301.2 286.4,85.45 C1314.1 ; v2(292.26,79.15) 291.67,79.15 R1328.1 ; v2(293.86,81.06) 293.4,81.52 291.59,81.52 291.27,81.83 R1319.1 290.81,82.15 290.76,82.2 R1322.1 R1329.1 288.6,82.2 287.08,83.73 C1314.1 ; C1314.1 287.08,86.37 v1(287.29,86.58) R1304.2
+3VS_IO: length 60.1
  TOP w0.762: 7.83,49.31 7.02,48.5 3.11,48.5 v4(2.88,48.72)
  IN2 w0.762: v4(18.4,87.79) 18.4,87.76 16.95,86.32 15.88,86.32 13.98,84.41 11.74,84.41 9.65,82.32 5.86,82.32 3.56,80.02 v4(1.6,80.02)
  BOTTOM w0.508: v4(19.34,87.81) 19.34,87.28 20.49,86.12 CON6701.2
  BOTTOM w0.762: v4(1.6,80.02) 1.6,52.16 2.88,50.88 v4(2.88,48.72)
  vias: v1(18.29,85.53)
+3VS_S0: length 16.4
  TOP w0.254: R1130.2 295.19,50.02 v2(295.06,50.15) ; v2(279.3,50.11) 279.04,49.84 R1111.2 ; v5(296.72,42.37) 296.4,42.05 U1101.H9 ; R1119.2 283.57,45.42 v2(283.95,45.04)
  IN3 w0.254: 298.61,43 297.35,43 v5(296.72,42.37)
  IN3 w0.508: v2(300.41,44.86) 300.41,43.92 299.49,43 298.61,43
  BOTTOM w0.127: v2(285.68,44.66) 284.89,44.66 v1(284.82,44.74)
  BOTTOM w0.254: R1144.2 279.43,49.98 v2(279.3,50.11) ; v2(285.68,44.66) 286.04,44.66 286.7,44 286.7,43.67 R1143.2 ; R1134.2 297.23,42.95 296.72,42.45 v5(296.72,42.37) 296.78,42.31 C1188.1
  vias: v2(279.13,44.05) v2(279.76,44.05) v4(301.82,44.27)
+3VS_S0_TBT: length 0.5
  TOP w0.254: U1101.R13 293.18,40.1 v5(293.5,40.42)
  vias: v1(284.36,42.96) v2(286.04,43.36)
+3VS_SSD2:
  vias: v1(25.25,25.61) v2(25.38,38.62) v2(25.38,38.01) v2(25.38,37.4) v2(25.38,23.4) v2(25.38,22.79) v2(25.38,22.18) v2(25.38,21.57) v2(25.38,20.96)
+3VS_SSD3:
  vias: v1(54.08,14.97) v2(34.91,8.87) v2(35.54,8.87) v2(36.18,8.87) v2(36.81,8.87) v2(37.45,8.87) v2(40.72,9) v2(41.33,9) v2(46.46,9) v2(47.1,9) v2(49.51,9.38) v2(49.51,8.74) v2(52.3,15.96) v2(53.83,15.73) v2(54.46,15.73)
+3VS_SSD_PCIE:
  vias: v1(35.36,30.84) v2(35.54,22.21) v2(36.18,22.21) v2(36.68,37.83) v2(36.68,35.8) v2(36.68,35.16) v2(36.81,22.21) v2(37.32,37.83) v2(37.32,37.19) v2(37.32,35.8) v2(37.32,35.16)
+3VS_TP: length 193.9
  TOP w0.254: SR3107.1 207.03,20.26 207.73,19.57 208.29,19.57 208.77,20.05 211.36,20.05 212.2,20.89 212.2,21.62 212.96,22.38 v2(212.96,22.6) ; R3072.1 R3073.1 158.25,15.14 158.46,14.93 158.46,14.53 158.75,14.24 161.9,14.24 163.02,15.36 163.02,16.85 162.43,17.44 162.43,20.39 v2(162.69,20.65) ; R2312.1 R2313.1 232.44,38.92 v2(232.54,38.82)
  TOP w0.432: v2(208.57,31.68) 209.88,31.68 213.65,35.45 216.27,35.45 218.4,37.57 v2(220.61,37.57)
  TOP w0.508: v2(224.43,35.36) 224.76,35.36 v1(226.52,33.6) 226.6,33.52 226.6,31.88 v2(226.57,31.86)
  IN1 w0.508: v2(232.54,38.82) 232.54,38.21 231.19,36.86 221.32,36.86 v2(220.61,37.57)
  IN2 w0.254: v2(212.96,22.6) 212.96,22.82 212.7,23.08 208.26,23.08 206.78,21.6 188.37,21.6 188.29,21.52 176.83,21.52 176.71,21.41 163.06,21.41 162.69,21.04 v2(162.69,20.65)
  IN3 w0.508: v2(226.57,31.86) 226.6,31.83 226.6,31.61 226.96,31.25 228.58,31.25 229.22,31.88 238,31.88 239.78,33.66 243.24,33.66 245.19,35.62 250.13,35.62 250.64,35.11 252.26,35.11 253.23,36.08 257.29,36.08 258.05,36.84 261.17,36.84 262.01,37.68 262.01,39.07 267.32,44.38 268.41,44.38 273.36,49.33 275.34,49.33 275.55,49.13 v2(276.18,49.13)
  BOTTOM w0.254: v2(212.96,22.6) 212.96,27.29 v2(208.57,31.68)
  BOTTOM w0.381: Q2301.1 v2(220.61,37.57)
  BOTTOM w0.508: Q2301.1 222.17,34.86 222.53,34.5 224.82,34.5 225.15,34.83 R2310.1 224.8,35.74 224.43,35.38 v2(224.43,35.36) ; v2(276.18,49.13) 276.23,49.08 277.86,49.08 278.02,49.24 R3170.1 C3104.1 SR3110.2 278.02,53.13 277.81,53.35 R3169.2
