# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWM1_B: length 19.3
  TOP w0.102: v1(60.1,181.44) 59.92,181.26 v2(59.92,180.8)
  TOP w0.254: v2(56.42,166.18) 56.28,166.18 56.08,166.38 U8006.1
  IN2 w0.254: v2(59.92,180.8) 59.92,177.73 58.02,175.82 58.02,170.9 55.73,168.61 55.73,166.78 56.33,166.18 v2(56.42,166.18)
  BOTTOM w0.222: U8000.12 59.64,181.34
  BOTTOM w0.254: 59.64,181.34 59.92,181.06 v2(59.92,180.8)
PWM2_A: length 30.6
  IN1 w0.254: v2(77.2,181.21) 66.46,181.21 64.75,179.51 60.15,179.51 59.14,180.52 53.99,180.52 53.34,181.17 v2(52.57,181.17)
  BOTTOM w0.102: U8002.1 77.48,180.93 v2(77.2,181.21) 75.72,179.74 v1(75.52,179.74)
  BOTTOM w0.203: v2(52.57,181.17) 52.94,181.53 52.94,181.61 53.07,181.74 U8000.26
PWM2_B: length 13.3
  TOP w0.102: v1(58.2,179.53) 58.32,179.53 v2(58.76,179.97)
  TOP w0.254: v2(65.65,172.33) 65.74,172.24 U8004.1
  IN3 w0.508: v2(65.65,172.33) 65.65,173.38 62.47,176.56 61.91,176.56 61.55,176.92 61.55,177.17 v2(58.76,179.97)
  BOTTOM w0.203: v2(58.76,179.97) 58.57,180.15 U8000.13
PWM3_A: length 33.7
  TOP w0.254: v2(52.1,181.57) 52.09,181.55 52.09,180.97 v1(54.15,178.9) 54.49,178.57 64.64,178.57 66.81,176.4 66.81,173.43 68.58,171.66 68.58,168.19 68.81,167.95 68.81,166.63 67.54,165.36 67.54,164.88 68.18,164.24 v2(68.26,164.24)
  BOTTOM w0.216: v2(52.1,181.57) 52.68,182.14 U8000.27
  BOTTOM w0.254: v2(68.26,164.24) 68.26,164.52 68.46,164.73 U8003.1
PWM_C: length 77.6
  TOP w0.102: v2(52.41,185.67) 52.29,185.79 v1(52.29,186.29)
  TOP w0.254: v2(101.45,155.56) 101.2,155.81 U8005.3
  IN1 w0.254: v2(52.41,185.67) 52.41,185.49 53.16,184.74 58.32,184.74 59.11,185.53 61.07,185.53 61.58,186.04 76.9,186.04 78.39,184.54 79.86,184.54 80.27,184.94 80.47,185.15 86.13,185.15 88.87,182.4 89.5,182.4 90.36,181.54 90.65,181.54 90.65,181.54 93.64,181.54 101.1,174.08 101.1,162.52 100.92,162.34 100.92,159.21 100.37,158.67 100.37,157.35 101.45,156.27 v2(101.45,155.56)
  BOTTOM w0.203: v2(52.41,185.67) 52.73,185.34 U8000.35
PWR_LED: length 303
  TOP w0.102: v2(150.35,30.41) 150.35,32.24 151.66,33.56 U3002.24
  IN2 w0.102: v2(83.75,183.14) 83.08,182.47 81.33,182.47 74.68,175.82 74.68,171.59 72.95,169.86 72.95,162.12 71.19,160.36 71.19,154.71 69.71,153.23 69.71,149.77 68.36,148.42 68.36,145.08 65.41,142.14 65.41,134.95 66.07,134.29 66.07,128.3 67.82,126.55 67.82,120.63 67.78,120.59 67.78,120.08 67.82,120.04 67.82,117.33 65.12,114.63 65.12,113.57 58.63,107.07 53.03,107.07 46.41,100.46 46.41,99.46 46.41,76.72 37.17,67.47 37.17,46.14 42.37,40.93 42.37,37.74 44.96,35.16 52.74,35.16 55.72,32.18 100.88,32.18 102.96,34.26 108.28,34.26 108.8,34.78 112.78,34.78 113.85,35.85 121.05,35.85 123.8,38.59 127.59,38.59 136.59,29.59 149.53,29.59 v2(150.35,30.41)
  BOTTOM w0.102: CON5602.17 89.75,183.72 89.52,183.5 88.98,183.5 88.96,183.47 84.08,183.47 v2(83.75,183.14) ; v1(150.7,31) 150.7,30.77 v2(150.35,30.41)
PWR_LED_LED: length 9.5
  TOP w0.114: LQ800.1 LC800.1 242.07,191.51 242.07,191.31 240.53,189.77 237.19,189.77 236.95,190.01 CON1.5
PWRBTN#: length 318
  TOP w0.102: JP5601.1 v2(87.41,189.59)
  IN2 w0.102: v2(155.35,30.33) 154.2,29.19 136.38,29.19 128.65,36.91 122.69,36.91 121.22,35.44 114.02,35.44 112.95,34.37 108.97,34.37 108.45,33.85 103.13,33.85 101.05,31.78 55.55,31.78 52.57,34.75 44.79,34.75 41.89,37.65 41.89,40.82 36.51,46.21 36.51,68.21 45.78,77.48 45.78,88.58 45.4,88.96 45.4,100.6 52.28,107.48 57.89,107.48 60.71,110.3 60.71,112.55 62.31,114.15 62.31,117.28 63.15,118.12 63.15,122.82 63.48,123.15 63.48,128.18 62.9,128.76 62.9,134.01 64.4,135.51 64.4,145.03 69.3,149.94 69.3,153.4 70.79,154.88 70.79,169.11 72.04,170.37 72.04,175.83 72.55,176.34 72.55,177.15 73.38,177.98 75.76,177.98 80.63,182.85 80.63,183.99 81.38,184.74 85.54,184.74 88.58,187.78 88.58,188.82 88.26,189.14 87.86,189.14 v2(87.41,189.59)
  BOTTOM w0.102: CON5602.16 89.25,185.16 88.61,185.8 88.61,188.85 88.32,189.14 87.86,189.14 v2(87.41,189.59) ; v1(156.24,32.49) R3053.2 R3024.1 v2(155.35,30.33) R3028.2
R303_D8: length 2.6
  BOTTOM w0.432: R2811.2 278.64,64.6 278.39,64.35 v1(277.73,64.35) 277.47,64.6 D2801.2
R_DMIC-CLK: length 3
  TOP w0.229: 6.96,25.67 7.34,26.05 U3600.3
  TOP w0.254: 6.96,25.67 6.61,25.32 6.61,24.39 R3611.2
R_DMIC-DATA: length 3
  TOP w0.229: U3600.2 6.94,26.25 6.5,25.8
  TOP w0.254: 6.5,25.8 5.87,25.18 v1(5.87,25.08) 5.95,25 R3610.2
RCIN#: length 134.9
  TOP w0.102: SR2201.1 244.96,68.1 v2(244.24,67.38) ; v2(152.93,27.54) 152.93,28.19 153.98,29.24 153.98,30.83 157.37,34.22 159.56,34.22 159.66,34.32 U3002.4
  IN1 w0.102: v2(244.24,67.38) 243.42,66.56 243.42,54.34 241.41,52.33 241.41,47.54 239.44,45.57 237.6,45.57 236.48,44.44 236.48,44.35 236.06,43.94 211.21,43.94 209.56,42.28 209.56,41.52 208.97,40.93 208.97,38.43 205.55,35.01 204.84,35.01 196.39,26.56 153.5,26.56 152.93,27.13 v2(152.93,27.54)
  BOTTOM w0.102: v2(152.93,27.54) 153.22,27.83 v1(153.22,28.3)
RESERVED_PIN64: length 2.9
  BOTTOM w0.102: CON5300.64 303.5,101.7 T5310.1
RL_XTAL1: length 9
  TOP w0.121: U3300.7 282.72,100.96 283.52,101.76 285.55,101.76 v1(285.79,102) C3324.1 287.07,103.28 289.17,103.28 289.91,102.53 Y3300.1
RL_XTAL2: length 7.3
  TOP w0.121: U3300.8 282.77,101.36 283.62,102.22 v1(284.05,102.22) 285.06,102.22 C3325.1 287.5,103.91 Y3300.3
ROM_CS#: length 4
  BOTTOM w0.121: R7400.1 130.87,68.61 131.02,68.46 U7401.1 ; R7400.1 R7483.2 ; R7400.1 v1(129.93,69.4)
ROM_CS#_R: length 31.7
  TOP w0.121: v2(135.24,73.19) 135.01,73.41 v1(134.42,73.41)
  IN4 w0.083: v2(135.24,73.19) 134.83,72.78 134.83,71.69 135.01,71.51 135.31,71.51 136.05,70.77 136.05,68.31 137.75,66.61 140.71,66.61 143.19,69.08 143.19,70.71 142.92,70.99 142.92,73.47 144.39,74.94 144.39,76.67 v3(145.51,77.79)
  BOTTOM w0.102: v3(145.51,77.79) 145.51,77.81 U7000.BJ4
  BOTTOM w0.121: R7483.1 131.9,70.47 131.9,72.24 132.81,73.15 135.2,73.15 v2(135.24,73.19)
ROM_SCLK: length 8.3
  BOTTOM w0.121: R7403.2 136,65.64 136,64.62 135.74,64.37 133.71,64.37 133.56,64.22 U7401.6 133.56,60.56 v1(133.28,60.28)
ROM_SCLK_R: length 24.9
  IN4 w0.083: v3(145.5,77.1) 145.82,76.78 145.82,73.12 145.15,72.45 145.15,69.52 144.56,68.94 144.56,67.91 143.84,67.18 143.51,67.18 143.03,67.18 142.59,66.74 142.59,66.06 142.16,65.63 140.57,65.63 140.49,65.55 140.49,64.91 140.4,64.83 140.07,64.83 139.99,64.91 139.99,65.55 139.91,65.63 139.58,65.63 139.49,65.55 139.49,64.91 139.41,64.83 139.08,64.83 139,64.91 139,65.55 138.92,65.63 138.35,65.63 v2(138.16,65.44)
  BOTTOM w0.102: v3(145.5,77.1) U7000.BK3
  BOTTOM w0.121: R7431.1 R7432.2 136.46,65.34 136.76,65.64 136.86,65.64 R7403.1 137.5,66.1 v2(138.16,65.44) 138.28,65.56 v1(138.28,66.12)
ROM_SI: length 4.1
  BOTTOM w0.121: U7401.5 134.83,60.46 v1(135.03,60.26) 135.77,60.99 135.77,61.68 R7402.2
ROM_SI_R: length 26.6
  IN4 w0.083: v2(137.9,62.36) 137.67,62.6 137.67,65.74 137.87,65.94 142.03,65.94 142.28,66.19 142.28,66.87 142.9,67.49 143.71,67.49 144.25,68.04 144.25,69.07 144.84,69.65 144.84,70.65 144.75,70.73 144.01,70.73 143.95,70.79 143.95,71.04 144.06,71.15 144.75,71.15 144.84,71.23 144.84,72.57 145.42,73.16 v3(145.42,75.41)
  BOTTOM w0.102: U7000.BK2 145.52,76.38 145.52,75.5 v3(145.42,75.41)
  BOTTOM w0.121: v1(136.96,60.52) 136.96,60.97 R7430.2 136.84,61.86 136.84,61.88 R7402.1 ; R7402.1 v2(137.9,62.36) ; R7402.1 136.8,62.88 136.8,62.91 R7428.1
ROM_SO: length 32
  TOP w0.121: v2(135.24,72.57) 134.45,71.79 v1(134.45,71.64)
  IN4 w0.083: v3(144.8,77.81) 143.59,76.6 143.59,74.94 141.76,73.11 141.76,68.2 140.53,66.97 139.72,66.97 139.27,67.42 137.88,67.42 136.51,68.79 136.51,71.3 v2(135.24,72.57)
  BOTTOM w0.102: U7000.BK4 144.81,77.81 v3(144.8,77.81)
  BOTTOM w0.121: v2(135.24,72.57) 135.09,72.72 132.98,72.72 132.33,72.06 132.33,70.95 132.46,70.81 R7426.1 132.75,70.04 132.65,69.94 R7427.2 132.29,68.97 U7401.2
RPD_G1: length 11.1
  TOP w0.076: U1201.K9 296.23,59.94 296.75,59.94
  TOP w0.102: v1(304.68,58.73) 304.68,58.38 304.07,57.77 302.57,57.77 302.48,57.85 SR1201.2 302.48,58.81 302.28,59.01 301.54,59.01 300.27,60.28 297.08,60.28 296.75,59.94
RPD_G2: length 8.9
  TOP w0.076: 296.97,60.83 296.97,60.83 296.59,60.45 296.29,60.45 296.03,60.2 U1201.K10
  TOP w0.102: v1(303.84,60.26) 303.42,60.67 302.11,60.67 302.03,60.58 SR1202.2 301.52,60.25 300.94,60.84 296.99,60.84 296.97,60.83
RST#: length 9
  TOP w0.102: R3307.2 SR3304.2 286.37,94.36 286.58,94.58 286.58,95.24 v1(286.49,95.33) 285.98,95.84 285.98,97.29 285.2,98.08 284.46,98.08 283.96,98.58 283.35,98.58 282.97,98.96 U3300.2
RST#_DP: length 5
  TOP w0.254: U1401.35 262.02,50.92 261.37,51.57 v1(260.92,51.57) 260.5,51.15 C1412.1 259.33,51.15 258.97,51.52 R1407.2
RSVD19: length 2.8
  TOP w0.089: v1(77.3,118.14) 77.3,118.88 v3(77.31,118.89) 77.62,119.2 77.91,119.2 R1004.1
  BOTTOM w0.102: U0300.BL22 77.64,118.57 v3(77.31,118.89)
RSVD28: length 3.1
  TOP w0.089: v1(76.64,120.43) 77.17,119.9 77.45,119.9 R1005.2 77.17,119.31 77.08,119.31 77.04,119.27
  TOP w0.102: v3(76.66,118.89) 76.66,118.89 77.04,119.27
  BOTTOM w0.102: U0300.BM22 76.99,118.56 v3(76.66,118.89)
RSVD30: length 2.7
  TOP w0.102: v3(76.01,114.17) 76.01,113.83 75.75,113.57 v1(75.37,113.57) 75.1,113.84 R1010.2
  BOTTOM w0.102: v3(76.01,114.17) 76.01,114.1 U0300.BN16
RSVD34: length 2.9
  TOP w0.102: v3(76.01,114.95) 75.55,114.95 R1009.1 74.81,115.38 v1(74.12,116.06)
  BOTTOM w0.102: v3(76.01,114.95) 76.01,114.89 U0300.BP17
RSVD_TP0: length 1.6
  TOP w0.102: T0708.1 78.04,112.28 v3(78.04,111.74)
  BOTTOM w0.102: v3(78.04,111.74) 78.48,111.74 78.66,111.56 U0300.BJ13
RSVD_TP1: length 2.9
  TOP w0.102: v3(79.52,112.53) 79.94,112.95 80.41,112.95 80.92,112.45 T0707.1
  BOTTOM w0.102: U0300.BJ14 79.23,112.24 v3(79.52,112.53)
RSVD_TP2: length 2.5
  TOP w0.102: v3(79.49,114.97) 79.18,115.28 79.18,115.37 T0717.1
  BOTTOM w0.102: v3(79.49,114.97) 79.49,114.33 U0300.BJ16
RSVD_TP3: length 1.3
  TOP w0.089: T0724.1 79.51,120.04 v3(79.47,120.07)
  BOTTOM w0.102: U0300.BJ24 v3(79.47,120.07)
RSVD_TP4: length 3.9
  TOP w0.102: v3(78.95,127.08) 78.54,127.49 78.54,129.07 78.42,129.19 T0734.1
  BOTTOM w0.102: v3(78.95,127.08) 78.87,127.08 U0300.BJ33
RSVD_TP5: length 1.5
  TOP w0.089: v3(78.95,127.73) 79.1,127.89 T0732.1
  BOTTOM w0.102: U0300.BJ34 78.65,127.51 78.72,127.51 v3(78.95,127.73)
RSVD_TP6: length 2.2
  TOP w0.102: T0719.1 79.12,113.67 v3(79.47,113.67)
  BOTTOM w0.102: U0300.BK16 78.64,113.42 79.21,113.42 v3(79.47,113.67)
RSVD_TP7: length 4.7
  TOP w0.102: v3(80.03,120.86) 80.19,120.69 80.19,119.64 T0722.1
  BOTTOM w0.102: U0300.BK24 78.67,120.45 79.62,120.45 v3(80.03,120.86)
RSVD_TP8: length 1.3
  TOP w0.102: T0714.1 77.54,127.08 v3(78.16,127.08)
  BOTTOM w0.102: U0300.BL33 78.09,127.08 v3(78.16,127.08)
RSVD_TP9: length 1.9
  TOP w0.102: T0703.1 75.81,127.62 v3(76.66,126.77)
  BOTTOM w0.102: v3(76.66,126.77) 76.66,126.7 U0300.BM33
RSVD_TP10: length 3
  TOP w0.089: v3(73.27,102.9) 73.82,102.34 T0709.1
  BOTTOM w0.102: v3(73.27,102.9) 73.47,102.7 74.27,102.7 U0300.BR1
RSVD_TP11: length 2.3
  TOP w0.089: v3(73.91,103.51) 74.69,104.3 T0710.1
  BOTTOM w0.102: U0300.BT2 74.39,103.73 74.15,103.51 v3(73.91,103.51)
RSVD_TP12: length 16.7
  BOTTOM w0.102: U0300.D1 113.02,103.14 113.24,102.93 117.38,102.93 117.85,103.4 120.44,103.4 120.74,103.1 120.74,102.67 121.27,102.14 121.73,102.14 123.15,100.72 123.15,99.32 124.29,98.18 T0702.1
RSVD_TP13: length 11.5
  TOP w0.102: T0704.1 119.23,100.92 v2(119.23,102.17)
  BOTTOM w0.102: U0300.E1 112.24,103.22 112.93,102.52 118.88,102.52 v2(119.23,102.17)
RSVD_TP14: length 9
  BOTTOM w0.102: T0706.1 119.96,103.2 117.94,103.2 117.46,102.73 113.1,102.73 112.58,103.24 112.58,103.62 112.54,103.66 U0300.E2
RSVD_TP36: length 4.4
  TOP w0.089: T0730.1 73.18,112.43 73.18,113.87 v3(73.49,114.18)
  BOTTOM w0.102: U0300.BR17 75.03,114.56 74.65,114.18 v3(73.49,114.18)
RSVD_TP40: length 2.5
  TOP w0.089: T0729.1 73.01,114.03 73.01,114.26 v3(73.53,114.78)
  BOTTOM w0.102: U0300.BT17 73.74,114.56 v3(73.53,114.78)
RTC_IN#: length 6.2
  TOP w0.102: v1(251.21,61.5) v2(251.21,60.86) 250.21,61.87 SR2101.1 250.68,62.66 250.68,63.74 250.83,63.89 Q2801.3
  BOTTOM w0.102: v2(251.21,60.86) 250.75,61.32 250.63,61.32 R2804.1
RTCRST#: length 272.6
  TOP w0.121: v2(255.17,69.83) 255.17,69.81 255.53,69.45 259.8,69.45 260.64,70.29 266.35,70.29 v2(271.99,64.65) 272.47,65.13 273.23,65.13 273.51,64.85 273.51,63.71 273.02,63.22 273.02,62.68 271.99,61.65 271.99,54.67 v1(272.22,54.44) 273.03,53.63 v2(273.03,53.42)
  IN2 w0.083: v2(98.91,14.84) 99.84,15.77 107.98,15.77 108.38,15.37 124.14,15.37 125.69,13.82 144.43,13.82 146.97,16.36 165.39,16.36 167,17.97 194.66,17.97 196.29,16.34 208.14,16.34 210.57,18.77 210.57,19.26 210.68,19.37 215.38,19.37 217,20.99 226.42,20.99 227.41,21.98 234.78,21.98 234.85,21.9 239.21,21.9 239.94,22.63 241.46,22.63 248.42,29.59 253.91,29.59 255.07,30.76 260.94,30.76 263.07,28.62 266.82,28.62 268.52,30.32 268.52,34.74 272.55,38.78 272.55,39.82 275.19,42.45 v2(275.49,42.45)
  IN3 w0.083: v2(275.49,42.45) 276.77,43.73 276.77,46.08 277.89,47.2 277.89,50.62 277.59,50.92 277.59,51.25 275.41,53.42 v2(273.03,53.42)
  BOTTOM w0.089: U2000.BC10 238.28,65.14 238.78,65.14 238.81,65.17 239.75,65.17 239.77,65.15
  BOTTOM w0.102: 240.77,65.64 240.28,65.15 239.77,65.15
  BOTTOM w0.121: v2(98.91,14.84) 98.91,14.92 97.54,16.29 95.68,16.29 R2801.1 ; v2(271.99,64.65) 271.99,64.32 272.27,64.04 C2828.1 272.57,64.35 272.45,64.47 272.45,64.93 272.57,65.06 R2812.2 ; v2(255.17,69.83) 254.74,69.83 252.88,67.97 252.25,67.97 251.46,68.76 247.12,68.76 246.98,68.62 246.97,68.62 246.29,68.62 244.51,66.84 243.89,66.84 243.71,66.66 242.17,66.66 241.15,65.64 240.77,65.64
RTCX1_NO_IO: length 8.8
  BOTTOM w0.089: U2000.BC9 238.16,65.64 238.79,65.64 238.88,65.55 239.72,65.55 239.75,65.58 239.89,65.58
  BOTTOM w0.121: 239.89,65.58 240.12,65.81 240.12,66.68 240.39,66.95 240.39,67.16 241.69,68.46 241.69,68.77 241.99,69.07 v1(241.99,69.3) 242.56,69.87 R2523.1 243.25,69.87 243.45,69.67 R2525.2
RTCX2_NO_IO: length 10.7
  BOTTOM w0.089: U2000.BD10 238.77,65.39 238.8,65.36 239.88,65.36
  BOTTOM w0.121: 239.88,65.36 239.98,65.36 240.34,65.72 240.34,66.53 240.6,66.78 240.91,66.78 241.77,67.65 v1(242.78,67.65) 242.78,68.08 242.58,68.28 242.58,68.64 R2523.2 243.3,69.01 243.36,68.94 C2501.1 245.16,68.94 245.65,69.43 Y2500.4
RTD3_CIO_PWR_EN: length 11.1
  TOP w0.102: v2(294.42,50.22) 294.42,50.02 294.82,49.61 296.42,49.61 296.58,49.77 R1130.1 297.24,49.36 297.24,46.03 297.21,46 U1101.F1
  BOTTOM w0.102: v2(294.42,50.22) 294.42,49.74 293.81,49.13 292.87,49.13 292.56,49.44 292,49.44 v1(291.67,49.11)
RTD3_USB_PWR_EN: length 1.9
  TOP w0.102: U1101.D4 298.35,44.65 298.05,44.35 v5(298.02,44.35)
  BOTTOM w0.102: R1134.1 298.15,43.26 298.13,43.29 R1110.1 298.13,44.25 v5(298.02,44.35)
RTN_A: length 5.7
  TOP w0.254: v2(56.57,179.53) 56.21,179.89 54.92,179.89 v1(53.94,180.87) 53.4,181.41 SR8013.2
  BOTTOM w0.152: U8000.18 v2(56.57,179.53)
RTN_B: length 3.8
  BOTTOM w0.203: R8027.2 62.36,184.21 60.89,184.21 v1(60.51,183.83) 60.43,183.74 U8000.6
S3: length 7.6
  TOP w0.102: U8300.7 27.31,47.1 27.33,47.08 C8319.1 26.9,45.96 26.9,45.26 27.08,45.09 27.08,44.59 R8305.2 ; R8305.2 26.35,44.3 v1(26.3,44.36) ; R8305.2 27.36,43.24 27.01,42.88 D8300.1
S5: length 11.9
  TOP w0.102: D8301.1 31.4,42.88 31.63,43.11 32.47,43.95 32.98,43.95 R8307.2 v1(33.33,45.32) 31.2,45.32 30.82,44.94 29.19,44.94 28.96,45.17 28.96,45.65 28.96,45.65 28.95,45.65 28.43,46.18 28.43,46.18 C8322.1 27.71,46.9 U8300.8
SATA_A_DE: length 8
  TOP w0.102: v1(39.33,16.09) 39.33,16.52 v2(39.5,16.69) 39.91,17.1 40.9,17.1 42.03,15.98 U1501.9
  BOTTOM w0.102: R1505.2 R1512.2 37.65,17.25 38.94,17.25 v2(39.5,16.69)
SATA_A_EQ1: length 7.3
  TOP w0.102: R1506.2 37.46,11.34 38.22,11.34 R1507.2 39.02,11.37 39.02,11.13 39.65,10.5 40.86,10.5 v1(41.03,10.68) 41.27,10.92 41.86,10.92 42.53,11.59 U1501.18
SATA_A_EQ2: length 7.7
  TOP w0.102: U1501.19 43.03,11.6 43.26,11.36 43.97,11.36 44.05,11.28 45.95,11.28 46.31,10.93 46.31,10.5 R1516.2 47.15,9.66 47.66,9.66 v1(48.11,9.2) 48.11,9.94 R1502.2
SATA_B_DE: length 8
  TOP w0.102: U1501.8 42.53,16.39 43.64,17.51 44.48,17.51 v2(45.35,16.64)
  BOTTOM w0.102: v2(45.35,16.64) 45.35,16.57 R1513.2 44.81,15.7 44.94,15.58 46.44,15.58 R1504.2
SATA_B_EQ1: length 5.2
  TOP w0.102: U1501.20 43.95,11.9 44.13,11.72 v1(45.32,11.72) 46.23,11.72 R1517.2 46.97,11.85 47.76,11.85 R1501.2
SATA_B_EQ2: length 9.2
  TOP w0.102: v1(36.13,13.95) 36.68,13.95 37.04,13.6 R1503.2 37.45,13.42 38.23,13.42 R1511.2 38.67,12.55 39.22,12 39.22,11.28 39.68,10.83 40.54,10.83 40.95,11.23 41.66,11.23 42.03,11.6 U1501.17
SATA_DEVSLP0: length 222.5
  TOP w0.102: v2(36.89,29.24) 36.25,29.88 SR5102.1
  IN1 w0.102: v2(36.89,29.24) 36.84,29.19 36.84,27.39 37.39,26.84 39.36,26.84 42.93,23.27 69.8,23.27 71.38,24.85 111.94,24.85 113.13,26.04 116.07,26.04 119.17,29.14 128.01,29.14 128.56,28.58 140.57,28.58 143.41,25.75 201.96,25.75 204.65,28.45 204.65,32.96 209.78,38.09 209.78,39.62 210.98,40.82 210.98,42.18 211.73,42.93 228.83,42.93 v2(230.05,41.7)
  BOTTOM w0.089: U2000.AG42 229.66,49.23 229.66,48.28 229.67,48.27 229.67,48.01 229.52,47.86 229.52,47.45
  BOTTOM w0.102: 229.52,47.45 229.52,47.38 229.5,47.35 v1(229.5,44.66) 230.13,44.03 R2157.2 229.8,43.77 229.72,43.7 229.72,42.37 229.75,42.35 229.75,42.01 v2(230.05,41.7)
SATA_LED#: length 5
  TOP w0.102: v2(93.71,186.34) R5603.2 92.82,185.66 93.17,185.3 D5601.3
  BOTTOM w0.102: v2(93.71,186.34) 93.71,185.88 93.25,185.43 CON5602.24
SATA_LED#_LED: length 10.1
  TOP w0.102: v1(233.94,191.24) 233.55,190.85 231.92,190.85
  TOP w0.114: CON1.2 235.45,190.57 235.21,190.33 234.88,190.33 233.97,191.24 v1(233.94,191.24) ; LC803.1 229.75,191.96 229.95,191.75 229.95,191.07 230.17,190.85 LQ803.2 231.92,190.85
SATA_LED_LED: length 3.8
  TOP w0.102: LR804.2 227.16,190.73 v1(227.16,190)
  TOP w0.114: LQ803.6 228.13,190.2 LR804.2 227.86,190.95 227.96,190.85 LQ803.5
SATA_RXN1: length 237.5
  IN4 w0.114: v2(16.06,28.86) 16.24,29.04 16.24,29.32 16.54,29.62 17.2,29.62 17.62,29.2 17.62,28.41 17,27.79 16.77,27.79 16.29,27.31 16.29,25.84 16.58,25.55 18.06,25.55 18.19,25.41 19.05,25.41 20.28,24.19 26.27,24.19 27.07,23.39 36.85,23.39 37.28,23.82 51.53,23.82 51.92,23.43 88.17,23.43 89.49,22.11 116.49,22.11 119.02,24.63 121.18,24.63 121.83,23.98 141.31,23.98 143.49,21.8 162.74,21.8 164.12,23.17 170.87,23.17 171.29,23.59 175.54,23.59 175.76,23.38 176.49,23.38 177.1,22.77 179.86,22.77 180.31,23.21 193.12,23.21 200.07,30.15 203.66,30.15 205.99,32.48 207.16,32.48 213.72,39.05 213.72,42.58 214.41,43.26 217.73,43.26 218.88,44.41 218.88,44.56 221.74,47.42 221.74,50.82 221.28,51.28 220.47,51.28 220.07,51.68 v2(219.72,51.68)
  BOTTOM w0.133: U2000.D39 219.49,51.68 v2(219.72,51.68) ; C5122.1 16.62,28.33 16.08,28.86 v2(16.06,28.86)
SATA_RXN2: length 206.1
  TOP w0.121: 50.25,16.21 50.25,15.48 49.99,15.22 48.03,15.22 47.78,14.97 C1507.2 ; 50.25,16.21 v1(50.46,16.21) ; 50.25,16.21 50.25,24.14 52.28,26.17 53,26.17 53.2,25.97 53.2,25.75 v2(52.91,25.46)
  IN4 w0.102: v2(52.91,25.46) 53.1,25.27 53.1,24.41 53.57,23.93 90.25,23.93 91.26,22.93 111.73,22.93 112.64,23.85 117.37,23.85 118.65,25.13 126.19,25.13 126.45,24.87 141.2,24.87 142.75,23.32 162.94,23.32 164.12,24.5 176.4,24.5 177.64,23.26 179.32,23.26 180.56,24.5 185.21,24.5 186.01,23.71 192.93,23.71 199.86,30.64 203.46,30.64 211.5,38.69 211.5,39.91 211.99,40.41 211.99,42.37 213.21,43.59 216.69,43.59 218.04,44.94 218.62,44.94 220.97,47.29 220.97,49.17 219.92,50.22 219.92,50.75 v2(220.07,50.91)
  BOTTOM w0.121: v2(220.07,50.91) 219.62,50.45 U2000.F41
SATA_RXN2_C: length 3.9
  TOP w0.121: U1501.4 44.63,14.17 44.73,14.28 45.73,14.28 ; v1(45.73,14.06) 45.73,14.28 ; 45.73,14.28 46.2,14.28 46.44,14.51 46.44,14.96 46.64,15.16 46.83,15.16 46.92,15.07 C1507.1
SATA_RXN2_CON: length 13
  TOP w0.121: C1510.1 30.54,13.1 30.32,13.32 28.78,13.32 v2(28.43,12.96)
  BOTTOM w0.121: v2(28.43,12.96) 27.7,13.69 27.7,15.9 27.41,16.19 23.08,16.19 22.61,15.72 22.61,14.86 22.75,14.72 CON5100.16
SATA_RXN2_CON_C: length 12.1
  TOP w0.121: 32.47,14.05 32.47,14.41 33.2,15.14 33.53,15.14 33.86,15.47 36.73,15.47 37.17,15.91 38.41,15.91 39.95,14.37 40.12,14.37 40.31,14.17 U1501.12 ; 32.47,14.05 v1(32.7,14.05) ; 32.47,14.05 32.47,13.51 32.22,13.27 31.86,13.27 C1510.2
SATA_RXN2_PASS: length 23.3
  TOP w0.121: R1518.2 29.11,12.81 v2(29.06,12.86) ; C1501.1 49.18,14.71 v2(49.23,14.66)
  IN1 w0.102: v2(49.23,14.66) 49.23,15.07 49.1,15.2 48.83,15.2 47.43,13.8 38.92,13.8 38.37,14.35 31.9,14.35 30.83,13.28 29.48,13.28 v2(29.06,12.86)
SATA_RXN3: length 197.7
  IN4 w0.114: v2(56.11,24.96) 56.76,25.61 58.76,25.61 59.34,25.03 117.02,25.03 118.23,26.23 141.52,26.23 142.85,24.91 163.05,24.91 163.68,25.55 185.72,25.55 185.98,25.29 190.37,25.29 190.77,25.69 193.42,25.69 199.43,31.69 203.02,31.69 209.42,38.09 209.42,39.85 210.89,41.32 210.89,42.92 212.49,44.52 216.02,44.52 217.84,46.34 218.6,46.34 219.79,47.53 219.79,48.72 v2(219.46,49.05)
  BOTTOM w0.133: C5170.1 42.8,17.17 42.8,17.86 43.57,18.63 51.12,18.63 56.55,24.06 56.55,24.53 v2(56.11,24.96) ; U2000.D43 219.2,48.8 v2(219.46,49.05)
SATA_RXN3_C: length 2.1
  BOTTOM w0.133: C5170.2 42.7,15.76 42.7,15.43 42.25,14.97 CON5104.43
SATA_RXN4_C: length 2.3
  BOTTOM w0.133: C5122.2 18.41,28.58 19.27,28.58 19.39,28.45 CON5103.43
SATA_RXP1: length 237.5
  IN4 w0.114: v2(219.72,52.29) 219.98,52.02 220.21,52.02 220.61,51.62 221.42,51.62 222.08,50.96 222.08,47.27 219.22,44.41 219.22,44.27 217.87,42.92 214.55,42.92 214.06,42.44 214.06,38.9 207.3,32.14 206.13,32.14 203.8,29.81 200.21,29.81 193.26,22.87 180.45,22.87 180,22.42 176.95,22.42 176.34,23.03 175.61,23.03 175.4,23.25 171.43,23.25 171.02,22.83 164.26,22.83 162.89,21.46 143.35,21.46 141.17,23.64 121.69,23.64 121.04,24.29 119.16,24.29 116.63,21.76 89.35,21.76 88.03,23.08 51.78,23.08 51.39,23.48 37.42,23.48 36.99,23.04 26.93,23.04 26.13,23.85 20.14,23.85 18.91,25.07 18.05,25.07 17.92,25.2 16.44,25.2 15.94,25.7 15.94,27.45 16.63,28.14 16.86,28.14 17.28,28.56 17.28,29.06 17.06,29.28 16.68,29.28 16.58,29.18 16.58,29 v2(16.72,28.86)
  BOTTOM w0.133: C5121.1 16.85,29.22 16.72,29.09 v2(16.72,28.86) ; v2(219.72,52.29) 219.34,52.29 219.16,52.11 U2000.E37
SATA_RXP2: length 205.8
  TOP w0.121: v2(53.68,25.46) 53.44,25.7 53.44,26.06 53.1,26.4 52.18,26.4 50.02,24.24 50.02,15.58 49.89,15.45 47.86,15.45 47.78,15.53 C1503.2
  IN4 w0.102: v2(219.44,50.91) 219.7,50.64 219.7,50.13 220.76,49.08 220.76,47.38 218.54,45.16 217.95,45.16 216.6,43.81 213.12,43.81 211.78,42.46 211.78,40.49 211.28,40 211.28,38.78 203.37,30.86 199.77,30.86 192.84,23.92 186.1,23.92 185.3,24.71 180.47,24.71 179.23,23.48 177.73,23.48 176.49,24.71 164.03,24.71 162.85,23.54 142.84,23.54 141.29,25.09 126.54,25.09 126.28,25.34 118.56,25.34 117.28,24.06 112.55,24.06 111.64,23.15 91.35,23.15 90.34,24.15 53.66,24.15 53.32,24.5 53.32,25.36 53.41,25.46 v2(53.68,25.46)
  BOTTOM w0.121: U2000.E41 219.1,50.57 v2(219.44,50.91)
SATA_RXP2_C: length 3.7
  TOP w0.121: U1501.5 44.65,14.67 44.81,14.51 46.11,14.51 46.2,14.61 46.2,15.06 46.92,15.77 C1503.1
SATA_RXP2_CON: length 13.2
  TOP w0.121: v2(28.44,13.57) 28.67,13.57 28.69,13.55 30.39,13.55 30.54,13.7 C1511.1
  BOTTOM w0.121: CON5100.15 22.25,14.72 22.38,14.85 22.38,15.82 22.98,16.42 27.51,16.42 27.94,16 27.94,13.79 28.15,13.57 v2(28.44,13.57)
SATA_RXP2_CON_C: length 12.1
  TOP w0.121: U1501.11 40.27,14.67 40.2,14.6 40.05,14.6 38.51,16.14 37.07,16.14 36.63,15.7 36.15,15.7 ; 36.15,15.7 v1(36.15,15.93) ; 36.15,15.7 33.76,15.7 33.43,15.37 33.1,15.37 32.23,14.5 32.23,13.61 32.12,13.5 31.95,13.5 C1511.2
SATA_RXP2_PASS: length 23.3
  TOP w0.121: v2(29.06,14.05) R1510.2 ; C1502.1 v2(49.22,15.96)
  IN1 w0.102: v2(49.22,15.96) 49.22,15.51 49.12,15.42 48.74,15.42 47.34,14.02 39.01,14.02 38.46,14.57 31.81,14.57 30.74,13.49 29.62,13.49 v2(29.06,14.05)
SATA_RXP3: length 197.8
  IN4 w0.114: v2(219.44,49.71) 220.14,49.02 220.14,47.39 218.74,45.99 217.98,45.99 216.16,44.18 212.63,44.18 211.23,42.78 211.23,41.18 209.76,39.71 209.76,37.94 203.16,31.35 199.57,31.35 193.57,25.34 190.91,25.34 190.51,24.94 185.84,24.94 185.58,25.2 163.82,25.2 163.19,24.57 142.7,24.57 141.38,25.89 118.37,25.89 117.17,24.68 59.2,24.68 58.62,25.27 57.13,25.27 v2(56.83,24.97)
  BOTTOM w0.133: v2(56.83,24.97) 56.83,23.94 51.24,18.35 43.69,18.35 43.08,17.74 43.08,17.1 C5169.1 ; v2(219.44,49.71) 219.08,49.36 U2000.E42
SATA_RXP3_C: length 2.1
  BOTTOM w0.133: CON5104.41 42.75,15.07 42.99,15.31 42.99,15.63 C5169.2
SATA_RXP4_C: length 2.3
  BOTTOM w0.133: CON5103.41 19.42,28.95 19.34,28.86 18.52,28.86 C5121.2
SATA_SSD_LED#: length 202.6
  TOP w0.102: v2(68.28,129.83) 63.18,129.83 61.78,131.22 v1(61.07,131.22) 60.48,131.22 v2(60.2,130.94) ; D5601.2 96.64,185.95 97.14,185.45 v2(97.14,184.51) ; SR5105.1 v2(34.14,37.32)
  IN2 w0.102: v2(34.14,37.32) 33.71,37.32 32.72,38.31 32.72,39.12 31.65,40.19 31.65,46.26 33.76,48.37 33.76,70.78 40.67,77.69 40.67,86.93 40.38,87.23 40.38,102.18 48.72,110.53 54.07,110.53 57.46,113.92 57.46,123.04 60.54,126.13 60.54,130.6 v2(60.2,130.94) ; v2(97.14,184.51) 97.14,183.12 95.61,181.59 93.81,181.59 91.52,183.88 87.18,183.88 84.76,181.45 81.75,181.45 75.7,175.4 75.7,171.17 75.29,170.76 75.29,157.61 74.58,156.9 74.58,152.13 73.2,150.75 73.2,144.77 71.13,142.7 67.42,142.7 66.43,141.72 66.43,135.4 68.28,133.54 v2(68.28,129.83)
SATA_TXN1: length 218.3
  IN4 w0.114: v6(213.34,50.59) 213.14,50.39 213.14,50.25 212.88,49.99 211.92,49.99 211.78,50.13 209.21,50.13 207.74,48.66 207.12,48.66 204.05,45.58 204.05,44.99 197.9,38.84 197.6,38.84 195.39,36.63 194.98,36.63 191.59,33.25 190.98,33.25 189.8,32.06 162.1,32.06 161.37,32.79 146.01,32.79 145.21,33.6 138.63,33.6 137.07,35.16 131.45,35.16 131.13,35.48 123.92,35.48 123.38,34.94 112.59,34.94 109.68,32.04 53.55,32.04 52.86,31.35 48.34,31.35 48.09,31.6 34.65,31.6 34.4,31.35 32.29,31.35 30.78,29.84 30.78,27.88 28.51,25.61 20.15,25.61 18.74,27.02 17.11,27.02 v2(16.85,27.29)
  BOTTOM w0.089: 217.08,51.57 217.14,51.5 217.63,51.5 217.7,51.57 U2000.B38
  BOTTOM w0.133: v6(213.34,50.59) 213.34,50.88 213.53,51.08 214.63,51.08 215.12,51.57 217.08,51.57 ; v2(16.85,27.29) 16.85,27.16 16.91,27.09 17.14,27.09 C5123.1
SATA_TXN2: length 200
  TOP w0.121: v2(53.91,30.28) 53.91,27.79 54.84,26.86 54.84,25.33 51.29,21.78 51.29,14.38 50.53,13.63 50.12,13.63 ; v1(50.12,13.85) 50.12,13.63 ; 50.12,13.63 49.76,13.63 49.35,13.22 47.9,13.22 47.78,13.33 R1509.2
  IN4 w0.102: v2(216.39,50.6) 216.2,50.41 216.2,50.14 214.42,48.36 212.57,48.36 212.43,48.22 210.01,48.22 208.55,46.76 207.89,46.76 205.93,44.8 205.93,43.61 199.26,36.94 198.36,36.94 196.6,35.18 196.6,34.07 192.31,29.77 159.24,29.77 158.11,30.9 141.93,30.9 141.15,31.68 124.49,31.68 123.95,32.23 120.01,32.23 119.41,32.82 113.19,32.82 109.82,29.46 54.48,29.46 54.16,29.78 54.16,30.21 54.08,30.28 v2(53.91,30.28)
  BOTTOM w0.102: v2(216.39,50.6) 216.61,50.82 217.07,50.82 217.09,50.81 217.51,50.81 217.72,51.01 U2000.B39
SATA_TXN2_C: length 3
  TOP w0.121: U1501.2 44.65,13.17 44.79,13.04 45.5,13.04 45.65,13.19 46.41,13.19 C1509.1
SATA_TXN2_CON: length 11.9
  TOP w0.121: v2(28.49,11.58) 28.66,11.41 30.38,11.41 30.54,11.56 C1506.1
  BOTTOM w0.121: v2(28.49,11.58) 28.39,11.58 28.05,11.92 28.05,12.43 27.2,13.28 27.2,15.34 26.88,15.66 24.09,15.66 23.75,15.32 CON5100.18
SATA_TXN2_CON_C: length 12.6
  TOP w0.121: v1(34.63,14.84) 34.63,14.61 ; 34.63,14.61 34.37,14.61 32.74,12.98 32.74,11.66 32.55,11.47 31.86,11.47 31.81,11.51 31.81,11.51 C1506.2 ; 34.63,14.61 35.69,14.61 35.85,14.77 37.34,14.77 37.82,14.29 39.02,14.29 40.2,13.1 40.36,13.1 40.43,13.17 U1501.14
SATA_TXN2_PASS: length 24
  TOP w0.121: v2(49.28,13.77) 49.11,13.94 48.87,13.94 R1509.1 ; C1515.2 29.11,11.92 v2(29.06,11.87)
  IN1 w0.102: v2(29.06,11.87) 29.37,11.56 30.66,11.56 32.77,13.67 37.8,13.67 39.17,12.3 47.1,12.3 48.01,13.22 49.11,13.22 49.28,13.39 v2(49.28,13.77)
SATA_TXN3: length 195.6
  IN4 w0.114: v2(58.45,30.21) 58.11,30.55 58.11,30.68 58.23,30.79 110.16,30.79 112.9,33.53 123.76,33.53 124.01,33.28 135.82,33.28 136.71,32.39 141.71,32.39 142.49,31.61 160.88,31.61 161.61,30.88 191.59,30.88 192.56,31.85 192.56,32.55 195.47,35.45 195.88,35.45 198.07,37.64 198.95,37.64 205.23,43.92 205.23,45.09 207.6,47.47 208.23,47.47 209.69,48.93 213.95,48.93 214.41,49.38 214.53,49.38 v2(214.7,49.55)
  BOTTOM w0.133: v2(58.45,30.21) 58.05,29.81 58.05,29.3 55.02,26.26 55.02,24.83 49.52,19.33 43.36,19.33 41.34,17.31 41.34,17.15 C5172.1 ; U2000.A41 217.39,50.12 217.3,50.21 217.01,50.21 216.68,49.89 215.04,49.89 v2(214.7,49.55)
SATA_TXN3_C: length 2
  BOTTOM w0.133: C5172.2 41.29,15.64 41.29,15.11 41.25,15.07 CON5104.47
SATA_TXN4_C: length 2.1
  BOTTOM w0.133: CON5103.47 19.37,27.45 19.13,27.21 18.52,27.21 C5123.2
SATA_TXP1: length 218.3
  IN4 w0.114: v2(16.85,26.68) 18.6,26.68 20.01,25.27 28.65,25.27 31.12,27.74 31.12,29.7 32.43,31.01 34.54,31.01 34.79,31.26 47.95,31.26 48.2,31.01 53,31.01 53.69,31.69 109.83,31.69 112.73,34.6 123.53,34.6 124.06,35.14 130.99,35.14 131.31,34.82 136.93,34.82 138.49,33.26 145.06,33.26 145.87,32.45 161.23,32.45 161.96,31.72 189.94,31.72 191.12,32.91 191.73,32.91 195.12,36.29 195.53,36.29 197.74,38.5 198.04,38.5 204.39,44.85 204.39,45.44 207.26,48.32 207.88,48.32 209.36,49.79 211.64,49.79 211.78,49.65 213.02,49.65 213.67,50.3 213.79,50.3 v2(214.06,50.58)
  BOTTOM w0.089: 217.14,51.28 217.19,51.32 218.07,51.32 U2000.C38
  BOTTOM w0.133: v2(16.85,26.68) 17,26.52 C5124.1 ; v2(214.06,50.58) 214.28,50.79 214.75,50.79 215.24,51.28 217.14,51.28
SATA_TXP2: length 200
  TOP w0.121: 51.52,14.61 51.52,14.29 50.63,13.39 49.86,13.39 49.44,12.98 47.88,12.98 47.78,12.88 R1508.2 ; 51.52,14.61 51.52,21.68 55.07,25.23 55.07,26.96 54.14,27.89 54.14,29.78 v2(54.64,30.28) ; 51.52,14.61 v1(51.74,14.61)
  IN4 w0.102: v2(215.78,50.6) 215.99,50.4 215.99,50.23 214.33,48.57 212.48,48.57 212.34,48.43 209.92,48.43 208.46,46.97 207.8,46.97 205.72,44.89 205.72,43.7 199.17,37.15 198.27,37.15 196.39,35.27 196.39,34.16 192.22,29.99 159.33,29.99 158.2,31.12 142.02,31.12 141.24,31.9 124.58,31.9 124.04,32.44 120.1,32.44 119.5,33.04 113.1,33.04 109.73,29.67 54.57,29.67 54.38,29.86 54.38,30.22 54.44,30.28 v2(54.64,30.28)
  BOTTOM w0.102: U2000.A39 217.33,51.01 216.19,51.01 v2(215.78,50.6)
SATA_TXP2_C: length 2.9
  TOP w0.121: C1508.1 46.47,12.95 45.75,12.95 45.6,12.8 44.76,12.8 44.63,12.67 U1501.1
SATA_TXP2_CON: length 11.9
  TOP w0.121: v2(28.43,10.85) 28.61,11.03 28.75,11.18 30.04,11.18 C1514.1
  BOTTOM w0.121: v2(28.43,10.85) 28.07,11.21 28.07,11.56 27.81,11.82 27.81,12.33 26.97,13.18 26.97,15.24 26.78,15.42 24.19,15.42 23.98,15.22 23.98,14.84 24.25,14.57 CON5100.19
SATA_TXP2_CON_C: length 12.7
  TOP w0.121: v1(32.52,11.01) 32.52,11.23 ; 32.52,11.23 31.96,11.23 C1505.2 ; 32.52,11.23 32.65,11.23 32.98,11.56 32.98,12.88 34.47,14.38 35.79,14.38 35.94,14.53 37.25,14.53 37.72,14.05 38.92,14.05 40.3,12.67 U1501.15
SATA_TXP2_PASS: length 23.9
  TOP w0.121: v2(29.06,10.68) C1514.2 ; R1508.1 v2(49.22,12.48)
  IN1 w0.102: v2(49.22,12.48) 49.22,12.93 49.15,13 48.1,13 47.19,12.08 39.08,12.08 37.71,13.46 32.86,13.46 30.75,11.35 29.74,11.35 v2(29.06,10.68)
SATA_TXP3: length 195.7
  IN4 w0.114: v2(57.77,30.24) 57.77,30.82 58.08,31.13 110.02,31.13 112.75,33.87 123.9,33.87 124.15,33.62 135.96,33.62 136.85,32.74 141.85,32.74 142.63,31.95 161.03,31.95 161.76,31.22 191.45,31.22 192.22,32 192.22,32.69 195.32,35.8 195.73,35.8 197.92,37.99 198.81,37.99 204.88,44.06 204.88,45.24 207.46,47.81 208.08,47.81 209.54,49.27 213.81,49.27 v2(214.71,50.17)
  BOTTOM w0.133: C5171.1 41.05,17.13 41.05,17.43 43.24,19.62 49.41,19.62 54.74,24.95 54.74,26.38 57.77,29.42 v2(57.77,30.24) ; U2000.A40 216.89,50.5 216.56,50.17 v2(214.71,50.17)
SATA_TXP3_C: length 2.1
  BOTTOM w0.133: CON5104.49 40.75,15.05 41,15.3 41,15.75 C5171.2
SATA_TXP4_C: length 2.1
  BOTTOM w0.133: C5124.2 18.72,26.92 19.25,26.92 19.28,26.95 CON5103.49
SBU1: length 40.8
  TOP w0.102: CON1201.A8 317.29,33.8 317.18,33.69 314.14,33.69 313.66,34.17 312.58,34.17 312.1,33.69 v2(312.1,32.77) ; SR1204.2 302.25,56.58 v2(302.52,56.58) ; v2(307.24,33.28) 307.24,33.23 v1(308.01,32.47)
  IN4 w0.102: v2(302.52,56.58) 302.82,56.28 302.82,54.92 305.1,52.64 305.1,44.48 305.52,44.06 305.52,41.6 307.89,39.22 307.89,33.93 v2(307.24,33.28)
  BOTTOM w0.102: v2(312.1,32.77) 312.04,32.83 U1208.9 U1208.2 307.69,32.83 v2(307.24,33.28)
SBU2: length 49.5
  TOP w0.102: SR1205.2 301.44,56.5 v2(301.73,56.5) ; v1(308.08,36.53) 307.44,37.18 v2(306.96,37.18)
  IN2 w0.102: CON1201.B8 320.98,33.03 320.99,33.03 arc(321.39,33.63) 321.53,34.34 321.53,37.6 320.3,38.83 309.62,38.83 307.97,37.18 v2(306.96,37.18)
  IN4 w0.102: v2(301.73,56.5) 301.96,56.5 302.61,55.85 302.61,54.84 304.81,52.65 304.81,44.36 305.32,43.85 305.32,41.51 307.69,39.14 307.69,37.51 307.36,37.18 v2(306.96,37.18)
  BOTTOM w0.102: v2(306.96,37.18) 308,37.18 308.22,36.96 U1207.9 U1207.2
SCLK: length 3.3
  TOP w0.121: v1(57.16,187.94) 57.37,187.73 v2(57.37,187.08)
  BOTTOM w0.121: R8012.1 57.37,188.01 v2(57.37,187.08) U8000.45
SDA: length 2
  BOTTOM w0.121: R8014.1 56.32,187.8 56.32,187.1 56.57,186.85 U8000.43
SDATA_IN_R: length 2.9
  TOP w0.121: U3600.8 9.34,26.22 10.06,25.5 v1(10.06,25.2) R3613.2
SDO: length 5.1
  TOP w0.102: U5800.1 301.75,130.86 R5802.1 R5801.1 299.45,130.21 v1(299.27,130.03)
SHUT_DOWN#: length 7
  BOTTOM w0.102: U7413.1 145.66,57.15 144.81,58 144.28,58 143.37,58.91 D7404.2 143.01,59.97 142.24,60.74 v1(141.11,60.74)
SLEW_CTL: length 6.6
  TOP w0.102: U1301.34 297.6,86.54 v2(297.29,86.85) 297.29,88.6 297.69,89.01 298,89.01 R1331.1 298.88,89.66 v1(298.88,88.78)
  BOTTOM w0.102: v2(297.29,86.85) 297.34,86.85 R1330.2
SLP_S5#: length 72.8
  TOP w0.102: SR2403.1 v1(244.2,71.36) 243.83,71.73 241.47,71.73 241.23,71.97 241.23,73.27 241.42,73.46 241.59,73.46 243.6,75.47 243.6,76.57 243.03,77.14 243.03,78.44 v2(243.47,78.87) ; v2(294.24,95.61) 294.36,95.5 Q5301.1
  IN1 w0.102: v2(294.24,95.61) 293.6,94.98 289.67,94.98 288.78,94.09 287.64,94.09 286.37,92.82 281.41,92.82 279.76,91.17 277.6,91.17 276.74,92.03 276.38,92.03 273.13,88.78 267.82,88.78 266.09,87.05 261.88,87.05 257.46,82.63 257.46,81.59 255.23,79.36 243.95,79.36 v2(243.47,78.87)
SLP_WLAN#: length 71.6
  TOP w0.102: v2(290.73,97.06) 291.52,96.27 291.52,95.21 291.16,94.84 Q5302.1 290.63,94.55 290.56,94.47 v1(289.92,94.47) ; SR2404.1 242.07,70.22 242.07,71.15 241.73,71.49 241.42,71.49 241.03,71.89 241.03,73.36 241.34,73.66 241.51,73.66 243.06,75.22 v2(243.06,75.75)
  IN3 w0.102: v2(290.73,97.06) 289.36,97.06 288.02,98.41 285.31,98.41 280.25,93.35 276.99,93.35 275.11,91.48 275.11,90.25 273.26,88.4 270.66,88.4 269.21,86.95 261.3,86.95 257.13,82.79 257.13,82.44 257.13,80.5 254.51,77.87 250.24,77.87 248.76,76.4 243.71,76.4 v2(243.06,75.75)
SM_RCOMP0: length 9.8
  BOTTOM w0.254: U0300.G1 111.43,103.33 112.92,101.84
  BOTTOM w0.305: R0504.2 119.18,101.07 118.42,101.84 112.92,101.84
SM_RCOMP1: length 16.6
  BOTTOM w0.305: U0300.H1 110.57,102.87 112.44,101 117.71,101 119.56,99.14 R0506.2 120.4,99.02 120.78,98.64 122.65,98.64 123.17,98.11 123.17,97.57 v1(122.54,96.93)
SM_RCOMP2: length 15.3
  BOTTOM w0.254: U0300.J2 110.14,103.91 110.14,102.61 110.36,102.4
  BOTTOM w0.305: 110.36,102.4 112.27,100.49 117.48,100.49 119.94,98.03 R0507.1 120.58,96.78 v1(120.73,96.63)
SMB0_CLK: length 159.2
  TOP w0.121: SR3010.1 R3071.2 167.52,25.74 168.15,25.74 168.45,25.53 168.45,24.71 168,24.26 v2(168,23.97) ; SR8802.1 260.56,34.86 260.13,35.29 v2(260.13,35.77)
  IN2 w0.083: v2(260.13,35.77) 260.27,35.62 260.27,35.58 260.55,35.31 260.93,35.31 262.36,36.74 262.36,37.32 262.76,37.72 264.15,37.72 264.85,37.02 266.72,37.02 269.12,39.41 269.12,40.78 v2(273.23,44.9)
  IN3 w0.083: v2(168,23.97) 168,24.04 168.4,24.43 168.57,24.43 169.14,25.01 185.06,25.01 185.99,24.08 185.99,23.83 186.49,23.33 187.55,23.33 187.65,23.42 v2(198.76,23.42)
  IN4 w0.083: v2(260.13,35.77) 260.13,35.82 259.65,36.3 252.63,36.3 252.04,35.71 244.3,35.71 243.83,35.24 230.2,35.24 227.28,32.32 213.22,32.32 209.8,28.9 207.18,28.9 201.2,22.92 199.26,22.92 v2(198.76,23.42)
  BOTTOM w0.121: v2(273.23,44.9) 274.41,44.9 278.49,40.82 281.52,40.82 282.15,40.19 282.15,37.4 v1(284.09,35.45) 285.27,34.27 286.87,34.27 287.25,33.89 287.25,29.45 287.89,28.81 D6005.3 288.17,29.85 288.59,30.27 289.27,30.27 290.73,28.81 292.55,28.81 D6002.1 293.69,29.36 293.87,29.18 SR6001.2
SMB0_CLK_BATT: length 8.7
  BOTTOM w0.121: CON6000.6 296,25.44 v1(296.37,25.81) 298.05,27.49 298.05,28.94 297.54,29.45 296.65,29.45 296.38,29.18 SR6001.1
SMB0_DAT: length 156.6
  TOP w0.121: SR3011.1 166.63,26.09 R3070.2 167.64,26.25 168.61,26.25 168.95,25.91 168.95,24.29 v2(168.63,23.97) ; v2(260.74,35.77) 260.74,35.41 261.42,34.73 SR8801.1
  IN2 w0.083: v2(272.57,44.94) 268.64,41 268.64,39.58 266.53,37.48 265.04,37.48 264.34,38.18 262.54,38.18 261.88,37.52 261.88,36.91 v2(260.74,35.77)
  IN3 w0.083: v2(168.63,23.97) 168.76,23.97 169.34,24.54 184.87,24.54 185.52,23.89 185.52,23.64 186.3,22.86 187.74,22.86 187.84,22.96 198.9,22.96 v2(199.37,23.42)
  IN4 w0.083: v2(199.37,23.42) 201.05,23.42 206.99,29.36 209.61,29.36 213.03,32.78 227.08,32.78 230.01,35.71 243.64,35.71 244.11,36.18 251.85,36.18 252.44,36.77 259.94,36.77 260.74,35.97 v2(260.74,35.77)
  BOTTOM w0.121: SR6002.2 292.11,30.45 D6003.1 290.7,29.94 289.86,30.77 288.65,30.77 288.17,31.25 D6006.3 288.17,33.71 287.08,34.81 v1(286.37,34.81) 285.58,34.81 282.68,37.7 282.68,40.49 281.86,41.32 278.7,41.32 274.49,45.52 272.88,45.52 272.57,45.22 v2(272.57,44.94)
SMB0_DAT_BATT: length 9.1
  BOTTOM w0.121: CON6000.7 298,25.89 v1(298.25,26.14) 298.56,26.45 298.56,29.19 297.67,30.08 296.48,30.08 296.11,30.45 SR6002.1
SMB1_CLK: length 524.2
  TOP w0.121: R3034.1 167.21,28.69 169.45,26.46 169.45,23.97 v2(169.54,23.89) ; v2(297.29,129.27) 298.56,129.27 298.68,129.39 298.68,131.05 297.87,131.86 R5803.1 296.85,133.63 v1(296.63,133.41) 295.97,134.07 293.96,134.07 R5001.2 293.17,134.12 294.13,133.16 U5000.8 ; v2(184.46,23.78) 184.46,23.22 184.88,22.8 184.88,21.69 185.21,21.36 185.21,18.97 184.13,17.89 184.13,14.64 183.64,14.14 SR3102.2 ; Q1202.2 289.66,68.68 290.15,69.17 v2(290.15,69.98)
  IN1 w0.083: v2(279.81,68.21) 280.03,67.99 282.52,67.99 283.5,68.97 286.57,68.97 287.11,68.43 288.09,68.43 289.64,69.98 v2(290.15,69.98)
  IN2 w0.083: v2(184.46,23.78) 184.46,23.83 184.9,24.27 185.41,24.27 185.78,23.9 196.88,23.9 v2(197.06,24.07)
  IN3 w0.083: v2(22.21,43.03) 21.98,42.81 21.98,42.12 22.22,41.87 22.69,41.87 23.43,41.13 23.43,36.95 24.65,35.73 24.65,31.46 24.16,30.98 24.16,29.79 24.65,29.31 24.65,24.36 23.95,23.67 23.95,21.23 23.39,20.67 23.39,19.09 24.88,17.6 29.15,17.6 32.61,14.15 47.8,14.15 48.75,15.1 49.69,15.1 50.31,14.48 54.45,14.48 55.22,15.25 62.9,15.25 65.08,17.43 109.39,17.43 111.95,19.99 116.29,19.99 119.01,22.71 121.29,22.71 122.74,24.16 v2(122.74,24.59) 123.85,23.48 141.56,23.48 141.84,23.2 160.95,23.2 161.87,24.12 164.27,24.12 165.27,23.11 169.19,23.11 169.54,23.46 v2(169.54,23.89) 169.73,23.69 169.73,23.55 170.44,22.84 183.24,22.84 184.18,23.78 v2(184.46,23.78) ; v2(297.29,129.27) 296.55,129.27 288.75,121.47 288.75,117.44 291.14,115.05 291.14,109 292.63,107.51 292.63,101.16 294.72,99.07 294.72,94.6 291.8,91.68 285.27,91.68 282.98,89.38 282.98,86.44 282.28,85.73 282.28,82.05 283.21,81.12 283.21,76.4 280.96,74.15 280.96,70.58 279.81,69.44 v2(279.81,68.21) 279.81,67.94 277.99,66.11 276.39,66.11 275.47,65.18 275.47,64.5 274.99,64.02 274.99,62.61 273.8,61.42 273.06,61.42 271.43,59.79 271.43,57.82 268.99,55.38 268.99,52.62 257.14,40.77 257.09,40.77 256.46,40.14 256.46,39.59 v2(256.47,39.59)
  IN4 w0.083: v2(197.06,24.07) 197.57,24.59 201.27,24.59 206.71,30.03 209.33,30.03 213.52,34.22 227.57,34.22 229.73,36.38 243.36,36.38 243.88,36.9 249.17,36.9 249.97,37.69 249.97,37.69 250.01,37.74 255.39,37.74 256.47,38.81 v2(256.47,39.59)
  BOTTOM w0.121: Q7401.3 128.77,77.83 126.82,75.89 126.82,67.93 128.24,66.51 128.24,64.87 128.49,64.62 128.49,54.16 126.58,52.25 126.58,37.12 124.77,35.31 124.77,33.82 124.36,33.41 124.36,32.29 123.5,31.43 123.5,29.45 124.04,28.91 124.04,26.38 122.74,25.08 v2(122.74,24.59) ; R1329.2 289.16,80.37 289.54,79.99 290.08,79.99 290.2,80.12 R1332.1 290.76,79.81 290.25,79.31 290.25,72.32 290.51,72.07 290.51,70.34 v2(290.15,69.98) ; CON6700.14 15.73,41.2 17.3,42.77 20.67,42.77 20.94,43.03 v2(22.21,43.03)
SMB1_CLK_GPU: length 19.5
  TOP w0.121: v1(145.68,79.99) 145.5,80.17 v3(145.5,80.6)
  IN4 w0.083: v2(135.06,79.2) 136.36,77.91 138.13,77.91 139.25,79.03 140.58,79.03 142.01,80.46 143.86,80.46 144.31,80.91 145.19,80.91 v3(145.5,80.6)
  BOTTOM w0.102: U7000.BJ8 145.58,80.68 v3(145.5,80.6)
  BOTTOM w0.121: v2(135.06,79.2) 134.83,79.2 134.04,79.99 R7409.1 133.58,79.59 133.76,79.41 133.92,79.41 134.2,79.13 134.2,77.1 133.98,76.88 Q7401.2
SMB1_CLK_HDMI: length 7.8
  TOP w0.121: U1301.13 296,80.64 v2(296.02,80.63)
  BOTTOM w0.121: v1(289.72,80.44) 289.91,80.63 291.5,80.63 291.62,80.5 R1332.2 293.12,80.12 293.17,80.07 293.83,80.07 295.46,80.07 v2(296.02,80.63)
SMB1_CLK_LED: length 6.3
  TOP w0.121: U3102.26 178.67,13.57 179.24,14.14 SR3102.1 181.43,14.46 181.61,14.64 182.63,14.64 182.68,14.69 v1(183.19,14.69)
SMB1_DAT: length 531.7
  TOP w0.121: v2(185.07,23.78) 185.07,23.32 185.38,23.01 v1(185.38,22.57) 185.71,22.24 185.71,18.76 184.63,17.68 184.63,13.18 184.03,12.58 183.46,12.58 182.85,13.19 SR3103.2 ; Q1201.2 287.18,68.33 287.25,68.41 v2(287.25,68.94) ; v2(302.04,128.73) R5804.1 301.53,128.83 301.53,128.48 301.33,128.28 299.55,128.28 299.07,128.76 295.97,128.76 292.21,132.52 R5002.2 292.56,134.8 292.67,134.7 292.67,133.89 294.04,132.51 U5000.7 ; v2(170.2,23.89) 170.2,24.18 169.95,24.42 169.95,26.66 167.42,29.2 166.5,29.2 R3035.1
  IN1 w0.083: v2(287.25,68.94) 287.25,68.94 286.77,69.43 283.3,69.43 282.36,68.49 280.78,68.49 v2(280.45,68.82)
  IN2 w0.083: v2(197.71,24.07) 197.71,23.69 197.45,23.43 185.44,23.43 185.09,23.78 v2(185.07,23.78)
  IN3 w0.083: v2(302.04,128.73) 302.04,128.68 301.68,128.33 296.3,128.33 289.23,121.26 289.23,117.62 291.65,115.2 291.65,109.48 293.1,108.03 293.1,101.45 295.21,99.35 295.21,94.42 291.99,91.21 291.82,91.21 291.8,91.19 285.46,91.19 283.44,89.18 283.44,86.25 282.74,85.54 282.74,82.24 283.67,81.31 283.67,76.2 281.42,73.96 281.42,70.39 280.45,69.42 v2(280.45,68.82) 280.45,67.92 278.18,65.65 276.67,65.65 275.95,64.93 275.95,64.22 275.45,63.72 275.45,62.42 273.99,60.96 273.25,60.96 271.9,59.6 271.9,57.63 269.46,55.19 269.46,52.24 257.22,40 256.97,40 v2(256.93,40.04) ; v2(185.07,23.78) 184.61,24.25 183.98,24.25 183.04,23.31 170.78,23.31 v2(170.2,23.89) 169.79,24.29 169.38,24.29 169.07,23.98 169.07,23.73 168.91,23.58 165.47,23.58 164.46,24.58 161.68,24.58 160.76,23.66 142.03,23.66 141.75,23.94 124.07,23.94 v2(123.42,24.59) 122.94,25.08 122.57,25.08 122.28,24.79 122.28,24.47 121.01,23.2 118.84,23.2 116.1,20.45 111.76,20.45 109.2,17.9 64.88,17.9 62.7,15.71 55.03,15.71 54.26,14.94 50.5,14.94 49.89,15.56 48.56,15.56 47.87,14.88 47.87,14.88 47.61,14.61 32.8,14.61 29.34,18.07 25.08,18.07 23.86,19.29 23.86,20.48 24.42,21.04 24.42,23.48 25.11,24.17 25.11,29.5 24.63,29.98 24.63,30.79 25.11,31.27 25.11,35.92 23.89,37.14 23.89,41.33 22.82,42.4 v2(22.38,42.4)
  IN4 w0.083: v2(197.71,24.07) 201.41,24.07 206.9,29.57 209.52,29.57 213.69,33.74 227.75,33.74 229.92,35.92 243.56,35.92 244.07,36.43 249.37,36.43 250.2,37.27 255.58,37.27 256.93,38.63 v2(256.93,40.04)
  BOTTOM w0.121: R1328.2 R1333.1 290.76,72.52 291.01,72.28 291.01,70.03 289.92,68.94 v2(287.25,68.94) ; CON6700.13 14.66,40.7 14.67,40.7 15.94,40.7 17.43,42.18 20.59,42.18 20.66,42.25 22.23,42.25 v2(22.38,42.4) ; v2(123.42,24.59) 123.42,25.03 124.54,26.14 124.54,29.12 124,29.66 124,31.06 124.86,31.93 124.86,33.2 125.27,33.61 125.27,35.1 127.08,36.91 127.08,51.92 128.99,53.83 128.99,64.85 128.74,65.1 128.74,66.75 127.81,67.68 127.81,76.17 128.9,77.26 129.79,77.26 131.27,75.77 Q7402.3
SMB1_DAT_GPU: length 19.7
  TOP w0.121: v2(135.22,73.81) 135.95,74.53 v1(136.2,74.53)
  IN4 w0.083: v2(135.22,73.81) 135.68,74.26 135.68,76.56 136.52,77.4 138.31,77.4 139.4,78.49 140.81,78.49 142.31,79.99 144.05,79.99 144.5,80.45 145.09,80.45 145.31,80.23 145.83,80.23 v3(146.21,80.61)
  BOTTOM w0.102: U7000.BH8 v3(146.21,80.61)
  BOTTOM w0.121: v2(135.22,73.81) 134.98,74.05 R7410.1 134.37,74.38 133.68,73.68 Q7402.2
SMB1_DAT_HDMI: length 21
  TOP w0.121: v2(296.02,79.86) 296.02,79.99 296.45,80.42 296.45,80.83 296.4,80.88 U1301.14
  BOTTOM w0.121: v1(286.52,69.1) 286.52,69.09 287.08,68.53 289.86,68.53 291.26,69.93 291.26,72.38 291.01,72.63 291.01,77.09 291.62,77.71 R1333.2 291.93,78.39 291.93,78.49 292.16,78.72 292.69,78.72 293.54,79.57 293.62,79.57 295.72,79.57 v2(296.02,79.86)
SMB1_DAT_LED: length 6.3
  TOP w0.121: U3102.27 179.32,13.32 179.6,13.6 180.5,13.6 180.91,13.19 SR3103.1 181.43,13.53 181.51,13.62 183.22,13.62 v1(183.8,13.04)
SMB2_CLK_GPU: length 12.6
  IN1 w0.083: v3(146.85,82.05) 146.23,81.43 144.48,81.43 143.09,80.04 141.06,80.04 140.71,80.39 140.35,80.39 138.75,78.79 v2(138.14,78.79)
  BOTTOM w0.102: U7000.BG9 v3(146.85,82.05)
  BOTTOM w0.121: SR7407.1 138.15,78.79 v2(138.14,78.79) 138.39,79.04 138.42,79.04 R7405.1
SMB2_DAT_GPU: length 13.3
  TOP w0.121: v1(145.89,82.54) 146.24,82.19 v3(146.24,82.03)
  IN1 w0.083: v3(146.24,82.03) 145.79,82.48 144.76,82.48 142.88,80.6 141.15,80.6 140.87,80.88 140.18,80.88 138.68,79.38 138.13,79.38 v2(137.53,78.79)
  BOTTOM w0.102: v3(146.24,82.03) 146.39,81.89 146.39,81.81 U7000.BH9
  BOTTOM w0.121: R7406.1 137.53,78.98 v2(137.53,78.79) 137.53,78.58 SR7408.1
SMB3_CLK_GPU: length 15.8
  TOP w0.121: v3(147.6,80.6) 147.48,80.47 R74107.1
  IN1 w0.083: v2(136.32,78.79) 136.32,78.52 137.06,77.77 139.34,77.77 139.93,78.36 141.22,78.36 141.74,78.88 143.24,78.88 145.41,81.05 147.15,81.05 v3(147.6,80.6)
  BOTTOM w0.102: U7000.BG8 v3(147.6,80.6)
  BOTTOM w0.121: R7407.1 136.26,78.84 v2(136.32,78.79) 136.26,78.74 R7498.1
SMB3_DAT_GPU: length 15.7
  TOP w0.121: R74108.1 148.48,80.42 v3(148.31,80.59)
  IN1 w0.083: v3(148.31,80.59) 147.65,81.25 144.95,81.25 143.04,79.34 141.55,79.34 141.03,78.82 139.73,78.82 139.15,78.24 137.34,78.24 136.93,78.66 v2(136.93,78.79)
  BOTTOM w0.102: v3(148.31,80.59) 148.25,80.65 U7000.BF8
  BOTTOM w0.121: R7408.1 137.09,78.95 v2(136.93,78.79) 136.93,78.38 R7499.1
SMB_CLK_DEBUG: length 23.5
  TOP w0.121: v2(64.98,133) 58.07,133 54.71,129.64 v1(54.13,129.64) 53.54,129.64 49.22,125.32 Q3102.4 47.95,125.32 47.81,125.18 R3111.2 R3115.2
  BOTTOM w0.121: SR4409.1 64.67,132.7 v2(64.98,133)
SMB_CLK_MAIN: length 182.3
  TOP w0.121: CON1600.253 107.62,58.07 108.92,59.36 110.96,59.36 v2(112.1,58.22) ; v2(109.19,46.02) 107.97,46.02 107.62,45.67 CON1700.253 ; Q3101.4 210.69,37.3 R3110.2 R3105.2 211.49,40.16 v1(210.52,41.13) 209.89,41.76 208.36,41.76 207.02,40.42 v2(207.02,39.48)
  IN1 w0.083: v2(109.19,46.02) 109.24,46.02 109.28,46.06 111.97,46.06 112.44,45.58 122.01,45.58 122.34,45.91 v2(122.34,46.49) 122.34,46.55 119.14,49.75 118.9,49.99 118.9,56.04 117.67,57.27 115.72,57.27 113.84,59.14 113.02,59.14 v2(112.1,58.22)
  IN3 w0.083: v2(207.02,39.48) 207.02,39.12 206.22,38.33 204.76,38.33 199.46,33.02 198.88,33.02 195.53,29.68 187.77,29.68 187.22,30.22 186.16,30.22 185.89,30.49 171.53,30.49 171.16,30.86 167.77,30.86 166.44,29.53 160.35,29.53 159.81,30.06 159.81,30.7 159.01,31.5 147.43,31.5 147.16,31.77 144.32,34.62 138.22,34.62 137.45,35.38 134.44,35.38 132.24,33.18 126.54,33.18 125.86,33.86 122.78,33.86 122.03,33.1 v2(122.03,32.98)
  BOTTOM w0.121: v2(109.19,46.02) 109.62,46.46 109.62,47.04 108.86,47.79 107.54,47.79 107.17,48.17 107.17,49.69 105.63,51.23 CON1701.253 ; CON1601.253 105.63,63.67 105.87,63.42 105.87,63.05 107.5,61.42 107.5,60.36 108.02,59.84 109.59,59.84 111.21,58.22 v2(112.1,58.22) ; v2(122.34,46.49) 122.34,45.68 121.87,45.22 121.87,43.28 122.14,43.01 122.14,36.19 121.74,35.79 121.74,33.93 122.03,33.64 v2(122.03,32.98)
SMB_CLK_RESUME: length 394.1
  TOP w0.121: v2(236.36,49.16) 236.57,48.95 236.57,45.68 237.38,44.86 237.38,43.33 C2304.1 238.17,42.54 238.17,40.81 R2327.2 238.01,40.24 238.21,40.04 238.21,38.69 v2(237.87,38.35) ; v2(46.03,124.7) 45.78,124.44 R3115.1 45.37,124.47 45.37,125.13 45.56,125.32 Q3102.3 ; v2(212.93,39.42) 212.93,38.69 R3110.1 212.35,37.45 210.04,35.14 207.58,35.14 207.02,35.7 207.02,36.71 207.61,37.3 Q3101.3
  IN1 w0.083: v2(63.99,114.28) 62.49,114.28 60.15,111.94 57.59,111.94 45.73,100.08 45.73,95.28 v2(46.01,95) ; v2(65.16,128.63) 64.68,128.15 58.55,128.15 57.77,128.94 57,128.94 55.79,130.16 53.27,130.16 47.81,124.7 v2(46.03,124.7)
  IN2 w0.083: v2(65.16,128.63) 65.57,128.22 65.57,124.89 66.38,124.09 66.38,121.67 65.4,120.69 65.4,115.67 64.01,114.28 v2(63.99,114.28)
  IN3 w0.083: v2(46.01,95) 46.44,95 48.97,92.47 48.97,86.17 33.87,71.07 33.87,59.83 33.27,59.23 33.27,54.29 34.25,53.31 34.25,48.86 33.69,48.3 33.69,44.27 33.16,43.73 33.16,40.62 35.59,38.18 35.59,33.05 39.12,29.52 39.12,25.89 41.99,23.02 59.8,23.02 62.54,25.76 98.4,25.76 104.14,31.5 112.38,31.5 113.3,32.42 119.47,32.42 122.04,35 126.33,35 127.01,34.32 131.77,34.32 133.97,36.52 138.73,36.52 138.91,36.34 144.2,36.34 147.9,32.64 160.62,32.64 161.96,31.29 166.6,31.29 167.3,32 171.63,32 172,31.63 186.37,31.63 186.63,31.36 187.7,31.36 188.24,30.81 195.06,30.81 198.08,33.84 198.08,34.81 198.38,35.11 199.94,35.11 205.36,40.53 208.3,40.53 208.43,40.39 210.6,40.39 211.05,39.94 212.41,39.94 v2(212.93,39.42)
  BOTTOM w0.121: U2000.AW44 236.36,48.87 v2(236.36,49.16) ; v2(212.93,39.42) 212.93,38.21 214.36,36.79 v1(215.42,36.79) 218.55,36.79 221.82,33.51 226.4,33.51 230.31,37.42 233.66,37.42 234.44,38.2 237.72,38.2 v2(237.87,38.35)
SMB_DATA_DEBUG: length 23.4
  TOP w0.121: v2(64.98,133.64) 58,133.64 54.5,130.14 53.22,130.14 51.51,128.43 v1(50.74,128.43) 47.99,128.43 47.81,128.25 R3113.2 R3109.2 46.64,126.8 46.45,126.62 Q3102.1
  BOTTOM w0.121: v2(64.98,133.64) 64.67,133.95 SR4408.1
SMB_DATA_MAIN: length 177.5
  TOP w0.121: v2(206.36,39.45) 207.2,38.6 Q3101.1 208.3,38.6 208.59,38.89 R3104.2 R3108.2 v1(207.68,40.34) ; v2(109.19,46.65) 107.54,48.31 107.54,49.06 107.87,49.39 CON1700.254 ; CON1600.254 107.87,62.77 109.45,61.19 109.45,60.46 110.05,59.86 111.17,59.86 112.76,58.27 v2(112.76,58.22)
  IN1 w0.083: v2(109.19,46.65) 112.03,46.65 112.61,46.07 v2(121.9,46.07) 118.44,49.53 118.44,55.85 117.48,56.8 115.53,56.8 113.65,58.68 113.21,58.68 v2(112.76,58.22)
  IN3 w0.083: v2(121.39,32.98) 121.39,33.13 122.59,34.32 126.05,34.32 126.73,33.65 132.05,33.65 134.25,35.84 137.65,35.84 138.41,35.08 144.51,35.08 147.62,31.97 159.23,31.97 160.28,30.92 160.28,30.26 160.55,29.99 166.25,29.99 167.58,31.32 171.35,31.32 171.72,30.95 186.09,30.95 186.35,30.69 187.42,30.69 187.96,30.14 195.34,30.14 198.69,33.48 199.27,33.48 204.57,38.79 205.69,38.79 v2(206.36,39.45)
  BOTTOM w0.121: v2(112.76,58.22) 112.76,58.05 112.34,57.63 111.09,57.63 109.38,59.34 107.09,59.34 106.69,58.94 106.69,58.45 105.88,57.64 CON1601.254 ; v2(121.9,46.07) 121.37,45.54 121.37,43.07 121.63,42.81 121.63,36.4 121.23,36 121.23,33.64 121.39,33.48 v2(121.39,32.98) ; v2(109.19,46.65) 108.56,47.29 107.03,47.29 105.88,46.14 CON1701.254
