# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 149.21,101.05 149.21,100.72 149.31,100.62 149.31,100.61 149.38,100.55 149.38,100.18 149.59,99.98 149.59,99.91 149.73,99.77 149.75,99.76 149.79,99.73 149.86,99.66 149.89,99.62 149.89,99.42 149.76,99.3 149.61,99.3 149.55,99.3 148.82,99.3 148.69,99.44 148.69,100.51 148.52,100.68 148.22,100.68 148.05,100.85 148.05,100.97 148.2,101.12 149.14,101.12
GND on TOP (solid shape): 164.24,56.83 164.24,56.5 164.09,56.35 163.8,56.26 163.7,55.96 163.55,55.81 163.51,55.81 163.4,55.71 162.49,55.71 162.46,55.73 162.46,56.14 162.49,56.17 163.18,56.17 163.28,56.27 163.58,56.27 163.73,56.42 163.73,56.83 163.79,56.88 164.19,56.88
GND on TOP (solid shape): 59.42,175.24 59.42,169.78 59.92,169.27 63.99,169.27 64.37,169.65 64.37,170.67 64.5,170.8 65.64,170.8 65.77,170.67 65.77,169.78 65.64,169.65 65.39,169.65 65,169.27 65,168.76 65.77,168 65.77,167.49 65.51,167.24 61.96,167.24 61.83,167.11 61.83,166.61 61.19,165.97 59.67,165.97 59.29,165.59 59.29,164.7 59.16,164.57 58.53,164.57 58.4,164.7 58.4,165.89 57.77,166.53 57.77,175.24 58.02,175.5 59.16,175.5
GND on TOP (solid shape): 259.82,83.04 259.82,82.66 259.75,82.58 259.75,81.82 259.92,81.64 261.01,81.64 261.09,81.56 261.09,81.41 261.23,81.28 261.25,81.25 261.29,81.22 261.4,81.11 262.64,81.11 262.67,81.13 262.67,79.66 262.49,79.48 261.73,79.48 261.6,79.61 261.6,79.94 261.22,80.32 261.22,80.53 260.99,80.75 258.4,80.75 258.32,80.83 258.32,81.52 258.43,81.62 259.34,81.62 259.54,81.82 259.54,82.63 259.44,82.73 259.44,83.07 259.52,83.14 259.72,83.14
GND on TOP (solid shape): 110.95,105.7 110.95,105.14 109.91,104.1 108.85,104.1 108.72,104.22 108.72,104.48 108.9,104.66 109.29,104.83 109.25,105.25 109.25,105.42 109.3,105.49 109.33,105.57 109.38,105.62 110.24,105.62 110.52,105.9 110.75,105.9
GND on TOP (solid shape): 163.21,58.99 163.29,58.95 163.37,58.94 163.48,58.83 163.61,58.83 163.72,58.73 163.76,58.42 164.04,58.29 164.15,58.29 164.24,58.2 164.24,57.82 164.17,57.74 163.91,57.74 163.81,57.84 163.81,58.02 163.46,58.38 163.28,58.38 163.13,58.53 162.44,58.53 162.41,58.55 162.41,58.96 162.44,58.99
GND on TOP (solid shape): 302.82,41.99 303.03,41.88 303.27,41.92 303.36,41.92 303.45,41.83 304.02,41.83 304.02,41.43 303.41,41.43 303.28,41.31 303,41.31 302.9,41.41 302.78,41.41 302.66,41.43 302.53,41.41 302.29,41.41 302.14,41.56 300.82,41.56 300.82,41.89 300.87,41.94 302.14,41.94 302.19,41.99
GND on TOP (solid shape): 119.7,19.05 120.18,19.05 120.19,19.05 120.7,19.05 120.81,18.94 120.81,17.7 120.76,17.64 120.59,17.64 120.56,17.68 120.56,18.4 120.52,18.43 120.35,18.43 120.31,18.4 120.31,17.68 120.27,17.64 120.11,17.64 120.06,17.69 120.06,18.44 120.03,18.47 119.86,18.47 119.81,18.42 119.81,17.7 119.76,17.64 119.59,17.64 119.56,17.68 119.56,18.4 119.52,18.43 119.35,18.43 119.31,18.4 119.31,17.68 119.27,17.64 119.11,17.64 119.06,17.69 119.06,18.92 119.19,19.05 119.7,19.05
GND on TOP (solid shape): 166.14,93.9 166.24,93.65 166.49,93.54 166.49,92.94 166.39,92.84 166.32,92.81 166.27,92.77 166.21,92.7 166.16,92.62 166.05,92.51 166.05,91.6 166.44,91.22 166.44,90.78 166.42,90.77 165.6,90.77 165.52,90.85 165.52,91.56 165.6,91.63 165.6,94.03 165.7,94.14 165.9,94.14
GND on TOP (solid shape): 168.64,52.31 168.74,52.31 168.81,52.38 168.81,52.43 168.94,52.56 169.17,52.56 169.32,52.41 169.32,52.18 169.02,51.87 168.64,51.87 168.64,51.52 169.12,51.04 169.12,50.71 168.76,50.35 167.7,50.35 167.11,49.77 166.91,49.77 166.81,49.87 166.81,51.32 167.1,51.61 168.14,51.61 168.26,51.72 168.26,52.74 168.28,52.76 168.28,53.22 168.64,53.22
GND on TOP (solid shape): 207.52,87.56 207.52,86.21 207.42,86.11 207.42,85.1 208.06,84.46 208.74,84.46 209.4,85.12 210.7,85.12 210.72,85.1 210.72,84.54 210.7,84.51 209.56,84.51 209.02,83.98 207.91,83.98 207.39,84.49 207.11,84.47 206.99,84.59 206.99,85.66 207.02,85.68 207.02,86.37 207.07,86.42 207.07,87.56 207.09,87.59 207.5,87.59
GND on TOP (solid shape): 132.83,18.93 132.83,17.69 132.78,17.64 132.61,17.64 132.57,17.68 132.57,18.39 132.54,18.43 132.37,18.43 132.33,18.39 132.33,17.67 132.29,17.64 132.13,17.64 132.07,17.69 132.07,18.44 132.05,18.47 131.88,18.47 131.83,18.42 131.83,17.69 131.78,17.64 131.61,17.64 131.57,17.68 131.57,18.39 131.54,18.43 131.37,18.43 131.33,18.39 131.33,17.67 131.29,17.64 131.13,17.64 131.07,17.69 131.07,18.34 130.94,18.47 130.69,18.47 130.59,18.57 130.59,18.91 130.73,19.05 132.71,19.05
GND on TOP (solid shape): 186.52,53.37 187.28,53.37 187.31,53.35 187.31,52.97 187.28,52.94 187.28,52 187.26,51.98 186.49,51.98 186.39,51.87 186.24,51.87 186.01,52.1 185.58,52.1 185.43,52.25 185.43,52.43 185.58,52.59 186.16,52.59 186.34,52.41 186.72,52.41 186.85,52.53 186.85,52.97 186.32,52.97 185.55,53.73 185.55,53.91 185.68,54.03 185.86,54.03
GND on TOP (solid shape): 19.16,76.23 19.16,74.66 18.78,74.28 18.78,68.05 19.16,67.67 20.55,67.67 20.81,67.42 24.36,67.42 24.49,67.55 27.67,67.55 27.79,67.67 27.79,68.18 27.92,68.31 28.17,68.31 28.68,68.82 32.11,68.82 32.24,68.69 32.24,65.13 31.86,64.75 17.21,64.75 17.02,64.94 17.02,67.03 15.34,68.71 8.77,68.71 8.54,68.94 8.54,72.28 8.61,72.35 9.03,72.35 9.57,71.82 11.74,71.82 12.56,72.64 12.56,76.06 12.81,76.31 19.09,76.31
GND on TOP (solid shape): 77.82,54.91 79.1,54.91 79.16,54.95 79.38,54.95 79.43,54.91 80.29,54.91 80.29,54.95 80.67,54.95 80.71,54.9 80.71,54.51 80.65,54.45 80.29,54.45 80.29,54.48 79.36,54.48 79.27,54.46 79.17,54.48 77.82,54.48 77.8,54.45 77.37,54.45 77.29,54.54 77.29,54.93 77.31,54.95 77.79,54.95
GND on TOP (solid shape): 195.76,98.2 195.76,98 195.66,97.9 195.51,97.9 195.5,97.92 195.04,97.94 194.99,97.49 194.99,97.36 194.49,96.86 193.83,96.86 193.81,96.83 193.81,96.63 193.78,96.6 193,96.6 192.97,96.63 192.97,97.52 193,97.54 194.37,97.54 195.15,98.33 195.64,98.33
GND on TOP (solid shape): 204.04,123.78 204.04,123.3 204.5,123.3 204.88,122.92 205.44,122.92 205.49,122.87 205.49,122 205.97,121.52 205.97,121.32 205.87,121.22 205.04,121.22 204.96,121.14 204.6,121.14 204.48,121.27 204.48,122.71 204.3,122.89 203.61,122.89 203.59,122.92 203.59,123.4 203.54,123.45 203.41,123.45 203.13,123.17 203.13,123.02 203.1,122.99 202.7,122.99 202.67,123.02 202.67,123.32 203.46,124.11 203.71,124.11
GND on TOP (solid shape): 90.7,127.74 90.7,127.43 90.74,127.39 90.9,127.39 90.95,127.34 90.95,126.1 90.89,126.04 90.72,126.04 90.7,126.01 90.7,125.85 90.62,125.77 90.62,125.65 90.58,125.61 90.37,125.61 90.31,125.68 90.31,125.71 90.31,125.87 90.24,126.02 90.24,127.5 90.3,127.61 90.32,127.73 90.35,127.8 90.42,127.83 90.6,127.83
GND on TOP (solid shape): 200.46,114.94 200.46,114.28 200.62,114.13 200.62,113.95 200.38,113.72 200.13,113.59 200.06,113.32 199.91,113.16 199.57,113.16 199.5,113.24 199.5,113.49 199.71,113.71 200.02,113.87 200.01,114.22 200.01,114.94 200.03,114.97 200.44,114.97
GND on TOP (solid shape): 209.43,97.85 210.52,97.85 210.55,97.82 210.55,97.24 210.19,96.76 210.55,96.27 210.55,95.87 210.52,95.84 209.63,95.84 209.61,95.87 209.61,96.17 209.58,96.2 208.77,96.2 208.64,96.32 208.64,96.5 208.79,96.65 208.79,96.91 208.57,97.14 208.57,98.1 208.74,98.28 209,98.28
GND on TOP (solid shape): 165.6,103.92 165.6,103.51 165.47,103.38 164.86,103.38 164.74,103.26 164.74,102.63 164.63,102.52 164.63,95.32 164.63,95.25 164.93,94.95 165.07,94.95 165.13,94.88 165.13,94.34 165.07,94.28 164.96,94.28 164.78,94.1 164.78,94.05 164.78,94.04 164.75,93.93 164.76,93.81 164.75,93.73 164.66,93.69 164.29,93.69 164.17,93.8 164.17,93.98 164.17,93.98 164.17,95.15 164.12,95.2 164.12,103.81 164.3,103.99 165.52,103.99
GND on TOP (solid shape): 179.79,58.91 179.79,58.43 179.74,58.38 178.95,58.38 178.87,58.3 178.65,58.17 178.58,57.92 178.41,57.74 178.14,57.74 178.03,57.84 178.03,58.22 178.13,58.32 178.48,58.37 178.58,58.72 178.64,58.78 178.75,58.78 178.9,58.94 179.76,58.94
GND on TOP (solid shape): 297.04,63.17 297.04,63.03 297.25,62.63 297.7,62.72 297.75,62.77 298.86,62.77 298.94,62.84 300.47,62.84 300.65,62.66 300.65,62.47 300.52,62.34 298.25,62.34 298.25,62.34 297.72,62.34 297.59,62.47 297.54,62.52 295.97,62.52 295.89,62.59 295.89,63.1 296.02,63.23 296.98,63.23
GND on TOP (solid shape): 39.58,10.32 40.82,10.32 41.17,10.29 41.41,10.55 41.42,10.56 41.51,10.65 41.89,10.65 42.4,11.16 43.03,11.16 43.16,11.03 43.27,11.03 45.83,11.03 46.08,10.78 46.08,10.4 46.21,10.27 46.21,9.94 46.08,9.81 42.78,9.81 42.53,9.56 39.05,9.56 38.59,10.01 35.16,10.01 35.03,10.14 35.03,10.93 35.16,11.06 36.07,11.06 36.18,11.16 38.74,11.16
GND on TOP (solid shape): 118.01,18.95 118.02,18.94 118.02,17.7 117.96,17.65 117.8,17.65 117.76,17.68 117.76,17.7 117.76,18.41 117.73,18.44 117.56,18.44 117.52,18.4 117.52,17.68 117.48,17.64 117.32,17.64 117.26,17.7 117.26,17.71 117.26,18.46 117.23,18.49 117.06,18.49 117.02,18.44 117.02,17.7 116.96,17.65 116.8,17.65 116.76,17.68 116.76,17.7 116.76,18.41 116.73,18.44 116.56,18.44 116.52,18.4 116.52,17.68 116.48,17.64 116.32,17.64 116.26,17.7 116.26,17.71 116.26,18.93 116.39,19.07 117.9,19.07
GND on TOP (solid shape): 147.54,59.66 148.78,59.66 149.21,59.24 149.21,57.22 149.58,56.84 150.05,56.84 150.28,56.62 150.28,56.1 150.11,55.93 148.69,55.93 148.61,55.97 148.59,56.05 148.44,56.44 148.02,56.46 147.5,56.46 147.46,56.47 147.07,56.85 147.07,59.67 147.22,59.82 147.38,59.82
GND on TOP (solid shape): 159.15,56.05 159.28,55.76 159.59,55.71 159.62,55.71 159.65,55.68 160.36,55.68 160.38,55.66 160.38,55.2 160.33,55.15 159.27,55.15 159.15,55.27 159.05,55.62 158.69,55.67 158.6,55.76 158.6,56.19 158.68,56.27 158.93,56.27
GND on TOP (solid shape): 200.21,79.92 200.21,79.23 200.36,79.08 200.36,78.75 200.25,78.64 199.9,78.57 199.82,78.21 199.73,78.11 199.37,78.11 199.24,78.24 199.24,78.62 199.32,78.69 199.72,78.76 199.75,79.17 199.75,79.92 199.78,79.94 200.18,79.94
GND on TOP (solid shape): 146.67,106.46 146.67,105.67 147.13,105.21 148.5,105.21 148.62,105.1 148.62,103.58 148.94,103.26 149.18,103.26 149.42,103.03 150.59,103.03 150.73,102.88 150.74,102.87 150.74,101.7 150.72,101.64 150.72,101.56 150.51,101.35 149.59,101.35 149.39,101.55 149.39,101.83 148.57,102.66 148.57,103.26 148.33,103.49 148.16,103.49 147.92,103.74 147.29,103.74 147.11,103.92 147.02,103.99 146.9,104.03 146.89,104.03 146.19,104.73 145,104.73 144.62,105.11 143.67,105.11 142.98,105.8 142.98,106.42 143.09,106.53 146.6,106.53
GND on TOP (solid shape): 203.51,89.01 203.51,88.78 202.95,88.22 202.95,87.92 203.03,87.92 203.16,88.04 203.38,88.04 203.38,88.2 203.54,88.35 203.54,88.53 203.69,88.68 203.89,88.68 204.04,88.53 204.04,88.32 203.84,88.12 203.84,88.07 203.87,88.04 204.5,88.04 204.73,87.81 205.26,87.81 205.29,87.79 205.29,86.93 205.75,86.47 205.75,85.61 205.62,85.48 205.42,85.48 205.29,85.61 205.29,86.16 205.26,86.19 204.98,86.19 204.81,86.01 204.55,86.01 204.4,86.16 204.4,87.18 203.92,87.66 203.36,87.66 203.13,87.43 202.55,87.43 202.55,88.55 203.16,89.16 203.36,89.16
GND on TOP (solid shape): 72.19,129.5 72.4,129.04 72.86,129.24 72.88,129.27 75.62,129.27 75.65,129.24 75.65,128.86 75.44,128.66 74.01,128.66 73.98,128.62 73.98,128.26 73.89,128.18 73.62,128.18 73.29,128.51 72.04,128.51 71.66,128.89 71.29,128.89 71.1,128.94 70.92,128.89 70.72,128.89 70.54,129.06 70.54,129.47 70.67,129.6 72.09,129.6
GND on TOP (solid shape): 156.59,114.34 156.84,114.34 156.97,114.21 156.97,113.09 156.55,112.67 155.49,112.67 155.4,112.76 155.4,113.04 155.45,113.13 155.54,113.14 155.99,113.45 155.54,113.76 155.45,113.77 155.4,113.85 155.4,114.15 155.6,114.35 156.59,114.35
GND on TOP (solid shape): 183.79,58.04 183.86,57.75 184.13,57.64 184.33,57.44 184.33,57.21 184.13,57 183.87,56.89 183.79,56.62 183.79,56.6 183.63,56.45 183.34,56.45 183.24,56.55 183.24,57.13 183.13,57.24 183.04,57.55 182.73,57.64 182.68,57.69 181.34,57.69 181.31,57.72 181.31,58.17 181.34,58.2 183.62,58.2
GND on TOP (solid shape): 233.89,96.22 234.17,96.1 234.45,95.98 234.53,95.93 234.62,95.91 234.92,95.79 235.23,95.67 235.33,95.61 235.44,95.59 235.72,95.48 235.99,95.38 236.12,95.3 236.27,95.28 236.53,95.19 236.79,95.1 236.87,95.07 236.95,95.05 237.31,94.93 237.65,94.83 237.77,94.77 237.9,94.75 238.01,94.71 238.13,94.59 238.13,93.58 238.03,93.48 237.39,93.48 237.17,93.71 233.84,93.71 233.51,94.04 233.51,96.07 233.66,96.22
GND on TOP (solid shape): 164.56,89.17 164.56,87.9 164.71,87.75 164.71,86.64 164.63,86.57 164.63,85.3 164.73,85.2 164.73,84.76 164.68,84.71 163.44,84.71 163.17,84.45 163.17,83.88 163.07,83.78 162.66,83.78 162.62,83.81 162.62,85.12 162.65,85.12 162.65,85.41 162.66,85.5 162.65,85.58 162.65,86.08 162.67,86.19 162.65,86.31 162.64,86.34 162.64,87.14 162.75,87.25 162.75,87.68 162.93,87.86 163.08,87.86 163.26,87.68 163.26,87.56 163.21,87.51 163.21,85.42 163.46,85.17 163.56,85.17 163.7,85.14 163.84,85.17 163.92,85.17 164.15,85.4 164.15,87.66 164.15,87.66 164.08,87.73 164.08,89.14 164.17,89.23 164.5,89.23
GND on TOP (solid shape): 121.65,78.34 121.65,72.12 121.52,71.99 119.11,71.99 118.98,72.12 118.98,75.34 119.49,75.34 119.49,75.29 119.5,75.23 119.52,75.18 119.55,75.13 119.58,75.09 119.62,75.05 119.67,75.02 119.72,74.99 119.77,74.97 119.83,74.96 119.88,74.96 119.94,74.97 119.99,74.98 120.04,75 120.09,75.03 120.13,75.07 120.17,75.11 120.2,75.16 120.23,75.21 120.24,75.26 120.25,75.32 120.25,75.37 120.24,75.43 120.23,75.48 120.2,75.53 120.17,75.58 120.13,75.62 120.09,75.65 120.04,75.68 119.99,75.71 119.94,75.72 119.88,75.73 119.83,75.72 119.77,75.71 119.72,75.7 119.67,75.67 119.62,75.64 119.58,75.6 119.55,75.55 119.52,75.51 119.5,75.45 119.49,75.4 119.49,75.34 118.98,75.34 118.98,78.34 119.11,78.47 121.52,78.47
GND on TOP (solid shape): 245.57,78.54 245.68,78.43 245.68,78.41 245.7,78.21 245.81,78.05 245.82,77.55 246.31,77.49 246.38,77.5 246.45,77.46 246.46,77.44 246.46,76.84 246.44,76.82 244.19,76.82 244.09,76.92 244.09,78.45 244.16,78.53 244.19,78.52 244.36,78.49 244.53,78.54
GND on TOP (solid shape): 35.06,39.28 35.06,37.93 34.83,37.7 33.33,37.7 32.98,37.35 32.98,36.91 33.2,36.68 35.01,36.68 35.11,36.58 35.11,33.05 34.93,32.87 33.36,32.87 33.14,33.09 33.14,33.1 33.09,33.15 33.09,33.85 33.08,33.88 33.09,33.91 32.85,34.49 32.4,34.06 32.37,33.98 32.3,33.94 31.91,33.94 31.55,34.3 31.55,39.33 31.91,39.68 34.65,39.68
GND on TOP (solid shape): 80.78,39.77 80.78,23.64 79.73,22.58 76.79,22.58 76.14,21.93 76.14,20.9 75.31,20.06 71.57,20.06 65.17,26.46 65.17,35.32 61.24,39.25 61.24,40.61 62.57,40.61 62.57,40.55 62.59,40.5 62.61,40.45 62.64,40.4 62.67,40.36 62.71,40.32 62.76,40.29 62.81,40.26 62.86,40.25 62.92,40.24 62.98,40.24 63.03,40.25 63.08,40.26 63.13,40.29 63.18,40.32 63.22,40.36 63.26,40.4 63.29,40.45 63.31,40.5 63.32,40.55 63.33,40.61 63.33,40.66 63.32,40.72 63.3,40.77 63.27,40.82 63.24,40.87 63.2,40.91 63.16,40.94 63.11,40.97 63.06,40.99 63,41 62.95,41 62.89,41 62.84,40.99 62.79,40.97 62.74,40.94 62.69,40.91 62.65,40.87 62.62,40.82 62.6,40.77 62.58,40.72 62.57,40.66 62.57,40.61 61.24,40.61 61.24,40.88 61.52,41.17 79.39,41.17
GND on TOP (solid shape): 149.73,73.17 149.73,72.99 149.04,72.29 149.04,70.11 149.02,70.09 148.46,70.09 147.69,70.86 147.69,70.87 147.39,71.17 147.39,72.22 147.73,72.22 147.74,72.16 147.75,72.11 147.77,72.06 147.79,72.01 147.83,71.96 147.87,71.93 147.91,71.89 147.96,71.87 148.02,71.85 148.07,71.84 148.13,71.84 148.18,71.84 148.24,71.86 148.29,71.88 148.34,71.91 148.38,71.94 148.42,71.99 148.45,72.03 148.47,72.08 148.49,72.14 148.5,72.19 148.5,72.25 148.49,72.3 148.47,72.36 148.45,72.41 148.42,72.45 148.38,72.49 148.34,72.53 148.29,72.56 148.24,72.58 148.18,72.6 148.13,72.6 148.07,72.6 148.02,72.59 147.96,72.57 147.91,72.55 147.87,72.51 147.83,72.47 147.79,72.43 147.77,72.38 147.75,72.33 147.74,72.27 147.73,72.22 147.39,72.22 147.39,72.65 148,73.26 148.8,73.26 148.89,73.35 149.55,73.35
GND on TOP (solid shape): 224.76,101.82 224.95,101.66 225.14,101.5 225.36,101.33 225.58,101.16 225.65,101.08 225.79,100.99 226.73,100.29 227.69,99.61 227.75,99.57 227.82,99.53 228.07,99.36 228.31,99.21 228.37,99.15 228.45,99.11 228.76,98.92 229.07,98.73 229.14,98.67 229.23,98.62 229.28,98.6 229.31,98.57 229.34,98.56 229.59,98.41 229.85,98.26 229.91,98.21 229.98,98.18 230.4,97.94 230.82,97.71 230.82,97.34 230.74,97.26 230.74,96.55 230.71,96.53 229.95,96.53 229.77,96.7 226.6,96.7 225.53,97.77 222.99,97.77 222.87,97.9 222.87,101.58 223.1,101.82
GND on TOP (solid shape): 181,80.35 181.3,80.32 181.37,80.26 181.45,80.24 181.75,79.83 182.11,80.18 182.2,80.27 183,80.27 183.16,80.11 183.16,79.29 183.08,79.21 181.87,79.21 181.64,79.43 181.53,79.43 181.45,79.51 181.37,79.82 181.06,79.91 181.04,79.98 180.99,80.05
GND on TOP (solid shape): 170.37,13.04 170.37,11.32 170.52,11.18 184.96,11.18 186.62,12.83 186.62,13.41 187.13,13.93 191.97,13.93 192.19,13.7 192.19,13.03 192.34,12.88 197.01,12.88 198.2,11.69 199.36,11.69 199.75,11.3 199.75,7.04 199.57,6.86 179.15,6.86 178.77,7.24 178.77,8.01 177.72,9.07 161.69,9.07 160.89,8.27 160.89,0.91 160.54,0.56 104.09,0.56 103.86,0.78 103.86,4.43 103.94,4.51 110.66,4.51 112.05,5.89 123.2,5.89 123.84,6.54 123.84,9.87 125.37,11.4 139.7,11.4 141.01,10.09 141.01,8.01 141.73,7.3 143.87,7.3 144.41,7.84 144.41,9.01 144.95,9.55 146.71,9.55 146.9,9.75 146.9,10.54 147.06,10.7 154.45,10.7 156.81,13.07 162.58,13.07 163.42,13.91 163.54,13.91 163.55,13.91 164,14.01 164.03,14.46 164.01,14.5 164.55,15.04 168.37,15.04
GND on TOP (solid shape): 147.46,82.86 147.61,82.91 147.76,82.86 147.79,82.83 147.81,82.83 147.9,82.73 148.14,82.32 148.57,82.51 148.7,82.51 149.16,82.39 149.33,82.84 149.38,82.9 149.79,82.9 149.85,82.85 149.85,82.35 149.58,82.09 149.38,82.09 149.15,81.86 148.49,81.86 148.43,81.81 148.36,81.78 148.29,81.77 148.21,81.78 148.14,81.83 148.1,81.86 147.57,81.86 147.17,82.25 147.17,82.61 147.39,82.83 147.42,82.83
GND on TOP (solid shape): 167.48,100.28 167.48,100.13 167.04,99.7 167.04,99.24 167.15,99.14 167.17,99.14 167.4,98.91 167.4,98.68 167.07,98.35 167.07,97.87 167.43,97.51 167.43,97.31 167.04,96.93 167.04,96.5 167.45,96.09 167.45,95.13 167.68,94.9 167.99,94.9 168.02,94.86 168.02,94.32 168,94.3 167.61,94.3 167.47,94.17 167.47,93.83 167.35,93.7 167.1,93.7 166.85,93.95 166.83,94.03 166.79,94.1 166.79,94.87 166.99,95.08 166.99,95.25 166.97,95.28 166.97,96.07 166.56,96.47 166.56,96.93 166.57,96.94 166.57,97.02 166.6,97.05 166.77,97.15 166.85,97.33 166.86,97.47 166.8,97.61 166.74,97.68 166.66,97.73 166.64,97.74 166.61,97.77 166.61,98.33 166.89,98.61 166.89,98.91 166.82,98.99 166.76,99.06 166.69,99.12 166.59,99.22 166.59,99.86 166.78,99.97 166.86,100.18 167.1,100.41 167.35,100.41
GND on TOP (solid shape): outline of 88 points within 128.76,79.23 132.2,83.4
GND on TOP (solid shape): 295.59,44.44 295.64,44.42 295.69,44.4 295.73,44.35 295.73,44.35 295.75,44.19 295.84,44.07 295.88,43.99 295.84,43.91 295.76,43.79 295.74,43.65 295.7,43.6 295.58,43.55 295.54,43.57 295.47,43.61 295.39,43.62 294.98,43.62 294.91,43.52 294.74,43.47 294.6,43.56 294.56,43.62 294.5,43.62 294.45,43.67 294.45,43.69 294.42,43.81 294.35,43.91 294.32,43.99 294.36,44.06 294.39,44.08 294.46,44.11 294.53,44.08 294.61,44.03 294.7,44 294.74,44 294.94,44.02 295.09,44.15 295.24,44.15 295.55,44.46
GND on TOP (solid shape): 164.73,79.48 164.82,79.44 164.83,79.34 164.81,79.12 164.95,78.94 165,78.86 164.95,78.77 164.83,78.38 165.19,78.17 165.21,78.17 165.21,76.08 165.02,75.9 164.49,75.9 164.43,75.97 164.43,77.48 164.46,77.49 164.69,77.76 164.56,78.08 164.51,78.16 164.55,78.24 164.67,78.59 164.39,78.83 164.34,78.88 164.31,78.97 164.25,79.04 164.16,79.2 164.25,79.37 164.29,79.42 164.32,79.48
GND on TOP (solid shape): 166.07,89.04 166.07,88.78 166.17,88.68 166.17,87.95 166.09,87.87 166.09,87.44 166.31,87.23 166.31,86.62 166.05,86.36 166.05,85.4 166.23,85.22 166.28,85.22 166.29,85.21 166.58,85.16 166.81,85.34 166.84,85.36 166.84,85.37 166.97,85.5 166.97,86.31 167.04,86.39 167.35,86.39 167.45,86.29 167.45,85.35 167.63,85.17 167.78,85.17 167.79,85.17 167.91,85.14 168.04,85.17 168.05,85.17 168.09,85.17 168.2,85.28 168.26,85.28 168.26,85.35 168.3,85.38 168.3,86.37 168.12,86.55 168.12,87.07 168.26,87.21 168.26,87.55 168.27,87.59 168.26,87.66 168.47,87.86 168.72,87.86 168.87,87.71 168.87,87.27 168.82,87.21 168.82,86.36 168.87,86.31 168.87,84.69 168.82,84.64 166.54,84.64 166.36,84.46 166.36,83.88 166.28,83.8 165.77,83.8 165.77,85.07 165.7,85.14 165.7,85.28 165.66,85.32 165.58,85.49 165.66,85.66 165.7,85.7 165.7,86 165.66,86.03 165.59,86.16 165.61,86.3 165.72,86.41 165.72,87.23 165.7,87.25 165.7,87.39 165.66,87.43 165.59,87.55 165.6,87.69 165.64,87.78 165.64,88.8 165.58,88.86 165.58,89.12 165.69,89.22 165.88,89.22
GND on TOP (solid shape): outline of 143 points within 70.13,145.36 75.5,168.35
GND on TOP (solid shape): outline of 170 points within 99,180.81 126,189.4
GND on TOP (solid shape): outline of 179 points within 167.92,134.48 170.36,139.81
GND on TOP (solid shape): outline of 174 points within 172.6,79.66 175.93,82.94
GND on TOP (solid shape): outline of 172 points within 231.25,55.15 234.17,60.46
GND on TOP (solid shape): outline of 205 points within 132.49,85.39 135.67,92.54
GND on TOP (solid shape): outline of 89 points within 305.87,55.43 321.39,76.46
GND on TOP (solid shape): outline of 82 points within 89.59,107.99 97.58,124.38
GND on TOP (solid shape): outline of 233 points within 39.73,34.27 50.27,38.97
GND on TOP (solid shape): outline of 142 points within 159.93,83.76 164.91,94.14
GND on TOP (solid shape): outline of 101 points within 291.83,56.54 295.76,59.8
GND on TOP (solid shape): outline of 223 points within 165.6,82.92 172.05,104.02
GND on TOP (solid shape): outline of 355 points within 85.81,41.24 107.36,47.29
GND on TOP (solid shape): outline of 409 points within 40.33,41.91 69.7,46.77
GND on TOP (solid shape): outline of 398 points within 39.14,50.35 69.66,58.24
GND on TOP (solid shape): outline of 396 points within 157.14,93.69 163.26,104.12
GND on TOP (solid shape): outline of 451 points within 81.13,106.03 86.32,117.99
GND on TOP (solid shape): outline of 491 points within 39.89,62.18 108.9,76.41
GND on TOP (solid shape): outline of 437 points within 151.47,81.79 159.17,101.08
GND on TOP (solid shape): outline of 441 points within 151.47,79.66 159.17,101.08
GND on TOP (solid shape): outline of 604 points within 85.52,50.33 107.31,59.01
GND on TOP (solid shape): outline of 665 points within 146.36,106.96 154.8,115.55
GND on TOP (solid shape): outline of 675 points within 91.04,107.78 109.56,147.05
GND on TOP (solid shape): outline of 1398 points within 308.98,81.59 322.14,135.11
GND on TOP (solid shape): outline of 2626 points within 0.51,0.51 323.99,193.19
GND on TOP (solid shape): outline of 2132 points within 289.78,35.6 300.34,45.18
GND on BOTTOM (solid shape): 25.67,83.63 25.67,81.67 25.36,81.37 24.48,81.37 24.23,81.62 24.23,83.92 24.27,83.96 25.34,83.96
GND on BOTTOM (solid shape): 34.91,96.5 34.91,94.47 33.51,93.07 31.98,93.07 31.73,93.33 31.73,96.5 31.98,96.76 34.65,96.76
GND on BOTTOM (solid shape): 37.62,58.45 37.62,55.48 37.28,55.14 35.45,55.14 34.58,56.01 34.58,58.52 34.77,58.7 37.37,58.7
GND on BOTTOM (solid shape): 104.93,8.58 104.93,6.46 104.58,6.11 101.87,6.11 101.76,6.22 101.76,9.31 101.8,9.35 104.16,9.35
GND on BOTTOM (solid shape): 107.34,183.28 107.34,180.98 107.2,180.84 106.16,180.84 106.03,180.97 106.03,183.07 106.32,183.37 107.25,183.37
GND on BOTTOM (solid shape): 115.92,65.76 115.92,62.8 115.64,62.51 114.68,62.51 114.48,62.71 114.48,65.78 114.62,65.91 115.77,65.91
GND on BOTTOM (solid shape): 126.6,59.53 126.6,59.09 126.5,58.99 124.27,58.99 124.2,59.06 124.2,59.52 124.28,59.61 126.53,59.61
GND on BOTTOM (solid shape): 226.65,81.59 226.65,78.39 226.51,78.25 221.69,78.25 221.49,78.44 221.49,81.74 221.65,81.9 226.35,81.9
GND on BOTTOM (solid shape): 278.11,97.39 278.11,94.22 277.98,94.09 277.09,94.09 276.97,94.22 276.97,97.26 277.22,97.52 277.98,97.52
GND on BOTTOM (solid shape): 283.6,20.17 283.6,17.66 283.39,17.46 282.35,17.46 282.3,17.51 282.3,20.1 282.61,20.4 283.37,20.4
GND on BOTTOM (solid shape): 319,112.88 321.04,112.88 321.04,113 322.14,113 322.14,111 310.8,111 310.8,113 319,113
GND on BOTTOM (solid shape): 65.85,70.61 65.99,70.48 65.99,69.44 65.85,69.3 64.77,69.3 64.7,69.36 64.7,70.5 64.86,70.66 65.85,70.66
GND on BOTTOM (solid shape): 317.6,32.4 317.6,31.6 317.48,31.49 316.69,31.49 316.49,31.69 316.49,32.27 316.67,32.45 317.56,32.45
GND on BOTTOM (solid shape): 18.78,75.84 18.78,71.61 18.4,71.23 11.29,71.23 9.55,72.97 9.55,75.72 10.42,76.59 18.03,76.59
GND on BOTTOM (solid shape): 66.45,43.42 66.45,42 66.38,41.93 64.66,41.93 64.57,42.01 64.57,43.19 64.83,43.44 66.43,43.44
GND on BOTTOM (solid shape): 72.17,70.23 72.17,68.44 72.07,68.33 70.47,68.33 70.34,68.46 70.34,70.07 70.57,70.29 72.12,70.29
GND on BOTTOM (solid shape): 81.49,70.34 81.49,68.25 81.39,68.15 79.72,68.15 79.56,68.31 79.56,70.35 79.82,70.62 81.21,70.62
GND on BOTTOM (solid shape): 84.05,150.73 84.05,143.49 83.55,142.98 76.56,142.98 76.18,143.36 76.18,146.92 78.09,148.83 78.09,150.22 79.23,151.37 83.42,151.37
GND on BOTTOM (solid shape): 106.55,156.98 106.55,155.74 106.52,155.71 105.02,155.71 104.85,155.88 104.85,156.95 104.95,157.06 106.48,157.06
GND on BOTTOM (solid shape): 227.82,19.79 228.71,19.79 228.83,19.67 228.83,17.63 228.71,17.51 225.79,17.51 225.53,17.76 225.53,20.05 225.79,20.3 227.31,20.3
GND on BOTTOM (solid shape): 262.09,29.39 262.09,25.87 261.63,25.42 258.93,25.42 257.83,26.52 256.52,29.57 256.52,31.68 256.82,31.99 259.49,31.99
GND on BOTTOM (solid shape): 283.5,45.14 283.5,43.92 283.38,43.8 280.27,43.8 280.14,43.92 280.14,45.14 280.34,45.33 283.31,45.33
GND on BOTTOM (solid shape): 299.8,78.16 299.8,76.82 299.73,76.74 294.93,76.74 294.75,76.92 294.75,77.83 294.85,77.93 296.09,77.93 296.4,78.24 299.73,78.24
GND on BOTTOM (solid shape): 307.68,19.18 307.68,17.56 307.57,17.46 306.48,17.46 306.16,17.77 305.67,17.77 305.52,17.93 305.52,19.11 305.82,19.41 307.45,19.41
GND on BOTTOM (solid shape): 12.78,56.75 12.78,47.23 12.53,46.97 10.95,46.97 9.61,48.32 9.61,55.81 10.78,56.98 12.55,56.98
GND on BOTTOM (solid shape): 54.48,125.88 54.48,124.76 54.18,124.47 53.57,124.47 53.42,124.62 53.42,125.33 53.19,125.56 53.19,125.84 53.3,125.94 54.41,125.94
GND on BOTTOM (solid shape): 97.95,70.62 97.95,69.51 97.72,69.28 95.48,69.28 95.36,69.39 95.36,70.45 95.69,70.78 97.79,70.78
GND on BOTTOM (solid shape): 111.04,190.74 111.04,188.48 110.93,188.37 110.33,188.37 110.28,188.42 110.28,190.73 110.42,190.87 110.48,190.89 110.53,190.91 110.87,190.91
GND on BOTTOM (solid shape): 209.81,48.22 209.81,46.82 208.26,45.27 207.37,45.27 207.17,45.47 207.17,48.9 207.47,49.21 208.82,49.21
GND on BOTTOM (solid shape): 75.09,68.15 75.09,67.77 74.94,67.62 74.56,67.62 74.19,67.24 73.9,67.24 73.51,67.63 73.02,67.63 72.93,67.72 72.93,68.17 72.99,68.23 75.02,68.23
GND on BOTTOM (solid shape): 169.14,156.7 169.14,146.98 169.74,146.39 169.74,144.02 169.33,143.62 157.46,143.62 156.7,144.38 156.7,156.57 157.21,157.08 168.76,157.08
GND on BOTTOM (solid shape): 287.21,94.94 287.21,94.04 287.13,93.96 287.13,91.29 287,91.17 286.24,91.17 286.11,91.29 286.11,93.83 285.73,94.22 285.73,94.98 285.86,95.1 287.05,95.1
GND on BOTTOM (solid shape): 60.69,101.71 60.69,100.82 60.43,100.57 60.31,100.57 59.67,99.93 59.54,99.93 58.65,100.82 58.53,100.82 56.37,102.98 56.37,103.49 56.62,103.74 58.65,103.74
GND on BOTTOM (solid shape): 19.03,83.9 19.03,81.31 18.47,80.75 14.8,80.75 13.95,81.6 13.95,83.53 14.25,83.83 16.53,83.83 16.76,84.05 18.88,84.05
GND on BOTTOM (solid shape): 69.48,43.16 69.48,42.86 69.77,42.57 69.77,42.01 69.72,41.96 68.6,41.96 68.53,42.02 68.53,42.55 68.92,42.93 68.92,43.21 69.04,43.34 69.3,43.34
GND on BOTTOM (solid shape): 77.85,68.29 77.85,67.79 77.77,67.71 77.26,67.71 76.96,68.01 76.78,68.01 76.74,68.01 76.7,68.01 76.63,68.01 76.47,68.17 76.47,68.45 76.58,68.56 77.57,68.56
GND on BOTTOM (solid shape): 93.21,63.35 93.21,61.24 93.02,61.05 91.99,61.05 91.83,61.2 91.83,61.44 92.32,61.93 92.32,63.01 92.08,63.25 92.08,63.74 92.12,63.78 92.78,63.78
GND on BOTTOM (solid shape): 106.15,160.76 106.15,158.1 106.03,157.97 105.03,157.97 104.77,158.23 104.77,160.2 104.95,160.37 105.26,160.37 105.52,160.63 105.52,160.76 105.64,160.89 106.03,160.89
GND on BOTTOM (solid shape): 116.38,59.87 116.38,59.03 116.07,58.72 110.98,58.72 110.77,58.92 110.77,59.82 111.23,60.28 111.23,61.22 110.85,61.6 110.85,62.26 110.99,62.39 113.86,62.39
GND on BOTTOM (solid shape): 142.22,156.49 142.22,146.5 143.25,145.47 143.25,144.06 142.98,143.78 136.82,143.78 135.34,145.26 135.34,149.28 134.43,150.19 134.43,155.49 135.77,156.83 141.88,156.83
GND on BOTTOM (solid shape): 209.88,151.73 209.88,143.45 209.59,143.17 205.3,143.17 202.74,145.73 201.29,145.73 201.1,145.92 201.1,152.28 201.27,152.45 209.15,152.45
GND on BOTTOM (solid shape): 217.99,48.72 217.99,48.44 217.91,48.37 217.91,48.11 217.56,47.76 216.8,47.76 216.67,47.89 216.67,48.27 217.05,48.65 217.58,48.65 217.71,48.78 217.94,48.78
GND on BOTTOM (solid shape): 75.91,142.62 83.15,142.62 86.72,139.05 86.72,137.78 86.47,137.52 72.8,137.52 71.99,138.34 66.07,138.34 65.74,138.67 65.74,142.32 66.58,143.16 75.37,143.16
GND on BOTTOM (solid shape): 81.71,42.77 81.71,41.87 81.66,41.82 81.26,41.82 81.21,41.87 81.21,42.55 81.18,42.58 80.56,42.58 80.4,42.74 80.4,42.86 80.53,43 81.48,43
GND on BOTTOM (solid shape): 110.39,28.03 110.95,27.46 110.95,18.37 108.84,16.26 98.29,16.26 97.11,17.44 97.11,18.9 101.26,23.06 101.26,25.73 103.59,28.05 110.36,28.05
GND on BOTTOM (solid shape): 127.92,133.78 127.92,130.77 127.84,130.69 125.99,130.69 125.84,130.84 125.84,132.19 125.58,132.44 125.28,132.75 125.28,135.44 125.48,135.64 126.06,135.64
GND on BOTTOM (solid shape): 151.12,143.15 151.12,141.17 150.86,140.91 150.39,140.91 148.15,140.91 148.11,140.92 148.1,140.96 148.1,141.34 148.3,141.54 148.3,143.29 148.44,143.44 150.84,143.44
GND on BOTTOM (solid shape): 126.85,124.95 128,124.95 128.12,124.82 128.12,123.68 127.95,123.5 124.54,123.5 123.35,122.31 120.63,122.31 120.5,122.44 120.5,124.95 120.76,125.2 126.6,125.2
GND on BOTTOM (solid shape): 188.83,154.84 188.83,151.98 189.2,151.61 191.23,151.61 191.34,151.5 191.34,146.43 190.53,145.63 187.51,145.63 185.65,143.77 185.4,143.77 185.4,143.77 181.04,143.77 180.78,144.03 180.78,157.13 181,157.34 186.33,157.34
GND on BOTTOM (solid shape): 294.99,42.49 294.99,41.14 294.98,41.13 294.98,40.85 294.93,40.79 294.55,40.79 294.43,40.92 293.65,40.92 293.2,41.37 293.2,41.71 293.3,41.82 293.73,41.82 293.88,41.97 293.88,42.48 293.96,42.55 294.92,42.55
GND on BOTTOM (solid shape): 10.42,61.6 15.14,61.6 15.47,61.93 15.73,61.93 15.96,61.7 15.96,60.89 15.77,60.7 15.37,60.7 15.15,60.92 7.6,60.92 7.55,60.96 7.55,61.67 7.84,61.96 9.12,61.96 9.44,62.28 9.74,62.28
GND on BOTTOM (solid shape): 10.11,78.09 17.92,78.09 18.21,77.8 18.21,77.08 18.05,76.92 15.09,76.92 14.89,77.12 7.43,77.12 7.29,77.26 7.29,77.9 7.47,78.09 7.49,78.09 7.9,78.5 9.7,78.5
GND on BOTTOM (solid shape): 135.62,8.49 135.62,6.33 135.49,6.2 131.43,6.2 131.3,6.08 106.1,6.08 106,6.18 106,8.13 106.24,8.36 113.14,8.36 114.41,7.09 125.33,7.09 126.6,8.36 131.2,8.36 132.11,9.28 134.83,9.28
GND on BOTTOM (solid shape): 195.86,177.86 195.86,173.21 195.76,173.11 192.81,173.11 192.73,173.2 192.73,174.74 192.56,174.91 190.43,174.91 190.07,174.56 190.07,173.25 189.93,173.11 186.63,173.11 186.4,173.34 186.4,175.36 186.51,175.47 186.51,178.17 186.81,178.47 195.25,178.47
GND on BOTTOM (solid shape): 97.64,150.86 97.64,146.79 97.9,146.54 99.42,146.54 99.68,146.29 99.68,142.73 101.81,140.59 104.62,140.59 104.72,140.5 104.72,139.07 104.27,138.62 100.23,138.62 96.12,142.73 92.06,142.73 91.29,143.49 91.29,150.86 91.8,151.37 97.14,151.37
GND on BOTTOM (solid shape): 171.86,135.46 172.57,135.46 172.62,135.41 172.62,135.06 172.58,135.02 171.64,135.02 171.55,135.11 171.38,135.11 171.33,135.16 170.88,135.16 170.83,135.21 170.37,135.21 170.32,135.26 170.32,135.41 170.36,135.45 170.4,135.49 170.6,135.49 170.66,135.55 171.77,135.55
GND on BOTTOM (solid shape): 203.25,76.67 203.25,75.55 203.31,75.5 203.31,75.49 203.33,75.47 203.38,75.42 203.4,75.39 203.42,75.36 203.42,75.18 203.41,75.17 203.4,75.13 203.4,74.28 203.32,74.21 203.02,74.21 202.83,74.4 202.83,76.44 202.91,76.51 202.91,76.75 202.99,76.83 203.09,76.83
GND on BOTTOM (solid shape): 74.02,160.61 74.02,151.24 72.75,149.97 72.75,146.29 72.62,146.16 71.74,146.16 71.61,146.29 71.61,146.79 71.35,147.05 70.85,147.05 70.47,146.67 70.47,146.29 70.34,146.16 69.32,146.16 69.2,146.29 69.2,147.3 69.45,147.56 70.47,147.56 70.72,147.81 70.72,161.4 71.1,161.78 72.85,161.78
GND on BOTTOM (solid shape): 300.4,89.16 300.5,89.17 300.78,89.17 300.95,89.01 300.95,88.12 300.51,88.12 300.49,88.15 300.49,88.6 300.46,88.63 300.08,88.63 300.06,88.6 300.06,88.09 299.6,88.09 299.6,88.53 299.57,88.55 299.42,88.55 299.19,88.78 299.19,89 299.37,89.17 300.3,89.17
GND on BOTTOM (solid shape): 176.19,135.91 176.28,135.82 176.45,135.82 176.58,135.7 177.28,135.7 177.36,135.62 177.36,135.61 177.41,135.52 177.49,135.46 177.49,135.33 177.43,135.28 177.22,135.28 177.19,135.3 176.47,135.3 176.31,135.47 175,135.47 174.93,135.53 174.93,135.89 174.97,135.93 176.14,135.93
GND on BOTTOM (solid shape): 276.52,19.86 276.52,17.81 277.39,16.94 278.2,16.94 278.45,16.68 278.45,14.56 278.17,14.27 274.34,14.27 274.18,14.43 274.18,16.97 274.04,17.11 272.93,17.11 272.86,17.19 272.86,18.71 272.52,19.04 272.52,19.88 272.52,19.88 272.52,20.09 272.66,20.23 276.15,20.23
GND on BOTTOM (solid shape): 236.96,19.67 236.96,17.63 236.84,17.51 236.58,17.51 236.2,17.13 236.2,16.36 235.57,15.73 235.57,14.71 235.31,14.46 232.52,14.46 232.39,14.59 232.39,15.73 232.52,15.86 234.3,15.86 234.55,16.11 234.55,16.75 235.18,17.38 235.18,19.67 235.31,19.79 236.84,19.79
GND on BOTTOM (solid shape): 99.58,173.72 102.13,173.72 102.71,173.14 102.71,171.89 102.57,171.76 102,171.76 101.78,171.54 101.78,170.99 101.36,170.57 101.36,169.22 101.71,168.87 103.88,168.87 103.91,168.84 103.91,168.67 103.88,168.64 101.66,168.64 101.36,168.34 101.36,168.34 101.21,168.19 96.92,168.19 96.45,168.67 96.45,173.85 96.6,174 99.3,174
GND on BOTTOM (solid shape): 110.17,75.42 110.17,67.04 108.98,65.85 106.4,65.85 106.4,65.89 104.75,67.55 103.83,67.55 103.83,67.56 103.74,67.64 103.74,71.72 103.18,72.28 103.18,73.16 103.37,73.34 104.28,73.34 104.4,73.22 104.4,68.29 104.57,68.12 105.96,68.12 106.28,68.44 106.28,69.65 106.08,69.86 106.08,75.34 107.09,76.36 109.23,76.36
GND on BOTTOM (solid shape): 161.36,135.78 161.78,135.78 162.02,135.54 162.03,135.53 162.08,135.46 162.15,135.4 162.15,135.28 162.08,135.21 161.89,135.21 161.84,135.23 161.78,135.23 161.6,135.41 161.27,135.41 161.27,135.4 161.09,135.4 160.55,135.94 159.5,135.94 159.42,136.02 159.42,136.39 159.45,136.41 160.73,136.41
GND on BOTTOM (solid shape): 119.61,154.88 119.61,153.58 119.89,153.3 121.03,153.3 121.85,152.48 121.85,149.82 121.64,149.61 120.29,149.61 119.93,149.25 119.14,149.25 118.94,149.44 118.94,149.99 118.91,150.02 118.78,150.02 118.75,149.99 118.75,148.92 118.73,148.9 118.56,148.9 118.55,148.92 118.55,150 118.25,150.3 118.25,154.85 118.38,154.97 119.52,154.97
GND on BOTTOM (solid shape): 210.82,181.74 210.82,174 210.67,173.85 210.1,173.85 209.93,174.02 209.93,174.6 209.79,174.75 208.23,174.75 207.95,174.47 207.95,173.29 207.71,173.05 205.86,173.05 205.86,173.06 204.61,173.06 204.4,173.27 204.4,174.12 203.89,174.63 202.31,174.63 201.85,174.16 201.85,173.22 201.74,173.12 198.8,173.12 198.8,177.88 202.76,181.84 210.72,181.84
GND on BOTTOM (solid shape): 220.29,98.87 220.29,98.38 220.18,98.27 219,98.27 218.96,98.22 218.96,97.71 218.99,97.67 220.26,97.67 220.32,97.61 220.32,97.07 220.26,97 219.03,97 218.94,96.92 218.94,96.5 219.01,96.43 220.2,96.43 220.27,96.35 220.27,96.02 219.54,95.29 217.61,95.29 217.36,95.54 217.36,98.84 217.49,98.97 220.2,98.97
GND on BOTTOM (solid shape): 309.44,90.88 309.46,90.84 309.48,90.71 309.43,90.58 309.38,90.53 309.33,90.5 309.23,90.46 309.23,90.38 309.05,90.2 309.05,89.69 308.8,89.45 307.7,89.45 307.4,89.75 307.4,89.97 307.58,90.15 308.12,90.15 308.93,90.97 309.35,90.97
GND on BOTTOM (solid shape): 119.1,166.62 119.1,161.8 119.05,161.76 118.93,161.45 119.1,161.16 119.1,158.77 118.24,157.91 116.48,157.91 116.25,158.14 116.25,159.26 117.44,160.45 117.44,165.57 116.5,166.51 116.5,167.18 116.92,167.61 118.11,167.61
GND on BOTTOM (solid shape): 203.35,111.91 203.4,111.85 203.47,111.8 203.48,111.79 203.48,110.67 203.49,110.65 203.49,110.57 203.6,110.54 203.8,110.34 203.8,110.18 203.79,110.16 203.69,110.07 203.67,110.05 203.66,110.03 203.63,110 203.62,109.97 203.62,109.37 203.56,109.31 203.2,109.31 203.09,109.42 203.09,110.83 203.11,110.84 203.11,111.51 203.16,111.56 203.16,111.87 203.2,111.91
GND on BOTTOM (solid shape): 265.39,67.16 266.33,67.16 266.68,66.81 266.68,60.76 265.51,59.6 264.24,59.6 263.46,60.38 263.46,61.63 262.9,62.19 262.75,62.55 262.39,62.7 262.08,63 262.08,65.82 262.72,66.45 262.72,67.47 262.74,67.49 265.06,67.49
GND on BOTTOM (solid shape): 74.53,176.26 74.53,171.73 74.43,171.58 74.4,171.41 74.4,169.78 73.13,168.51 73.13,164.95 72.88,164.7 71.99,164.7 71.86,164.83 71.86,165.34 71.61,165.59 71.1,165.59 70.72,165.21 70.72,164.83 70.59,164.7 69.58,164.7 69.45,164.83 69.45,165.84 69.7,166.1 70.59,166.1 71.1,166.61 71.1,176.77 71.23,176.89 73.89,176.89
GND on BOTTOM (solid shape): 208.99,97.37 209.01,97.37 209.09,97.29 209.09,97.29 209.4,96.98 209.4,96.98 209.59,96.8 209.94,96.8 210.16,96.57 210.16,96.04 210.13,96.01 208.94,96.01 208.45,96.5 208.43,96.5 208.42,96.51 208.03,96.51 207.56,96.99 207.52,97.04 207.46,97.08 207.46,97.15 207.58,97.27 207.67,97.27 207.71,97.25 207.75,97.25 207.87,97.13 208.49,97.13 208.76,97.4 208.95,97.4
GND on BOTTOM (solid shape): 153.46,136.63 153.46,136.46 153.46,136.46 153.46,136.18 153.19,135.91 151.92,135.91 151.25,135.24 151.08,135.24 151.04,135.28 151.04,135.43 151.1,135.5 151.14,135.58 151.14,135.59 151.56,136.01 151.62,136.02 151.64,136.04 151.7,136.09 151.76,136.16 151.81,136.22 152.28,136.22 152.44,136.38 152.44,136.39 152.74,136.69 153.4,136.69
GND on BOTTOM (solid shape): 217.12,98.62 217.12,94.85 216.8,94.52 212.83,94.52 212.42,94.93 212.42,97.36 212.49,97.44 214.17,97.44 214.22,97.49 214.63,97.58 214.71,97.98 214.85,98.12 214.85,98.78 215.06,98.99 216.74,98.99
GND on BOTTOM (solid shape): 295.2,38.49 295.2,38.26 295.29,38.18 295.29,38.04 295.31,38.02 295.45,38.02 295.54,37.92 296.11,37.92 296.16,37.88 296.16,36.29 295.74,35.87 294.88,35.87 294.84,35.91 294.84,36.24 294.64,36.45 294.64,37.17 294.78,37.31 295.13,37.31 295.15,37.33 295.15,37.89 295.12,37.92 294.96,37.92 294.69,38.19 294.69,38.56 295.13,38.56
GND on BOTTOM (solid shape): 84.05,10.52 84.05,8.36 80.88,5.19 80.88,3.03 81.01,2.9 84.05,2.9 84.23,2.72 84.23,1.94 84.05,1.76 75.67,1.76 75.55,1.89 75.55,4.43 75.67,4.55 76.94,4.55 77.07,4.68 77.07,5.44 78.59,5.44 78.59,4.68 78.72,4.55 79.36,4.55 79.48,4.68 79.48,9.38 79.74,9.63 81.01,9.63 81.13,9.76 81.13,10.54 81.37,10.78 83.8,10.78
GND on BOTTOM (solid shape): 88.6,127.13 88.6,127.01 88.48,126.76 88.6,126.52 88.6,126.36 88.55,126.31 88.49,126.22 88.29,126.22 88.28,126.25 88.21,126.34 88.11,126.4 88.1,126.4 87.83,126.67 87.83,127.43 87.99,127.59 88.14,127.59
GND on BOTTOM (solid shape): 186.88,136.26 186.92,136.24 186.94,136.21 186.98,136.18 187.02,136.15 187.11,136.07 188.26,136.07 188.32,136.01 188.32,135.65 188.25,135.59 186.2,135.59 185.88,135.28 185.78,135.28 185.65,135.4 185.65,135.45 185.67,135.46 185.73,135.52 185.78,135.6 185.78,135.61 185.91,135.73 185.92,135.74 185.99,135.82 186.17,136 186.43,136 186.68,136.25 186.7,136.26
GND on BOTTOM (solid shape): 34.88,13.24 34.91,13.22 35.08,13.22 35.11,13.24 35.11,14.87 35.39,14.87 35.39,13.29 35.77,12.91 35.77,12.58 35.67,12.48 34.22,12.48 34.1,12.54 33.97,12.55 32.87,12.55 32.7,12.73 32.7,14.31 32.8,14.41 33.46,14.41 33.53,14.33 33.53,13.39 33.64,13.29 34.07,13.29 34.12,13.34 34.12,14.84 34.37,14.84 34.37,13.24 34.4,13.22 34.58,13.22 34.6,13.24 34.6,14.87 34.88,14.87
GND on BOTTOM (solid shape): 86.21,127.19 86.21,126.98 86.12,126.76 86.21,126.54 86.21,126.33 86.19,126.31 86.17,126.28 86.09,126.2 85.94,126.2 85.93,126.21 85.86,126.32 85.75,126.4 85.74,126.4 85.43,126.71 85.43,127.43 85.5,127.49 85.55,127.56 85.85,127.56
GND on BOTTOM (solid shape): 295.45,40.74 296.01,40.74 296.08,40.67 296.08,39.45 296.26,39.26 296.26,39.09 296.17,39 296.04,39 295.89,39.15 295.89,39.25 295.7,39.25 295.68,39.28 295.52,39.42 295.3,39.43 294.93,39.43 294.82,39.53 294.83,39.53 294.83,39.86 294.96,40 295.14,40 295.28,40.14 295.28,40.67 295.35,40.74
GND on BOTTOM (solid shape): 156.12,52.66 156.23,52.66 156.24,52.65 156.32,52.62 156.41,52.64 156.42,52.64 156.84,52.64 156.87,52.61 156.99,52.61 157.01,52.59 157.24,52.59 157.34,52.5 157.34,52.39 157.27,52.33 157.23,52.25 157.16,52.18 156.88,52.18 156.87,52.19 156.16,52.19 156.14,52.18 156,52.18 155.97,52.2 155.81,52.35 155.14,52.35 155.08,52.41 155.08,52.81 155.09,52.82 155.96,52.82
GND on BOTTOM (solid shape): 238.02,71.67 238.01,71.64 237.98,71.46 238.05,71.3 238.06,71.28 238.06,71.12 238.05,71.11 237.98,70.89 238.06,70.68 238.06,70.11 238.33,69.83 238.33,69.65 238.61,69.37 238.61,69.27 238.51,69.17 237.93,69.17 237.57,69.53 237.22,69.53 237.04,69.7 237.04,71.25 237.57,71.79 237.9,71.79
GND on BOTTOM (solid shape): 78.85,179.43 78.85,178.54 79.23,178.16 89.34,178.16 89.58,177.92 89.58,176.55 89.85,176.28 89.85,175.09 89.67,174.91 88.35,174.91 87.99,174.56 87.99,173.74 87.84,173.59 86.85,173.59 86.72,173.72 86.72,174.89 86.47,175.14 86.47,175.37 85.32,176.51 82.53,176.51 82.15,176.13 77.7,176.13 77.45,176.38 77.45,177.15 77.58,177.27 77.96,177.27 78.21,177.53 78.21,178.29 77.96,178.54 77.58,178.54 77.45,178.67 77.45,179.56 77.58,179.69 78.59,179.69
GND on BOTTOM (solid shape): 238.62,49.29 238.62,49.25 238.72,49.15 238.72,49.09 238.71,48.99 238.73,48.9 238.73,48.88 238.73,48.8 238.83,48.7 238.94,48.7 239,48.69 239.59,48.11 239.59,47.74 239.5,47.66 238.95,47.66 238.62,48 238.59,48.01 238.53,48.07 238.51,48.1 238.5,48.11 238.5,48.28 238.41,48.36 238.41,49.03 238.42,49.04 238.42,49.24 238.47,49.29 238.61,49.29
GND on BOTTOM (solid shape): 45.14,74.51 45.14,67.64 45.41,67.37 48.27,67.37 48.35,67.29 48.35,65.84 45.34,65.84 45.27,65.77 45.27,63.75 45.66,63.36 45.66,63.15 45.49,62.98 45.18,62.98 44.98,63.19 44.98,65.73 44.87,65.84 41.84,65.84 41.77,65.77 41.77,63.27 41.68,63.18 41.58,63.18 41.32,62.92 41.32,62.82 41.04,62.54 40.64,62.54 40.51,62.68 40.51,63.19 40.8,63.49 41.18,63.49 41.48,63.78 41.48,65.73 41.37,65.84 39.64,65.84 38.39,67.1 38.39,74.97 39.5,76.08 43.57,76.08
GND on BOTTOM (solid shape): 83.88,127.13 83.88,127.01 83.76,126.76 83.88,126.52 83.88,126.36 83.83,126.31 83.76,126.22 83.57,126.22 83.56,126.23 83.5,126.33 83.4,126.39 83.4,126.39 83.09,126.7 83.09,127.45 83.15,127.5 83.2,127.58 83.24,127.62 83.39,127.62
GND on BOTTOM (solid shape): 176.1,137.63 176.23,137.63 176.54,137.32 176.54,137.28 176.58,137.24 176.58,137.24 176.64,137.15 176.72,137.09 176.73,137.09 176.77,137.05 176.81,137.05 176.9,136.96 177.31,136.96 177.37,136.89 177.37,136.89 177.43,136.81 177.5,136.74 177.5,136.66 177.44,136.61 177.39,136.55 176.81,136.55 176.23,137.13 175.94,137.13 175.69,137.38 174.94,137.38 174.85,137.47 174.85,137.79 174.9,137.84 175.9,137.84
GND on BOTTOM (solid shape): 300.61,46.69 300.64,46.68 300.66,46.64 300.66,45.54 300.64,45.51 300.61,45.49 300.05,45.49 299.54,44.99 299.54,43.42 299.53,43.39 299.49,43.37 298.94,43.37 298.93,43.36 298.66,43.36 298.51,43.52 298.51,44.92 299.77,46.19 300.03,46.19 300.12,46.27 300.13,46.29 300.13,46.64 300.15,46.68 300.18,46.69
GND on BOTTOM (solid shape): 206.07,112.42 206.05,112.36 206.04,112.35 205.97,112.29 205.93,112.21 205.92,112.2 205.9,112.18 205.9,112.08 205.9,112 205.92,111.97 205.99,111.86 206.1,111.78 206.1,111.78 206.13,111.76 206.13,110.72 206.24,110.61 206.24,109.31 206.17,109.24 205.8,109.24 205.72,109.32 205.72,111.71 205.42,112.01 205.42,112.15 205.71,112.43 205.72,112.44 205.79,112.48 205.85,112.55 205.95,112.55
GND on BOTTOM (solid shape): 210.9,120.58 210.9,119.9 210.79,119.8 209.85,119.8 209.76,119.71 209.76,119.24 209.55,119.04 208.63,119.04 208.58,119.03 208.53,119.01 208.15,119.01 208.08,119.09 208.01,119.16 208.01,119.32 208.04,119.35 208.06,119.37 208.13,119.44 208.98,119.44 208.99,119.45 209.14,119.45 209.25,119.56 209.25,120.19 209.27,120.23 209.29,120.27 209.34,120.31 209.41,120.35 209.49,120.37 209.62,120.37 209.67,120.41 209.8,120.41 210.08,120.69 210.78,120.69
GND on BOTTOM (solid shape): 42.97,41.96 43.07,41.86 43.68,41.86 43.76,41.93 43.76,42.35 43.76,42.35 43.76,43.28 43.76,43.31 43.76,43.35 43.76,43.52 43.72,43.56 53.57,43.56 53.6,43.53 53.6,43.18 53.49,43.07 53.05,43.07 53.01,43.03 53.01,41.96 53.13,41.84 53.15,41.82 54.4,41.82 54.55,41.98 54.55,43.19 54.34,43.4 54.34,43.51 54.4,43.56 63.36,43.56 63.71,43.21 63.71,42.98 63.58,42.86 62.87,42.86 62.77,42.76 62.77,41.9 62.13,41.27 42.99,41.27 41.18,43.08 41.18,43.52 41.22,43.56 42.97,43.56
GND on BOTTOM (solid shape): 74.14,128.94 75.02,128.94 75.58,128.38 75.6,128.29 75.55,128.22 75.49,128.18 75.44,128.12 75.36,128.08 75.27,128.11 74.93,128.21 74.73,127.92 74.5,127.69 73.77,127.69 73.63,127.83 73.63,128.86 73.53,128.96 73.53,129.1 73.64,129.21 73.87,129.21
GND on BOTTOM (solid shape): 102.67,127.32 102.67,127.31 102.72,127.22 102.8,127.15 102.8,127.02 102.66,126.76 102.8,126.5 102.8,126.37 102.73,126.31 102.68,126.22 102.66,126.19 102.49,126.19 102.46,126.23 102.45,126.24 102.39,126.33 102.3,126.39 102.29,126.4 101.95,126.74 101.95,127.42 102.04,127.49 102.11,127.59 102.12,127.62 102.37,127.62
GND on BOTTOM (solid shape): 282.3,101.61 284.36,101.61 284.65,101.31 285.53,100.43 285.83,100.43 286.8,101.4 288.4,101.4 288.47,101.33 288.47,100.92 288.37,100.82 288.09,100.82 288.07,100.85 287.51,100.85 287.36,100.69 287.36,98.15 286.95,97.74 286.39,97.49 286.15,96.92 285.86,96.63 283.24,96.63 283.11,96.76 283.11,97.53 283.24,97.65 283.79,97.65 284.21,98.08 284.21,99.32 283.98,99.55 279.54,99.55 279.48,99.6 279.48,102.04 279.66,102.22 281.69,102.22
GND on BOTTOM (solid shape): 300.27,41.68 300.27,40.65 300.04,40.57 299.85,40.71 299.85,40.95 299.81,40.95 299.81,40.95 298.26,40.95 298.23,40.95 298.23,40.92 298.16,40.85 298.16,40.35 298.13,40.32 297.92,40.32 297.87,40.37 297.87,40.93 297.85,40.96 297.83,41.01 297.82,41.05 297.82,41.17 297.82,41.18 297.82,41.6 298.04,41.83 298.15,41.83 298.24,41.92 300.03,41.92
GND on BOTTOM (solid shape): 116.82,136.89 116.82,135.97 116.59,135.74 116.59,135.08 116.53,135.02 116.53,134.59 116.59,134.53 116.59,133.59 116.56,133.58 116.44,133.03 117,133.04 117.08,133.08 117.15,133.05 117.33,132.87 119.23,132.87 119.37,132.74 119.37,130.51 119.03,130.17 116.49,130.17 113.72,132.93 113.72,136.77 114.07,137.12 116.59,137.12
GND on BOTTOM (solid shape): 205.1,87.71 205.1,86.74 205.24,86.6 205.62,86.6 205.71,86.51 205.71,86 205.7,85.99 205.7,85.37 206.08,84.99 206.1,84.96 206.13,84.94 206.13,84.78 205.82,84.47 205.75,84.42 205.7,84.36 205.59,84.36 205.51,84.44 205.51,84.55 205.58,84.62 205.63,84.7 205.65,84.72 205.65,84.75 205.62,84.99 205.43,85.15 205.42,85.15 205.3,85.27 205.3,85.84 205.08,86.06 204.59,86.06 204.4,86.25 204.4,86.4 204.55,86.54 204.55,87.79 204.56,87.81 205,87.81
GND on BOTTOM (solid shape): 20.38,14.56 20.38,13.44 20.45,13.37 20.61,13.37 20.63,13.39 20.63,14.56 20.66,14.59 20.83,14.59 20.86,14.56 20.86,13.39 20.96,13.29 21.47,13.29 21.62,13.44 21.62,14.56 21.67,14.61 21.85,14.61 21.88,14.59 21.88,13.32 21.95,13.24 23.07,13.24 23.12,13.29 23.12,14.54 23.17,14.59 23.35,14.59 23.37,14.56 23.37,11.58 23.02,11.22 20.87,11.22 20.76,11.11 20.76,10.62 20.61,10.47 18.85,10.47 18.62,10.7 18.62,11.53 19.63,12.54 19.63,12.78 19.64,12.78 19.64,14.54 19.69,14.59 19.84,14.59 19.87,14.56 19.87,13.44 19.92,13.39 20.1,13.39 20.12,13.42 20.12,14.56 20.17,14.61 20.33,14.61
GND on BOTTOM (solid shape): 203.09,95.99 203.14,95.93 203.21,95.88 203.21,95.56 203.29,95.47 203.29,95.4 203.68,95.01 203.77,95 203.91,94.85 203.92,94.83 203.92,94.77 203.99,94.7 203.99,94.5 204.56,93.93 204.56,93.04 204.74,92.87 204.74,92.81 204.79,92.78 204.91,92.6 204.85,92.4 204.82,92.37 204.76,92.34 204.7,92.31 204.61,92.31 204.56,92.33 204.51,92.35 204.07,92.79 203.38,92.79 203.32,92.85 203.32,93.22 203.38,93.27 203.86,93.27 203.92,93.32 203.92,93.62 203.52,94.01 203.52,94.74 202.91,95.35 202.91,95.9 202.99,95.99
GND on BOTTOM (solid shape): 205.7,96.63 205.78,96.55 205.88,96.49 205.89,96.49 206.16,96.22 206.16,96.07 206.02,95.83 206.16,95.59 206.16,95.42 206.15,95.4 206.15,95.1 206.16,95.09 206.16,94.96 206.85,94.27 206.85,93.31 206.78,93.24 206.07,93.24 205.98,93.33 205.98,95.33 205.77,95.54 205.77,95.54 205.63,95.68 205.63,95.68 205.54,95.77 205.54,95.9 205.6,95.97 205.65,96.06 205.65,96.08 205.67,96.1 205.67,96.28 205.59,96.36 205.56,96.39 205.53,96.42 205.53,96.54 205.62,96.63
GND on BOTTOM (solid shape): 298.26,39.35 299.53,39.35 299.83,39.05 300.25,39.05 300.42,38.88 300.42,38.46 300.76,38.12 303.12,38.12 303.33,37.91 303.33,32.85 304.14,32.04 304.72,32.04 305.03,31.73 305.03,28.94 305.48,28.49 307.61,28.49 308.02,28.09 308.02,24.75 307.23,23.95 304.48,22.77 304.4,22.69 299.93,22.69 299.78,22.84 299.78,24.87 299.17,25.48 299.17,29.07 298.63,29.61 298.63,30.53 299.17,31.07 299.17,32.01 299.29,32.14 299.78,32.14 300.11,32.47 300.11,33.23 300.47,33.59 300.47,35.18 299.93,35.72 299.93,37.73 299.17,38.5 298.85,38.5 298.58,38.78 298.44,38.78 298.39,38.82 297.63,38.82 297.56,38.87 297.49,38.9 297.29,39.1 297.29,39.22 297.41,39.35 298.25,39.35
GND on BOTTOM (solid shape): 105.03,127.29 105.11,127.2 105.17,127.15 105.18,127.14 105.18,127.03 105.02,126.76 105.18,126.49 105.18,126.38 105.1,126.32 105.05,126.25 105.01,126.22 104.85,126.22 104.82,126.22 104.81,126.25 104.74,126.34 104.65,126.4 104.64,126.4 104.36,126.68 104.36,126.8 104.36,127.38 104.36,127.44 104.51,127.59 104.53,127.6 104.72,127.6
