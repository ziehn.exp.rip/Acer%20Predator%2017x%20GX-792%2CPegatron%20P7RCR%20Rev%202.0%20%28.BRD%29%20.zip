# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_IFPD_DATA2: length 168
  TOP w0.108: C1409.1 256.88,44.63 256.24,44.63 256.04,44.84 256.04,44.97 v2(256.44,45.37)
  IN2 w0.095: v2(138.38,83.48) 138.62,83.24 138.62,83.04 138.54,82.96 138.31,82.96 138.18,82.83 138.18,82.38 138.43,82.13 138.43,79.49 138.79,79.13 138.79,78.47 138,77.68 138,76.43 136.73,75.16 136.73,69.48 137.27,68.94 137.27,60.13 138.69,58.71 138.69,56.98 142.55,53.12 142.55,51.54 147.9,46.2 148.61,46.2 154.58,40.23 193.2,40.23 193.39,40.42 239.81,40.42 240.53,41.14 242.91,41.14 243.22,41.44 245.99,41.44 246.92,42.37 247.17,42.37 247.47,42.08 247.64,42.08 247.93,42.37 247.93,42.51 247.63,42.81 247.63,43.09 248.02,43.48 248.35,43.48 248.59,43.24 248.75,43.24 248.95,43.44 248.95,43.59 248.72,43.82 248.72,44.18 249.33,44.79 252.04,44.79 253.57,46.32 255.19,46.32 255.7,45.8 256.01,45.8 v2(256.44,45.37)
  BOTTOM w0.108: U7000.BM12 143.56,83.56 140.35,83.56 139.74,82.94 138.43,82.94 138.21,83.16 138.21,83.32 v2(138.38,83.48)
DP_IFPD_DATA2#: length 168
  TOP w0.108: C1403.1 257.06,44.4 256.14,44.4 255.8,44.74 255.8,45.07 v2(255.8,45.37)
  IN2 w0.095: v2(137.77,83.48) 137.94,83.3 137.94,82.29 138.2,82.04 138.2,79.39 138.56,79.03 138.56,78.57 137.77,77.78 137.77,76.53 136.5,75.26 136.5,69.38 137.03,68.85 137.03,60.03 138.46,58.61 138.46,56.88 142.32,53.02 142.32,51.45 147.8,45.97 148.51,45.97 154.48,40 193.3,40 193.49,40.18 239.91,40.18 240.62,40.9 243.01,40.9 243.32,41.21 246.08,41.21 247.02,42.14 247.08,42.14 247.37,41.84 247.73,41.84 248.16,42.27 248.16,42.61 247.87,42.9 247.87,42.99 248.12,43.24 248.25,43.24 248.49,43 248.85,43 249.19,43.34 249.19,43.69 248.96,43.92 248.96,44.08 249.43,44.55 252.13,44.55 253.66,46.08 255.09,46.08 v2(255.8,45.37)
  BOTTOM w0.108: U7000.BM11 143.47,83.33 140.45,83.33 139.83,82.71 138.33,82.71 137.98,83.06 137.98,83.27 v2(137.77,83.48)
DP_IFPD_DATA3: length 169.8
  TOP w0.108: 254.69,43.4 254.18,43.4 253.83,43.75 v2(253.83,43.75) ; 254.69,43.4 255.22,43.4 256.09,42.52 256.8,42.52 C1404.1 ; 254.69,43.4 v1(254.69,43.62)
  IN2 w0.095: v2(137.47,82.91) 137.06,82.51 137.06,82.33 137.33,82.07 137.33,80.45 135.88,79.01 135.88,67.77 136.41,67.24 136.41,59.55 137.47,58.49 137.47,56.29 139.72,54.04 139.72,53.22 147.48,45.46 147.69,45.46 153.37,39.79 153.37,39.52 153.88,39.01 193.19,39.01 193.96,38.24 194.88,38.24 195.65,39.01 196.7,39.01 231.04,39.01 231.61,39.59 235.04,39.59 235.61,39.01 238.45,39.01 239.1,39.66 240.14,39.66 240.88,40.4 243.27,40.4 243.57,40.7 247.6,40.7 250.33,43.42 251.24,43.42 251.7,43.87 253.37,43.87 253.75,44.25 254.03,44.25 254.16,44.13 254.16,43.83 254.08,43.75 v2(253.83,43.75)
  BOTTOM w0.108: U7000.BL11 144.27,83.05 143.95,82.73 143.47,82.73 143.31,82.89 140.95,82.89 140.16,82.1 137.41,82.1 137.15,82.37 137.15,82.59 v2(137.47,82.91)
DP_IFPD_DATA3#: length 169.8
  TOP w0.108: v1(256.47,42.06) 256.47,42.29 ; 256.47,42.29 256,42.29 255.12,43.16 v2(253.68,43.16) ; 256.47,42.29 257.14,42.29 C1406.1
  IN2 w0.095: v2(253.68,43.16) 253.21,43.64 251.79,43.64 251.34,43.19 250.42,43.19 247.7,40.46 243.66,40.46 243.37,40.16 240.98,40.16 240.24,39.43 239.2,39.43 238.55,38.78 235.52,38.78 234.94,39.35 231.71,39.35 231.13,38.78 196.61,38.78 195.75,38.78 194.98,38 193.86,38 193.09,38.78 153.78,38.78 153.14,39.42 153.14,39.69 147.6,45.23 147.38,45.23 139.49,53.12 139.49,53.95 137.24,56.2 137.24,58.39 136.18,59.45 136.18,67.14 135.64,67.67 135.64,79.1 137.09,80.55 137.09,81.97 136.81,82.25 v2(136.81,82.94)
  BOTTOM w0.108: v2(136.81,82.94) 136.91,82.84 136.91,82.27 137.31,81.86 140.26,81.86 141.05,82.65 143.21,82.65 143.37,82.5 144.05,82.5 144.27,82.72 144.82,82.72 U7000.BK11
DP_IFRC_AUXN: length 260.1
  TOP w0.108: v2(292.68,121.09) 292.82,121.23 SR7208.1 ; Q4601.4 289.05,119.88 289.21,120.05 R7213.1 C4627.1 290,120.2 v2(289.74,119.95)
  IN1 w0.095: v2(289.74,119.95) 289.94,119.75 290.17,119.75 290.71,119.21 290.71,117.85 290.14,117.29 288.1,117.29 282.87,112.05 282.87,109.26 282.33,108.72 282.33,107.93 280.73,106.34 280.73,104.99 280.39,104.65 279.15,104.65 273.69,99.19 272.71,99.19 268.69,95.17 265.63,95.17 263.26,92.8 263.26,92.31 262.86,91.92 261.13,91.92 258.13,88.91 254.81,88.91 253.69,87.8 252.63,87.8 251.82,88.6 244.91,88.6 240.15,83.84 240.15,82.37 239.12,81.33 229.26,81.33 228.5,80.57 221.79,80.57 219.46,78.24 212.58,78.24 209.34,75.01 204.22,75.01 201.68,72.47 199.86,72.47 189.14,61.75 189.14,54.85 187.46,53.17 187.46,46.81 186.02,45.37 170.84,45.37 170.53,45.67 161.02,45.67 160.87,45.52 154.46,45.52 149.17,50.81 149.17,52.62 147.92,53.87 146.01,53.87 145.12,54.77 145.12,55.77 144.02,56.87 144.02,57.03 139.88,61.18 139.88,63.2 140.36,63.68 140.36,64.2 140.27,64.29 138.97,64.29 138.68,64.58 138.68,65.13 138.95,65.39 140.22,65.39 140.36,65.54 140.36,66.13 139.67,66.81 139.67,68.54 139.58,68.63 138.86,68.63 138.72,68.49 138.72,66.49 138.39,66.15 137.19,66.15 135.69,67.65 135.69,68.76 135.92,69 137.22,69 137.31,69.09 137.31,69.47 137.22,69.57 135.92,69.57 135.69,69.8 135.69,70.38 135.92,70.61 137.22,70.61 137.31,70.7 137.31,71.09 137.22,71.18 135.92,71.18 135.69,71.41 135.69,77.05 135.53,77.2 135.53,79.02 136.08,79.56 137.17,79.56 139.12,81.52 139.8,81.52 140.63,82.35 141.19,82.35 141.38,82.17 141.43,82.17 v3(141.8,81.8)
  IN3 w0.095: v2(289.74,119.95) 289.74,119.64 289.85,119.53 290.54,119.53 290.75,119.75 290.75,121.07 291.62,121.93 292.24,121.93 292.53,121.64 292.53,121.23 v2(292.68,121.09)
  BOTTOM w0.108: U7000.BL9 144.28,81.65 143.96,81.97 142.99,81.97 142.89,82.07 141.88,82.07 141.8,81.99 v3(141.8,81.8)
DP_IFRC_AUXP: length 260.2
  TOP w0.108: Q4601.1 290.64,118.58 290.25,118.19 R7214.1 C4626.1 289.46,118.23 v2(289.74,118.51) ; v2(292.03,121.1) 291.93,121.2 SR7207.1
  IN1 w0.095: v2(141.19,81.8) 141.19,82.02 141.09,82.12 140.73,82.12 139.89,81.28 139.22,81.28 137.27,79.33 136.18,79.33 135.77,78.92 135.77,77.3 135.92,77.15 135.92,71.51 136.02,71.42 137.31,71.42 137.55,71.18 137.55,70.61 137.31,70.37 136.02,70.37 135.92,70.28 135.92,69.9 136.02,69.8 137.31,69.8 137.55,69.57 137.55,68.99 137.31,68.76 136.02,68.76 135.92,68.67 135.92,67.75 137.29,66.38 138.29,66.38 138.49,66.58 138.49,68.59 138.77,68.87 139.68,68.87 139.91,68.64 139.91,66.91 140.6,66.22 140.6,65.44 140.32,65.16 139.05,65.16 138.92,65.03 138.92,64.68 139.07,64.52 140.37,64.52 140.6,64.29 140.6,63.58 140.11,63.1 140.11,61.27 144.26,57.13 144.26,56.96 145.35,55.87 145.35,54.87 146.11,54.11 148.01,54.11 149.41,52.71 149.41,50.91 154.56,45.76 160.77,45.76 160.92,45.91 170.63,45.91 170.94,45.6 185.92,45.6 187.23,46.91 187.23,53.27 188.91,54.95 188.91,61.84 199.77,72.7 201.58,72.7 204.12,75.24 209.25,75.24 212.48,78.47 219.36,78.47 221.7,80.81 228.4,80.81 229.17,81.57 239.02,81.57 239.92,82.47 239.92,83.94 244.81,88.84 251.92,88.84 252.73,88.03 253.6,88.03 254.72,89.15 258.03,89.15 261.04,92.15 262.76,92.15 263.02,92.41 263.02,92.89 265.53,95.4 268.59,95.4 272.61,99.42 273.59,99.42 279.05,104.88 280.3,104.88 280.5,105.09 280.5,106.43 282.1,108.03 282.1,108.82 282.63,109.36 282.63,112.15 288,117.52 290.05,117.52 290.47,117.95 290.47,119.11 290.07,119.51 289.85,119.51 289.74,119.41 v2(289.74,118.51)
  IN3 w0.095: v2(292.03,121.1) 292.3,121.37 292.3,121.55 292.14,121.7 291.71,121.7 290.99,120.97 290.99,119.65 290.63,119.3 289.9,119.3 289.74,119.15 v2(289.74,118.51)
  BOTTOM w0.108: U7000.BK9 144.82,81.98 144.29,81.98 144.06,82.21 143.08,82.21 142.99,82.3 141.7,82.3 v2(141.19,81.8)
DP_OUT_DATA0: length 19
  TOP w0.108: v1(305.19,126.8) 305.42,126.8 ; 305.42,126.8 305.42,127.44 306.27,128.29 307.39,128.29 307.46,128.29 C4629.1 ; 305.42,126.8 305.42,126.4 305,125.98 305,122.44 305.39,122.05 305.39,119.95 302.72,117.27 302.72,116.12 301.49,114.89 300.41,114.89 300.3,115 U4601.35
DP_OUT_DATA0#: length 19
  TOP w0.108: 306.76,128.05 306.36,128.05 305.65,127.34 305.65,126.3 305.24,125.89 305.24,122.54 305.63,122.15 305.63,119.85 302.95,117.18 302.95,116.02 301.58,114.66 300.43,114.66 300.28,114.5 U4601.34 ; 306.76,128.05 v1(306.76,127.83) ; 306.76,128.05 307.38,128.05 C4631.1
DP_OUT_DATA0#_CON: length 9.1
  TOP w0.108: v1(308.31,129.49) 308.31,129.27 ; 308.31,129.27 309,129.27 309.44,128.83 309.44,128.3 309.15,128.01 308.85,128.01 C4631.2 ; 308.31,129.27 308.03,129.27 307.85,129.45 307.85,129.95 308.54,130.64 309.07,130.64 310.89,128.82 311.17,128.82 CON4601.3
DP_OUT_DATA0_CON: length 9.1
  TOP w0.108: 308.97,130.87 308.44,130.87 307.62,130.05 307.62,129.35 307.93,129.03 308.9,129.03 309.2,128.73 309.2,128.4 309.05,128.25 308.87,128.25 C4629.2 ; 308.97,130.87 309.17,130.87 310.99,129.06 311.15,129.06 CON4601.1 ; 308.97,130.87 v1(308.97,131.1)
DP_OUT_DATA1: length 17.9
  TOP w0.108: C4628.1 307.39,126.32 306.41,126.32 306.15,126.07 306.15,123.83 ; 306.15,123.83 306.15,119.62 303.54,117 303.54,115.78 301.13,113.37 300.38,113.37 300.25,113.5 U4601.32 ; 306.15,123.83 v1(305.93,123.83)
DP_OUT_DATA1#: length 17.9
  TOP w0.108: C4630.1 307.44,126.09 306.5,126.09 306.39,125.97 306.39,125.48 ; U4601.31 300.25,113 300.38,113.14 301.22,113.14 303.77,115.68 303.77,116.9 306.39,119.52 306.39,125.48 ; 306.39,125.48 v1(306.61,125.48)
DP_OUT_DATA1#_CON: length 10.2
  TOP w0.108: v2(310.01,126.83) 309.82,126.63 309.82,126.3 309.6,126.09 308.83,126.09 C4630.2
  IN1 w0.095: v2(310.01,126.83) 309.86,126.98 309.86,126.98 309.86,128.61 311.28,130.03 311.81,130.03 312.12,129.73 312.12,127.59 312.4,127.31 312.68,127.31 CON4601.6
DP_OUT_DATA1_CON: length 10.3
  TOP w0.108: C4628.2 308.88,126.32 309.51,126.32 309.58,126.4 309.58,126.63 v2(309.38,126.83)
  IN1 w0.095: CON4601.4 312.63,127.54 312.5,127.54 312.35,127.69 312.35,129.83 311.91,130.26 311.19,130.26 309.63,128.71 309.63,127.08 v2(309.38,126.83)
DP_OUT_DATA2: length 23.8
  TOP w0.108: v1(304.61,116.47) 304.83,116.47 ; 304.83,116.47 304.83,117.2 306.91,119.28 306.91,120.49 307.15,120.73 308.68,120.73 308.79,120.84 308.79,121.16 308.68,121.27 307.15,121.27 306.91,121.52 306.91,122.04 307.15,122.28 308.68,122.28 308.79,122.39 308.79,122.71 308.68,122.82 307.15,122.82 306.91,123.07 306.91,124.26 307.17,124.52 307.45,124.52 C4632.1 ; 304.83,116.47 304.83,115.73 300.97,111.87 300.38,111.87 300.25,112 U4601.29
DP_OUT_DATA2#: length 23.8
  TOP w0.108: C4633.1 307.39,124.29 307.27,124.29 307.14,124.16 307.14,123.16 307.25,123.06 308.78,123.06 309.02,122.81 309.02,122.29 308.78,122.05 307.25,122.05 307.14,121.94 307.14,121.61 307.25,121.51 308.78,121.51 309.02,121.26 309.02,120.74 308.78,120.5 307.25,120.5 307.14,120.39 307.14,120.05 ; U4601.28 300.25,111.5 300.38,111.64 301.07,111.64 305.07,115.63 305.07,117.11 307.14,119.18 307.14,120.05 ; v1(307.37,120.05) 307.14,120.05
DP_OUT_DATA2#_CON: length 4.1
  TOP w0.108: CON4601.9 311.16,125.83 310.82,125.83 310.35,125.36 310.35,124.98 309.66,124.29 308.89,124.29 C4633.2
DP_OUT_DATA2_CON: length 4.1
  TOP w0.108: CON4601.7 311.16,126.07 310.72,126.07 310.11,125.46 310.11,125.08 309.56,124.52 308.83,124.52 C4632.2
DP_OUT_DATA3: length 19.9
  TOP w0.108: v1(302.37,111.21) 302.37,110.99 ; 302.37,110.99 301.79,110.99 301.17,110.37 300.39,110.37 300.25,110.5 U4601.26 ; 302.37,110.99 303.64,110.99 304.01,111.35 304.01,111.5 303.01,112.5 303.01,112.85 303.38,113.22 303.73,113.22 304.72,112.22 304.95,112.22 305.26,112.53 305.26,112.78 304.4,113.65 304.4,113.98 304.88,114.46 305.95,114.46 306.03,114.54 306.03,117.31 308.18,119.46 308.74,119.46 C4634.1
DP_OUT_DATA3#: length 19.9
  TOP w0.108: 305.52,114.22 306.04,114.22 306.26,114.44 306.26,117.22 308.27,119.23 308.64,119.23 C4635.1 ; 305.52,114.22 v1(305.52,114) ; 305.52,114.22 304.98,114.22 304.63,113.88 304.63,113.74 305.5,112.88 305.5,112.43 305.05,111.98 304.63,111.98 303.63,112.98 303.48,112.98 303.25,112.75 303.25,112.6 304.24,111.6 304.24,111.25 303.74,110.75 301.89,110.75 301.27,110.14 300.38,110.14 300.25,110 U4601.25
DP_OUT_DATA3#_CON: length 8
  TOP w0.108: C4635.2 310.16,119.2 311.49,119.2 312.32,120.04 312.32,124.1 312.52,124.3 312.69,124.3 CON4601.12
DP_OUT_DATA3_CON: length 8
  TOP w0.108: C4634.2 310.1,119.44 311.39,119.44 312.09,120.14 312.09,124.2 312.42,124.53 312.62,124.53 CON4601.10
DP_PD#: length 2.8
  TOP w0.108: v1(268.28,51.79) R1414.2 266.85,51.33 266.85,50.96 266.52,50.63 U1401.26
DP_REQ: length 5.6
  TOP w0.102: v1(260.92,38.92) 261.07,39.07 261.26,39.07 R1405.2 R1401.1 262.45,41.05 262.45,41.86 262.92,42.34 262.92,42.7 263.02,42.8 U1401.4
DP_REXT: length 2.6
  TOP w0.102: U1401.7 264.52,43.08 265.21,42.39 v1(265.21,42.32) 265.21,41.76 R1411.1
DPSRC1_AUX_N: length 5.4
  TOP w0.102: U1101.W11 291.2,41.4 v5(291.52,41.07)
  BOTTOM w0.108: v5(291.52,41.07) 291.39,41.07 291.01,40.7 290.5,40.7 290.38,40.82 290.14,40.82 289.41,40.09 287.53,40.09 287.48,40.04 C1146.2
DPSRC1_AUX_P: length 5.4
  TOP w0.102: v5(290.87,41.07) 290.87,41.07 U1101.Y11
  BOTTOM w0.108: C1147.2 287.27,40.9 287.46,40.9 287.59,40.77 287.59,40.6 287.47,40.48 287.47,40.39 287.54,40.32 289.31,40.32 290.05,41.06 290.47,41.06 290.6,40.93 290.81,40.93 290.87,41 v5(290.87,41.07)
DPSRC1_ML0_N: length 5.7
  TOP w0.089: 288.57,43.03 288.58,43.01 288.67,43.01 288.67,43.01 288.96,43.01 289.01,43.01 289.21,42.81 289.23,42.81 289.23,42.81 289.51,42.81 289.59,42.89 289.59,42.98 289.53,43.05 U1101.AC7
  TOP w0.108: 288.57,43.03 287.74,43.03 ; 287.74,43.03 v1(287.74,42.8) ; 287.74,43.03 287.64,43.03 286.73,43.94 285.29,43.94 C1139.2
DPSRC1_ML0_P: length 5.6
  TOP w0.089: U1101.AB7 289.62,43.28 289.1,43.28 289.06,43.24 288.67,43.24 288.66,43.25 288.59,43.25 288.58,43.26 288.57,43.26
  TOP w0.108: v1(286.26,44.4) 286.26,44.17 ; 286.26,44.17 285.33,44.17 C1138.2 ; 286.26,44.17 286.83,44.17 287.74,43.26 288.57,43.26
DPSRC1_ML1_N: length 5.1
  TOP w0.089: 288.06,42.11 288.08,42.11 288.09,42.12 288.53,42.12 288.6,42.04 289.01,42.04 289.16,41.89 289.51,41.89 289.59,41.97 289.59,42.06 289.53,42.13 U1101.AC9
  TOP w0.108: C1141.2 285.62,42.52 285.81,42.52 285.97,42.69 286.36,42.69 286.94,42.11 288.06,42.11
DPSRC1_ML1_P: length 5.1
  TOP w0.089: 288.06,42.34 288.08,42.34 288.09,42.33 288.62,42.33 288.69,42.26 289,42.26 289.1,42.36 289.62,42.36 U1101.AB9
  TOP w0.108: C1140.2 285.55,42.76 285.71,42.76 285.87,42.92 286.46,42.92 287.04,42.34 288.06,42.34
DPSRC1_ML2_N: length 5.2
  TOP w0.089: 288.61,41.06 288.62,41.07 289.09,41.07 289.19,40.97 289.51,40.97 289.59,41.05 289.59,41.14 289.53,41.21 U1101.AC11
  TOP w0.108: C1143.2 285.63,41 286.77,41 287.05,40.72 287.74,40.72 ; 288.61,41.06 288.27,40.72 287.74,40.72 ; 287.74,40.72 v1(287.74,40.5)
DPSRC1_ML2_P: length 5.2
  TOP w0.089: 288.68,41.31 288.7,41.29 289.04,41.29 289.19,41.44 289.62,41.44 U1101.AB11
  TOP w0.108: v1(286.3,41.46) 286.29,41.24 ; 286.29,41.24 286.87,41.24 287.15,40.96 288.18,40.96 288.52,41.31 288.68,41.31 ; 286.29,41.24 285.65,41.24 C1142.2
DPSRC1_ML3_N: length 7.8
  TOP w0.089: U1101.AC13 289.43,40.29 289.52,40.2 289.52,40.11 289.46,40.05 289.17,40.05 289.07,40.15 288.48,40.15 288.47,40.14 288.45,40.14
  TOP w0.108: 288.45,40.14 288.25,39.93 288.25,38.31 287.96,38.02 287.74,38.02 ; v1(287.74,37.8) 287.74,38.02 ; 287.74,38.02 286.63,38.02 286.14,38.51 286.14,39.43 285.94,39.62 285.84,39.62 C1145.2
DPSRC1_ML3_P: length 7.8
  TOP w0.089: 288.44,40.38 288.47,40.38 288.47,40.37 288.98,40.37 289.13,40.52 289.62,40.52 U1101.AB13
  TOP w0.108: C1144.2 285.62,39.86 286.04,39.86 286.3,39.59 286.37,39.52 286.37,39.2 ; 286.37,39.2 v1(286.6,39.2) ; 286.37,39.2 286.37,38.61 286.72,38.26 287.86,38.26 288.01,38.41 288.01,40.03 288.36,40.38 288.44,40.38
DRAMRST_R#: length 289.8
  TOP w0.102: 69.38,64.8 69.38,66.07 v2(68.99,66.45) ; 69.38,64.8 69.38,63.99 69.13,63.75 67.52,63.75 66.83,63.06 63.8,63.06 63.07,62.33 63.07,59.39 v2(63.81,58.66) ; 69.38,64.8 CON1600.108 ; CON1700.108 69.37,51.9 69.17,51.7 64.92,51.7 64.11,50.88 63.39,50.88 62.22,49.7 62.22,48.08 63.28,47.02 64.8,47.02 65.88,45.93 v2(66.15,45.93)
  TOP w0.121: v2(244.43,73.03) 244.85,72.61 244.85,72.17 245.16,71.86 245.8,71.86 SR2407.1
  IN1 w0.102: v2(63.81,58.66) 64.65,57.82 64.65,47.44 v2(66.15,45.93) 66.66,45.43 66.66,41.38 67.29,40.75 94.34,40.75 95.23,41.64 101.96,41.64 102.72,42.4 109.84,42.4 112.12,44.68 123.88,44.68 v2(124.52,45.32) ; v2(123.46,32.95) 124.1,33.59 128.23,33.59 128.31,33.51 133.2,33.51 134.4,34.7 137.17,34.7 138.11,33.76 139.7,33.76 143.87,29.6 161.46,29.6 162.02,29.04 164.8,29.04 165.41,29.65 196.06,29.65 202.67,36.26 202.67,38.05 207.14,42.52 207.14,43.44 211.15,47.45 217.51,47.45 218.09,48.04 220.17,48.04 220.45,48.32 228.83,48.32 229.31,48.8 231.04,48.8 231.5,49.26 233.8,49.26 235.29,50.76 236.08,50.76 236.56,51.24 236.56,52.1 238.36,53.9 238.36,67.29 240.82,69.76 240.82,70.59 243.26,73.03 v2(244.43,73.03)
  BOTTOM w0.102: v2(123.46,32.95) 123.46,34 124.07,34.6 v1(124.07,44.36) 124.07,44.6 124.52,45.04 v2(124.52,45.32) ; v2(66.15,45.93) 66.91,45.93 67.38,45.47 CON1701.108 ; CON1601.108 67.38,57.39 66.85,57.91 66.28,57.91 65.54,58.66 v2(63.81,58.66) ; v2(68.99,66.45) 69.42,66.89 69.42,67.98 68.61,68.79 C1603.2 C1703.2 C1702.2 C1602.2
DXN: length 68.9
  TOP w0.254: v2(263.99,92.57) 263.97,92.55 263.97,90.43 262.5,88.96 259.18,88.96 258.89,89.24 Q5001.2 ; U5000.3 289.59,131.86 288.85,131.12 C5004.2 287.98,131.12 285.92,129.06 285.92,124.63 285.85,124.56 285.85,120.92 v2(286.19,120.58)
  IN3 w0.254: v2(286.19,120.58) 286.28,120.58 286.74,120.13 286.74,118.25 285.87,117.38 285.87,113.58 284.27,111.98 284.27,108.23 283.49,107.45 283.49,104.73 283.98,104.24 283.98,102.33 282.46,100.81 282.46,98.46 281.43,97.43 278.85,94.85 276.8,94.85 275.96,94.01 269.61,94.01 269.19,93.58 268.09,93.58 267.53,93.02 265.77,93.02 264.84,92.09 264.44,92.09 263.99,92.54 v2(263.99,92.57)
DXP: length 72.6
  TOP w0.254: v2(286.19,119.95) 286.09,119.95 285.34,120.7 285.34,124.81 285.4,124.88 285.4,129.45 v1(285.71,129.75) 287.94,131.99 C5004.1 288.96,131.99 289.49,132.51 U5000.2 ; v2(264.64,92.58) 264.48,92.42 264.48,90.02 262.91,88.45 259.85,88.45 258.74,87.34 Q5001.1 257.13,87.34 257,87.47 257,88.18 256.89,88.29 Q5001.3
  IN3 w0.254: v2(286.19,119.95) 286.23,119.92 286.23,118.61 285.33,117.72 285.33,113.8 283.76,112.22 283.76,108.43 282.98,107.65 282.98,104.47 283.47,103.97 283.47,102.62 281.95,101.1 281.95,98.67 280.89,97.61 278.64,95.36 276.59,95.36 275.75,94.51 269.4,94.51 268.97,94.09 267.88,94.09 267.33,93.54 265.57,93.54 264.64,92.61 v2(264.64,92.58)
EC_AGND: length 2.9
  TOP w0.178: U3002.75 152.47,18.4 152.3,18.24 C3021.2
  TOP w0.457: SR3014.2 152.3,17.26 C3021.2
EC_PIN_104: length 10.4
  TOP w0.102: U3002.104 161.78,23.91 160.13,22.26 157.98,22.26 156.47,23.76 v2(156.47,24.06)
  BOTTOM w0.102: R3022.1 155.56,24.7 R3038.1 156.43,24.02 v2(156.47,24.06) 156.75,23.79 v1(156.75,23.45)
EC_PIN_107: length 29.9
  TOP w0.102: v2(156.57,27.96) 156.57,26.5 158.12,24.95 158.12,24.01 158.83,23.3 160.77,23.3 161.42,23.95 161.42,24.96 161.58,25.11 U3002.107
  IN2 w0.102: v2(153.54,27.56) 153.13,27.97 152.35,27.97 v2(151.95,27.57)
  IN3 w0.102: v2(153.54,27.56) 154.36,28.38 156.15,28.38 v2(156.57,27.96)
  BOTTOM w0.102: R3012.1 159.54,33.51 v1(159.04,33) 157.66,31.63 157.66,30.3 156.38,29.01 154.58,29.01 153.54,27.97 v2(153.54,27.56) ; R3028.1 153.4,29.7 151.95,28.25 v2(151.95,27.57)
EC_PIN_113: length 4.8
  TOP w0.102: v2(161.37,27.58) 161.45,27.51 U3002.113
  BOTTOM w0.102: R3040.1 160.39,28.39 R3011.1 ; R3040.1 161.02,27.94 v2(161.37,27.58) ; R3040.1 161.97,28.39 v1(162.16,28.2)
EC_PIN_119: length 32.1
  TOP w0.102: U3002.119 163.19,29.91 163.43,30.15 163.43,30.54 163.73,30.84 163.73,31.17 163.92,31.36 v1(164.4,31.36) 164.51,31.36 165.26,30.61 165.26,30.26 165.5,30.01 166.36,30.01 166.88,29.5 167.59,29.5 167.67,29.42 R3098.1 168.43,28.79 170.19,27.03 170.19,24.79 170.81,24.18 v2(170.81,23.91)
  IN1 w0.102: v2(157.08,24.06) 157.46,23.68 162.58,23.68 163.02,24.12 164.44,24.12 164.93,23.63 166.03,23.63 166.78,24.38 170.66,24.38 170.81,24.23 v2(170.81,23.91)
  BOTTOM w0.102: R3023.2 156.24,26.02 157.08,25.17 v2(157.08,24.06)
EC_PIN_122: length 4.8
  TOP w0.102: U3002.122 161.61,31.11 161.37,30.87 v2(161.37,30.51)
  BOTTOM w0.102: v2(161.37,30.51) 161.18,30.7 R3039.1 161.18,31.85 160.94,32.09 R3021.1 v1(161.93,32.49)
EC_PIN_125: length 12.6
  TOP w0.102: U3002.125 159.51,32.31 156.95,29.75 154.9,29.75 154.59,30.06 v2(154.59,30.33)
  BOTTOM w0.102: v1(153.19,32.19) R3019.1 R3024.2 154.49,30.44 v2(154.59,30.33)
EC_RST#: length 24.7
  TOP w0.102: U3002.14 155.66,37.5 155.72,37.56 C3011.1 155.4,38.02 155.31,38.1 v1(155.31,41.28) 154.96,40.93 140.57,40.93 R5004.2 C5002.1 138.84,40.09 138.44,40.09 D5004.3
EDP_AUX_DN_C: length 2.1
  BOTTOM w0.108: C4530.2 114.29,182.72 114.29,183.83 L4505.1
EDP_AUX_DN_R: length 7.3
  TOP w0.108: CON4500.15 115.25,189.02 115.34,189.11 115.34,189.63 v2(115.08,189.89)
  BOTTOM w0.108: 114.58,187.92 114.58,188.24 114.84,188.5 115.22,188.5 115.31,188.59 115.31,189.66 v2(115.08,189.89) ; 114.58,187.92 114.58,187.2 R4523.2 114.63,186.7 114.63,186.62 114.33,186.31 114.33,185.99 L4505.2 ; 114.58,187.92 v1(114.35,187.92)
EDP_AUX_DP_C: length 2
  BOTTOM w0.108: C4529.2 114.53,182.59 114.53,183.84 L4505.4
EDP_AUX_DP_R: length 7.3
  TOP w0.108: v2(115.81,189.89) 115.58,189.66 115.58,189.19 115.75,189.02 CON4500.14
  BOTTOM w0.108: 115.55,188.91 115.55,188.5 115.32,188.27 114.94,188.27 114.81,188.14 114.81,187.35 R4524.2 114.87,186.75 114.87,186.52 114.56,186.21 114.56,185.92 L4505.3 ; 115.55,188.91 v1(115.77,188.91) ; 115.55,188.91 115.55,189.63 v2(115.81,189.89)
EDP_AUXN: length 132
  IN2 w0.095: v2(129.77,80.88) 129.63,81.03 129.07,81.03 127.03,83.07 127.03,97.44 127.37,97.79 127.37,122.57 126.53,123.41 126.53,124.38 123.7,127.22 123.7,134.37 124.14,134.81 124.14,146.18 123.12,147.2 123.12,152.21 122.22,153.12 122.22,159.56 118.54,163.23 118.54,166.74 117.6,167.68 117.6,176.67 115.58,178.69 114.18,178.69 113.7,179.18 v2(113.7,179.89) ; v3(148.25,82.66) 148.39,82.8 148.39,83.09 148.07,83.41 144.11,83.41 142.35,85.17 139.45,85.17 v2(138.97,84.69)
  BOTTOM w0.108: C4530.1 114.28,181.08 114.28,180.89 113.98,180.6 113.98,180.18 v2(113.7,179.89) ; U7000.BF11 148.18,83.05 148.25,82.98 v3(148.25,82.66) ; v2(129.77,80.88) 129.93,80.73 R7322.1 130.88,80.99 131.4,80.99 132.79,82.39 133.59,82.39 135.4,84.19 138.47,84.19 v2(138.97,84.69)
EDP_AUXP: length 132
  IN2 w0.095: v2(138.31,84.69) 138.74,85.12 139.07,85.12 139.35,85.41 142.45,85.41 144.21,83.65 148.17,83.65 148.63,83.19 148.63,83.07 148.97,82.73 v3(149,82.7) ; v2(114.36,179.89) 113.93,179.46 113.93,179.28 114.28,178.92 115.68,178.92 117.84,176.77 117.84,167.78 118.78,166.84 118.78,163.33 122.45,159.66 122.45,153.21 123.36,152.31 123.36,147.3 124.38,146.28 124.38,134.71 123.93,134.27 123.93,127.31 126.77,124.48 126.77,123.51 127.61,122.67 127.61,97.69 127.26,97.34 127.26,83.17 129.17,81.26 129.47,81.26 v2(129.77,81.57)
  BOTTOM w0.108: v2(114.36,179.89) 114.22,180.03 114.22,180.5 114.52,180.8 114.52,181.19 C4529.1 ; v2(138.31,84.69) 138.05,84.43 135.3,84.43 133.5,82.62 132.69,82.62 131.3,81.23 130.9,81.23 R7321.1 129.83,81.52 v2(129.77,81.57) ; U7000.BE11 v3(149,82.7)
EDP_RCOMP: length 2.7
  TOP w0.089: R0300.2 114.14,128.57 v1(114.41,128.3)
  TOP w0.254: v3(113.1,129.49) 113.32,129.27 R0300.2
  BOTTOM w0.254: v3(113.1,129.49) 113.03,129.43 U0300.D37
EDP_TX0_DN_C: length 2
  BOTTOM w0.108: L4504.4 116.84,183.74 116.84,182.56 C4533.2
EDP_TX0_DN_R: length 6.5
  TOP w0.108: v2(117.34,189.89) 117.09,189.65 117.09,189.19 117.25,189.04 CON4500.11
  BOTTOM w0.108: L4504.3 116.94,185.95 116.94,186.23 117.14,186.43 117.14,187.99 ; 117.14,187.99 117.14,189.69 v2(117.34,189.89) ; 117.14,187.99 v1(117.35,187.99)
EDP_TX0_DP_C: length 2
  BOTTOM w0.108: L4504.1 116.61,183.93 116.61,182.75 C4531.2
EDP_TX0_DP_R: length 6.2
  TOP w0.108: v2(116.7,189.89) 116.86,189.74 116.86,189.13 116.75,189.02 CON4500.12
  BOTTOM w0.108: L4504.2 116.7,185.95 116.7,186.33 116.9,186.53 116.9,189.69 v2(116.7,189.89)
EDP_TX1_DN_C: length 2.1
  BOTTOM w0.108: RN4503.1 119.12,183.73 119.12,182.57 C4534.2
EDP_TX1_DN_R: length 6.6
  TOP w0.108: CON4500.8 118.75,189.1 118.62,189.23 118.62,189.65 v2(118.86,189.89)
  BOTTOM w0.108: 118.89,188.61 118.65,188.86 118.65,189.68 v2(118.86,189.89) ; 118.89,188.61 v1(119.06,188.78) ; 118.89,188.61 119.28,188.22 119.28,185.89 RN4503.2
EDP_TX1_DP_C: length 2
  BOTTOM w0.108: C4535.2 118.88,182.74 118.88,183.94 RN4503.3
EDP_TX1_DP_R: length 6.6
  TOP w0.108: v2(118.2,189.89) 118.38,189.71 118.38,189.12 118.25,188.99 CON4500.9
  BOTTOM w0.108: 119.05,187.05 119.05,188.12 118.41,188.76 118.41,189.68 v2(118.2,189.89) ; 119.05,187.05 v1(118.82,187.05) ; 119.05,187.05 119.05,186.01 RN4503.4
EDP_TX2_DN_C: length 1.8
  BOTTOM w0.108: C4519.2 121.47,182.88 121.47,183.79 RN4502.1
EDP_TX2_DN_R: length 7.3
  TOP w0.108: CON4500.5 120.25,189.09 120.1,189.23 120.1,189.58 120.38,189.86 v2(120.38,189.89)
  BOTTOM w0.108: v1(121.01,188.81) 120.85,188.64 ; 120.85,188.64 121.8,187.69 121.8,187.03 121.47,186.7 121.47,185.99 RN4502.2 ; 120.85,188.64 120.13,189.35 120.13,189.64 v2(120.38,189.89)
EDP_TX2_DP_C: length 1.8
  BOTTOM w0.108: C4520.2 121.23,182.93 121.23,183.88 RN4502.3
EDP_TX2_DP_R: length 7.2
  TOP w0.108: v2(119.65,189.89) 119.87,189.67 119.87,189.14 119.75,189.02 CON4500.6
  BOTTOM w0.108: RN4502.4 121.23,185.91 121.23,186.79 121.35,186.91 ; 121.35,186.91 121.56,187.12 121.56,187.59 119.9,189.26 119.9,189.64 v2(119.65,189.89) ; 121.35,186.91 v1(121.19,187.08)
EDP_TX3_DN_C: length 2.5
  BOTTOM w0.108: L4501.4 124.79,183.81 124.79,183.49 124.46,183.16 123.96,183.16 123.79,182.99 123.79,182.85 C4522.2
EDP_TX3_DN_R: length 8.6
  TOP w0.108: CON4500.2 121.75,189.11 121.62,189.24 121.62,189.63 v2(121.89,189.91)
  BOTTOM w0.108: v1(122.84,189.13) 122.84,188.91 ; 122.84,188.91 122.03,188.91 121.62,189.32 121.62,189.64 v2(121.89,189.91) ; 122.84,188.91 123.42,188.91 124.81,187.52 124.81,185.95 L4501.3
EDP_TX3_DP_C: length 2.5
  BOTTOM w0.108: C4521.2 123.55,182.96 123.55,183.09 123.86,183.4 124.36,183.4 124.56,183.59 124.56,183.86 L4501.1
EDP_TX3_DP_R: length 8.5
  TOP w0.108: v2(121.17,189.89) 121.38,189.68 121.38,189.2 121.25,189.07 CON4500.3
  BOTTOM w0.108: 124.58,187.1 124.58,185.95 L4501.2 ; 124.58,187.1 v1(124.35,187.1) ; 124.58,187.1 124.58,187.42 123.33,188.67 121.93,188.67 121.39,189.22 121.39,189.69 v2(121.17,189.89)
EDP_TXN_0: length 123.9
  IN2 w0.095: v2(133.18,88.08) 132.99,88.27 132.62,88.27 132.41,88.48 132.41,93.38 130.33,95.46 130.33,131.26 127.09,134.51 127.09,149.44 127.97,150.32 127.97,159.79 130.58,162.4 130.58,168.49 128.29,170.78 128.29,178.88 124.8,182.38 118.18,182.38 116.82,181.02 v2(116.82,179.89)
  BOTTOM w0.108: C4533.1 116.82,181.21 v2(116.82,179.89) ; U7000.BM17 143.95,87.45 143.95,87.59 143.9,87.64 143.38,87.64 142.55,88.46 134.8,88.46 134.73,88.39 133.49,88.39 v2(133.18,88.08)
EDP_TXN_1: length 121.8
  IN2 w0.095: v2(119.18,180.37) 119.28,180.47 119.28,180.57 120.33,181.62 124.34,181.62 127.39,178.57 127.39,168.58 128.98,166.99 128.98,166.01 127.05,164.07 127.05,160.8 126.73,160.47 126.73,154.88 127.13,154.47 127.13,150.73 126.35,149.95 126.35,134.2 129.58,130.97 129.58,95.04 131.67,92.95 131.67,88.04 132.8,86.92 132.8,86.64 v2(133.21,86.23)
  BOTTOM w0.108: U7000.BK17 144.97,87.25 144.6,86.88 144.22,86.88 144.03,86.69 143.37,86.69 142.35,87.71 135.19,87.71 133.86,86.39 133.36,86.39 v2(133.21,86.23) ; C4534.1 118.98,181.08 118.98,180.58 v2(119.18,180.37)
EDP_TXN_2: length 122
  IN2 w0.095: v2(130.69,86.43) 130.21,86.91 130.21,87.24 130.02,87.43 130.02,88.6 130.23,88.8 130.23,92.98 128.85,94.36 128.85,128.95 127.75,130.05 126.02,130.05 125.22,130.85 125.22,133.8 125.61,134.19 125.61,150.29 125.16,150.74 125.16,160.21 126.24,161.29 126.24,165.44 126.4,165.6 126.4,178.39 123.91,180.88 121.17,180.88 121.09,180.8 121.09,180.5 v2(121.37,180.22)
  BOTTOM w0.108: U7000.BL15 144.26,85.85 143.94,86.17 143,86.17 142.53,86.64 135.28,86.64 133.54,84.89 132.72,84.89 132.16,85.46 132.16,86.35 131.7,86.8 131.38,86.8 ; C4519.1 121.77,181.26 121.72,181.21 121.22,181.21 121.12,181.12 121.12,180.46 v2(121.37,180.22) ; 131.38,86.8 131.07,86.8 v2(130.69,86.43) ; 131.38,86.8 v1(131.38,86.57)
EDP_TXN_3: length 119.5
  IN2 w0.095: v2(123.76,180.29) 123.58,180.12 123.58,179.79 125.89,177.48 125.89,165.98 124.88,164.98 124.88,161.66 123.88,160.66 123.88,154.29 124.09,154.08 124.09,149.63 125.11,148.61 125.11,134.4 124.72,134 124.72,127.66 128.35,124.04 128.35,93.76 128.86,93.25 128.86,85.78 129.39,85.26 131.45,85.26 131.71,85 131.71,84.42 131.29,84 130.92,84 v2(130.74,83.83)
  BOTTOM w0.108: v2(123.76,180.29) 123.68,180.37 123.68,181.33 C4522.1 ; U7000.BM14 143.65,85.25 143.33,85.25 143.25,85.33 143,85.33 142.45,85.88 135.92,85.88 134.04,84 130.92,84 v2(130.74,83.83)
EDP_TXP_0: length 124
  IN2 w0.095: v2(116.11,179.89) 116.59,180.37 116.59,181.12 118.08,182.61 124.89,182.61 128.53,178.98 128.53,170.88 130.82,168.59 130.82,162.3 128.21,159.69 128.21,150.23 127.32,149.34 127.32,134.61 130.57,131.36 130.57,95.56 132.65,93.48 132.65,88.58 132.72,88.5 132.99,88.5 v2(133.18,88.69)
  BOTTOM w0.108: v2(116.11,179.89) 116.59,180.37 116.59,181.06 C4531.1 ; U7000.BM18 143.4,87.95 142.65,88.7 134.7,88.7 134.63,88.62 133.25,88.62 v2(133.18,88.69)
EDP_TXP_1: length 121.8
  IN2 w0.095: v2(118.57,180.4) 118.37,180.6 118.37,180.73 118.45,180.8 119.18,180.8 120.23,181.85 124.44,181.85 127.62,178.67 127.62,168.68 129.22,167.09 129.22,165.91 127.29,163.98 127.29,160.7 126.96,160.38 126.96,154.98 127.37,154.57 127.37,150.63 126.59,149.85 126.59,134.3 129.82,131.07 129.82,95.14 131.91,93.05 131.91,88.14 v2(133.21,86.84)
  BOTTOM w0.108: v2(118.57,180.4) 118.74,180.57 118.74,181.19 C4535.1 ; v2(133.21,86.84) 133.42,86.63 133.77,86.63 135.09,87.95 142.44,87.95 143.47,86.93 143.93,86.93 144.26,87.25 U7000.BL17
EDP_TXP_2: length 121.8
  IN2 w0.095: v2(120.73,180.22) 120.85,180.34 120.85,180.9 121.07,181.12 124,181.12 126.64,178.48 126.64,165.5 126.47,165.34 126.47,161.19 125.4,160.12 125.4,150.84 125.85,150.39 125.85,134.09 125.46,133.7 125.46,130.94 126.12,130.28 127.84,130.28 129.08,129.05 129.08,94.45 130.46,93.07 130.46,88.7 130.26,88.5 130.26,87.52 130.44,87.34 130.44,87.29 v2(130.69,87.04)
  BOTTOM w0.108: U7000.BK15 144.95,85.85 144.62,86.18 144.26,86.18 144.04,86.41 143.09,86.41 142.63,86.88 135.19,86.88 133.44,85.13 132.82,85.13 132.39,85.55 132.39,86.44 131.8,87.04 v2(130.69,87.04) ; C4520.1 120.88,180.37 v2(120.73,180.22)
EDP_TXP_3: length 119.4
  IN2 w0.095: v2(123.12,180.29) 123.34,180.07 123.34,179.69 125.65,177.38 125.65,166.08 124.64,165.07 124.64,161.75 123.65,160.76 123.65,154.19 123.86,153.98 123.86,149.53 124.88,148.51 124.88,134.49 124.49,134.1 124.49,127.56 128.11,123.94 128.11,93.67 128.63,93.15 128.63,85.69 129.29,85.02 131.35,85.02 131.47,84.9 131.47,84.51 131.2,84.24 130.94,84.24 v2(130.74,84.43)
  BOTTOM w0.108: U7000.BM15 143.75,85.64 143.6,85.49 143.43,85.49 143.34,85.57 143.09,85.57 142.54,86.12 135.83,86.12 133.95,84.24 130.94,84.24 v2(130.74,84.43) ; v2(123.12,180.29) 123.44,180.62 123.44,181.44 C4521.1
EN: length 6.7
  TOP w0.102: U1501.7 43.03,16.46 43.82,17.25 44.43,17.25 44.74,16.95 v2(44.74,16.64)
  BOTTOM w0.102: R1514.2 46.41,17.76 45.27,17.76 C1512.2 44.76,16.67 v2(44.74,16.64)
ENABLE1: length 7.1
  TOP w0.102: U8100.20 259.74,61.33 259.37,61.7 259.11,61.7 257.59,63.23 257.59,63.56 257.19,63.95 SR8102.1 257.19,64.97 257.16,65.01 R8111.1 256.44,65.41 256.22,65.64 v1(256.22,66.1)
ENABLE2: length 26.2
  TOP w0.102: SR8103.2 265.79,66.53 268.87,63.46 268.87,57.93 266.83,55.9 v1(266.83,55.04) 266.05,54.26 263.67,54.26 263.59,54.34 260.12,54.34 259.9,54.57 259.9,55.71 259.04,56.57 259.04,58.12 259.23,58.32 U8100.6
EQ0: length 4.8
  TOP w0.102: v1(297.72,120.48) 298.2,120.48 299.04,119.64 299.04,118.29 299.29,118.04 R4601.1 299.18,117.77 U4601.39
EQ1: length 5.4
  TOP w0.102: v1(295.97,120.66) 296.42,120.2 296.99,120.2 297.58,119.62 297.78,119.62 298.15,119.24 298.15,118.45 R4606.1 298.56,117.73 298.68,117.61 U4601.40
EQ2: length 6.1
  TOP w0.102: U4601.41 298.18,117.38 R4602.1 297.95,118.47 297.95,119.16 297.69,119.41 297.49,119.41 296.96,119.95 296.12,119.95 295.61,119.44 v1(295.61,118.96)
EQ3: length 4.8
  TOP w0.102: v1(293.86,119.01) 294.44,118.42 295.61,118.42 295.99,118.04 R4627.1 297.68,117.04 U4601.42
EQ_SEL_A0: length 23.8
  TOP w0.102: R1325.1 296.78,79.74 v2(296.91,79.86) 297.34,80.3 297.34,80.68 297.6,80.94 U1301.17
  BOTTOM w0.102: v1(285.02,68.13) 289.85,68.13 291.49,69.78 291.49,72.48 291.25,72.73 291.25,75.4 291.52,75.67 291.9,75.67 R1324.2 292.72,76.94 292.92,77.15 292.92,78.11 293.44,78.63 294.97,78.63 295.6,79.26 296.3,79.26 v2(296.91,79.86)
ESPI_ALERT0#: length 221.5
  TOP w0.121: SR2208.1 247.09,65.41 v2(247.52,65.84) ; v2(161.32,42.17) 161.76,41.73 161.76,41.02 161.86,40.92 161.86,39.89 161.7,39.73 161.7,39.12 161.47,38.89 R3013.1
  IN2 w0.083: v2(239.38,46.08) 240.24,46.95 240.24,52.2 240.01,52.43 240.01,54.01 243.08,57.09 243.08,61.98 246.41,65.31 246.99,65.31 v2(247.52,65.84)
  IN4 w0.083: v2(238.97,31.1) 238.13,31.94 231.5,31.94 229.96,30.4 229.96,29.6 229.68,29.33 228.86,28.51 228.05,28.51 226.71,27.17 212.24,27.17 210.33,25.26 209.88,25.26 209.71,25.26 206.43,21.98 205.4,21.98 204.74,21.32 204.02,21.32 201.54,18.84 185.65,18.84 185.42,18.61 175.79,18.61 175.52,18.35 166.32,18.35 165.88,18.78 146.6,18.78 146.35,18.54 138.65,18.54 136.05,21.14 133.74,21.14 133.43,20.84 131.12,20.84 130.82,21.14 127.79,21.14 v2(127.26,20.61)
  BOTTOM w0.121: v2(238.97,31.1) 238.97,31.82 240.81,33.66 243.08,33.66 247.48,38.07 247.48,39.46 247.15,39.79 247.15,41.1 v1(246.46,41.79) 243.85,44.41 241.05,44.41 v2(239.38,46.08) ; v2(127.26,20.61) 127.26,23.42 129.77,25.93 129.77,27.13 130.13,27.49 130.76,27.49 132.04,28.77 132.04,31.2 134.4,33.56 134.4,34.33 141.15,41.08 160.89,41.08 161.32,41.51 v2(161.32,42.17)
EXP_RXN0: length 23.5
  TOP w0.102: 144.1,93.29 144.13,93.29 144.14,93.28 145.41,93.28 145.87,92.82 146.23,92.82 146.28,92.88 v3(146.28,93.12)
  TOP w0.121: 144.1,93.29 143.71,93.29 143.56,93.15 142.14,93.15 141.51,92.52 140.24,92.52 ; C0631.1 128.87,98.79 128.96,98.7 128.96,98.25 129.55,97.67 129.55,96.94 129.8,96.69 136.83,96.69 138.72,94.8 139.27,94.8 139.71,94.37 139.71,92.82 140.01,92.52 140.24,92.52 ; 140.24,92.52 v1(140.24,92.74)
  BOTTOM w0.121: v3(146.28,93.12) 146.55,93.39 U7000.BH26
EXP_RXN1: length 26.9
  TOP w0.102: 144.58,93.62 144.61,93.62 144.62,93.63 147.12,93.63 147.48,93.28 147.48,93.17 148.12,92.53 148.57,92.53 148.78,92.74 148.78,92.98 v3(149,93.2)
  TOP w0.121: v1(129.37,99.12) 129.37,99.34 ; 129.37,99.34 127,99.34 C0629.1 ; 129.37,99.34 129.8,99.34 129.94,99.21 131.83,97.31 136.87,97.31 138.88,95.31 139.45,95.31 140.13,94.63 140.13,93.99 140.55,93.57 143.33,93.57 143.56,93.8 144.05,93.8 144.24,93.62 144.58,93.62
  BOTTOM w0.121: U7000.BE26 v3(149,93.2)
EXP_RXN2: length 23.1
  TOP w0.102: 143.8,94.71 143.82,94.71 143.84,94.7 144.46,94.7 144.9,94.25 146.78,94.25 146.89,94.36 v3(146.89,94.61)
  TOP w0.121: C0627.1 128.81,100.72 129.44,100.72 ; 143.8,94.71 141.12,94.71 141.05,94.78 141.05,94.98 139.83,96.2 139.25,96.2 136.41,99.05 131.91,99.05 130.24,100.72 129.44,100.72 ; v1(129.44,100.94) 129.44,100.72
  BOTTOM w0.121: U7000.BG27 147.25,94.06 147.15,93.96 146.97,93.96 146.89,94.04 v3(146.89,94.61)
EXP_RXN3: length 23.8
  TOP w0.121: C0625.1 127.1,101.58 130.06,101.58 132.17,99.47 136.58,99.47 139.43,96.63 140.09,96.63 141.58,95.14 144.42,95.14 144.64,95.36 145.6,95.36 145.68,95.27 145.68,94.89 145.77,94.8 146.19,94.8 146.26,94.87 v3(146.26,95.21)
  BOTTOM w0.121: U7000.BH29 146.39,95.49 146.39,95.33 v3(146.26,95.21)
EXP_RXN4: length 24.3
  TOP w0.102: v3(149,95.3) 148.63,95.66 148.63,95.71 148.3,96.04 146.1,96.04 146.08,96.06 146.06,96.06
  TOP w0.121: C0623.1 129.76,103.18 132.57,100.37 136.95,100.37 139.8,97.52 140.46,97.52 141.92,96.06 146.06,96.06
  BOTTOM w0.121: v3(149,95.3) 148.93,95.37 U7000.BE29
EXP_RXN5: length 25.9
  TOP w0.102: 145.98,96.34 146.01,96.34 146.02,96.36 146.37,96.36 146.48,96.25 148.05,96.25 148.14,96.34 148.14,96.56 148,96.69 v3(147.59,96.69)
  TOP w0.121: C0621.1 127.13,103.66 129.92,103.66 132.79,100.79 137.18,100.79 140.03,97.95 140.64,97.95 142.02,96.56 144.42,96.56 144.64,96.34 145.98,96.34
  BOTTOM w0.121: v3(147.59,96.69) U7000.BG30
EXP_RXN6: length 22
  TOP w0.102: v3(146.21,97.39) 146.21,97.27 146.11,97.17 145.64,97.17 145.22,97.59 144.47,97.59 144.32,97.44 143.84,97.44 143.82,97.46 143.8,97.46
  TOP w0.121: C0619.1 129.34,104.88 129.99,104.88 133.18,101.69 137.62,101.69 140.45,98.86 140.99,98.86 142.39,97.46 143.8,97.46
  BOTTOM w0.121: U7000.BH32 146.55,97.94 146.45,98.04 146.29,98.04 146.21,97.96 v3(146.21,97.39)
EXP_RXN7: length 25.8
  TOP w0.121: v3(148.3,97.4) 148.01,97.69 147.86,97.69 147.71,97.84 144.77,97.84 144.46,98.15 144.18,98.15 ; v1(144.18,97.93) 144.18,98.15 ; 144.18,98.15 142.31,98.15 141.16,99.3 140.62,99.3 137.8,102.12 133.41,102.12 129.78,105.75 127.03,105.75 C0617.1
  BOTTOM w0.121: U7000.BE32 v3(148.3,97.4)
EXP_RXN8: length 25.5
  TOP w0.121: v1(141.05,100.54) 140.89,100.38 ; 140.89,100.38 138.25,103.01 133.81,103.01 129.67,107.15 129.03,107.15 128.41,107.78 127.39,107.78 126.98,108.19 ; 140.89,100.38 141.05,100.22 141.5,100.22 142.68,99.04 144.68,99.04 145.14,98.59 146.65,98.59 v3(146.89,98.83)
  BOTTOM w0.121: v3(146.89,98.83) 146.89,98.22 146.96,98.15 147.16,98.15 147.25,98.24 U7000.BG33
EXP_RXN9: length 23.3
  TOP w0.121: C0613.1 129.27,109.23 129.36,109.14 129.36,108.97 129.21,108.83 129.21,108.65 129.29,108.57 129.82,108.57 130.09,108.31 130.09,107.7 134.11,103.67 138.61,103.67 140.29,101.99 140.67,101.99 142.96,99.7 144.18,99.7 144.22,99.66 145.55,99.66 145.99,99.22 146.12,99.22 v3(146.3,99.4)
  BOTTOM w0.121: v3(146.3,99.4) 146.3,99.6 U7000.BH35
EXP_RXN10: length 27.1
  TOP w0.121: v3(148.29,99.5) 147.82,99.97 144.5,99.97 144.33,100.13 143.14,100.13 140.19,103.07 139.94,103.07 138.92,104.1 135.34,104.1 131.37,108.06 131.37,109.21 130.45,110.13 128.95,110.13 128.61,110.48 127.26,110.48 C0611.1
  BOTTOM w0.121: v3(148.29,99.5) 148.64,99.85 U7000.BE35
EXP_RXN11: length 26.1
  TOP w0.102: 144.2,101.29 144.23,101.29 144.24,101.27 144.33,101.27 144.94,100.67 146.56,100.67 v3(146.84,100.95)
  TOP w0.121: v1(129.88,112.49) 129.88,112.28 ; 129.88,112.28 129.65,112.28 129.24,111.87 129.14,111.87 C0605.1 ; 129.88,112.28 130.64,112.28 132.3,110.62 132.3,108.48 135,105.77 137.1,105.77 137.79,105.09 139.53,105.09 143.33,101.29 144.2,101.29
  BOTTOM w0.121: v3(146.84,100.95) 146.9,100.89 146.9,100.31 146.97,100.24 147.12,100.24 147.25,100.37 U7000.BG36
EXP_RXN12: length 28.6
  TOP w0.102: 144.33,101.72 144.35,101.72 144.37,101.73 145.15,101.73 145.39,101.98 146.52,101.98 146.56,101.94 146.56,101.83 v3(146.26,101.53)
  TOP w0.121: 126.98,112.68 127.36,112.68 127.41,112.73 127.41,113.01 127.49,113.08 129.52,113.08 130.18,113.74 131.13,113.74 131.79,113.08 ; v1(131.63,112.91) 131.79,113.08 ; 131.79,113.08 132.72,112.15 132.72,108.66 135.18,106.2 137.28,106.2 137.96,105.51 139.74,105.51 143.53,101.72 144.33,101.72
  BOTTOM w0.121: v3(146.26,101.53) 146.55,101.82 U7000.BH38
EXP_RXN13: length 29.8
  TOP w0.102: v3(149,101.6) 148.59,102.01 148.17,102.01 147.94,102.24 147.22,102.24 146.87,102.6 145.95,102.6 145.82,102.73 145.44,102.73 145.42,102.75 145.4,102.75
  TOP w0.121: 144.48,102.65 144.99,102.65 145.09,102.75 145.4,102.75 ; 144.48,102.65 v1(144.48,102.87) ; 144.48,102.65 143.87,102.65 141.28,105.24 141.28,106.24 140.68,106.84 139.63,106.84 139.2,106.41 138.33,106.41 137.64,107.1 135.55,107.1 133.62,109.03 133.62,112.53 131.12,115.02 129.49,115.02 129.11,114.64 C0608.1
  BOTTOM w0.121: U7000.BE38 v3(149,101.6)
EXP_RXN14: length 30.2
  TOP w0.102: 144.18,103.58 144.2,103.58 144.22,103.6 144.58,103.6 144.72,103.74 145.29,103.74 146.01,103.02 147.14,103.02 147.21,102.95 147.21,102.63 147.29,102.54 147.56,102.54 147.62,102.6 v3(147.62,103.02)
  TOP w0.121: C0602.1 127.33,115.5 131.25,115.5 134.04,112.7 134.04,109.2 135.72,107.52 140.32,107.52 ; 140.32,107.52 140.6,107.52 141.71,106.42 141.71,105.42 143.55,103.58 144.18,103.58 ; 140.32,107.52 v1(140.32,107.31)
  BOTTOM w0.121: v3(147.62,103.02) U7000.BG39
EXP_RXN15: length 27.3
  TOP w0.121: 129.6,117.13 129.05,117.13 C0600.1 ; 129.6,117.13 v1(129.6,117.35) ; 129.6,117.13 130.92,117.13 134.98,113.06 134.98,109.53 136.09,108.42 140.97,108.42 142.6,106.79 142.6,105.8 143.49,104.91 144.53,104.91 144.91,104.53 146.08,104.53 146.59,104.02 146.59,103.84 v3(146.82,103.61)
  BOTTOM w0.121: v3(146.82,103.61) 146.92,103.72 146.92,103.72 U7000.BG41
EXP_RXP0: length 23.6
  TOP w0.102: v3(146.9,93.2) 146.9,93.18 146.34,92.62 145.78,92.62 145.33,93.07 144.14,93.07 144.13,93.06 144.1,93.06
  TOP w0.121: 129.31,96.93 129.31,96.84 129.7,96.45 136.73,96.45 138.62,94.56 139.18,94.56 139.47,94.27 139.47,92.72 139.91,92.29 141.61,92.29 142.24,92.91 143.66,92.91 143.81,93.06 144.1,93.06 ; 129.31,96.93 v1(129.09,96.93) ; 129.31,96.93 129.31,97.57 128.98,97.9 C0630.1
  BOTTOM w0.121: U7000.BG26 v3(146.9,93.2)
EXP_RXP1: length 27
  TOP w0.102: v3(148.3,93.2) 148.58,92.92 148.58,92.82 148.49,92.73 148.2,92.73 147.68,93.25 147.68,93.36 147.21,93.83 144.62,93.83 144.61,93.85 144.58,93.85
  TOP w0.121: v1(142.93,94.03) 142.93,93.81 ; 142.93,93.81 143.23,93.81 143.46,94.04 144.15,94.04 144.34,93.85 144.58,93.85 ; 142.93,93.81 140.65,93.81 140.37,94.09 140.37,94.73 139.55,95.54 138.98,95.54 136.97,97.55 131.93,97.55 130.17,99.3 129.9,99.58 127.21,99.58 C0628.1
  BOTTOM w0.121: U7000.BF26 147.84,93.44 147.84,93.3 147.93,93.2 v3(148.3,93.2)
EXP_RXP2: length 23
  TOP w0.102: 143.8,94.48 143.82,94.48 143.84,94.5 144.37,94.5 144.82,94.05 147.06,94.05 v3(147.63,94.62)
  TOP w0.121: C0626.1 128.8,100.48 130.14,100.48 131.81,98.81 136.31,98.81 139.15,95.97 139.73,95.97 140.82,94.88 140.82,94.68 141.02,94.48 141.13,94.48 ; 141.13,94.48 v1(141.13,94.26) ; 141.13,94.48 143.8,94.48
  BOTTOM w0.121: v3(147.63,94.62) 147.63,94.57 U7000.BF27
EXP_RXP3: length 23.7
  TOP w0.121: v3(146.83,95.19) 146.44,95.59 146.43,95.59 146.42,95.6 144.54,95.6 144.32,95.37 141.67,95.37 140.19,96.86 139.52,96.86 136.68,99.71 132.27,99.71 130.16,101.81 127.1,101.81 C0624.1
  BOTTOM w0.121: U7000.BG29 146.87,95.27 146.87,95.23 v3(146.83,95.19)
EXP_RXP4: length 24.4
  TOP w0.102: v3(148.29,95.31) 148.43,95.45 148.43,95.58 148.43,95.58 148.43,95.63 148.22,95.84 146.1,95.84 146.08,95.83 146.06,95.83
  TOP w0.121: 146.06,95.83 141.82,95.83 140.36,97.29 139.7,97.29 136.86,100.13 132.48,100.13 129.66,102.95 129.13,102.95 128.99,102.8 128.99,102.41 128.87,102.29 C0622.1
  BOTTOM w0.121: v3(148.29,95.31) U7000.BF29
EXP_RXP5: length 25.9
  TOP w0.102: 145.98,96.58 146.01,96.58 146.02,96.56 146.45,96.56 146.56,96.45 147.02,96.45 147.15,96.58 147.15,96.93 v3(147.61,97.39)
  TOP w0.121: C0620.1 127.13,103.9 130.02,103.9 132.88,101.03 137.28,101.03 140.12,98.18 140.73,98.18 142.12,96.8 144.52,96.8 144.74,96.58 145.98,96.58
  BOTTOM w0.121: U7000.BF30 147.95,96.52 148.01,96.58 148.01,96.96 147.61,97.37 v3(147.61,97.39)
EXP_RXP6: length 22
  TOP w0.102: 143.8,97.22 143.82,97.22 143.84,97.24 144.41,97.24 144.56,97.39 145.13,97.39 145.55,96.97 146.35,96.97 146.77,97.39 v3(146.89,97.39)
  TOP w0.121: C0618.1 129.29,104.65 129.89,104.65 133.08,101.45 137.52,101.45 140.35,98.63 140.89,98.63 142.3,97.22 143.8,97.22
  BOTTOM w0.121: U7000.BG32 v3(146.89,97.39)
EXP_RXP7: length 25.8
  TOP w0.121: 129.19,105.98 127.23,105.98 C0616.1 ; 129.19,105.98 129.88,105.98 133.51,102.35 137.9,102.35 140.71,99.53 141.25,99.53 142.4,98.38 144.56,98.38 144.74,98.2 144.86,98.08 147.8,98.08 147.96,97.92 148.12,97.92 v3(148.29,98.1) ; 129.19,105.98 v1(129.19,106.2)
  BOTTOM w0.121: v3(148.29,98.1) 147.95,97.76 U7000.BF32
EXP_RXP8: length 25.5
  TOP w0.121: 126.98,107.3 127.22,107.54 127.87,107.54 ; v3(147.63,98.81) 147.17,98.35 145.04,98.35 144.59,98.81 142.58,98.81 141.41,99.98 140.95,99.98 138.15,102.78 133.71,102.78 129.57,106.92 128.94,106.92 128.31,107.54 127.87,107.54 ; 127.87,107.54 v1(127.87,107.32)
  BOTTOM w0.121: U7000.BF33 147.69,98.71 147.63,98.77 v3(147.63,98.81)
EXP_RXP9: length 23.3
  TOP w0.102: v3(146.88,99.48) 146.88,99.39 146.49,98.99 146.14,98.99 146.13,98.98
  TOP w0.121: C0612.1 129.72,108.34 129.85,108.21 129.85,107.6 134.01,103.44 138.51,103.44 140.19,101.75 140.57,101.75 142.86,99.47 144.08,99.47 144.12,99.42 145.45,99.42 145.89,98.98 146.13,98.98
  BOTTOM w0.121: U7000.BG35 146.95,99.55 v3(146.88,99.48)
EXP_RXP10: length 27.1
  TOP w0.121: C0606.1 127.45,110.71 128.7,110.71 129.05,110.36 130.55,110.36 131.6,109.31 131.6,108.16 135.43,104.33 139.01,104.33 140.04,103.31 140.29,103.31 143.24,100.36 144.43,100.36 144.59,100.2 148.28,100.2 v3(148.29,100.19)
  BOTTOM w0.121: v3(148.29,100.19) 148.1,100.19 147.95,100.04 U7000.BF35
EXP_RXP11: length 26.1
  TOP w0.102: 144.2,101.05 144.23,101.05 144.24,101.07 144.25,101.07 144.85,100.46 147.17,100.46 v3(147.61,100.89)
  TOP w0.121: 143.8,101.05 143.23,101.05 139.43,104.85 137.69,104.85 137,105.54 134.91,105.54 132.06,108.38 132.06,110.52 130.54,112.04 129.75,112.04 129.34,111.63 129.03,111.63 C0610.1 ; 143.8,101.05 v1(143.8,100.84) ; 143.8,101.05 144.2,101.05
  BOTTOM w0.121: U7000.BF36 147.61,100.89 v3(147.61,100.89)
EXP_RXP12: length 28.6
  TOP w0.102: 144.33,101.95 144.35,101.95 144.37,101.94 145.07,101.94 145.31,102.18 146.6,102.18 146.76,102.02 146.76,101.64 v3(146.84,101.56)
  TOP w0.121: 126.98,113.57 127.26,113.57 127.51,113.32 129.42,113.32 130.08,113.98 130.36,113.98 ; v1(130.36,114.2) 130.36,113.98 ; 130.36,113.98 131.22,113.98 132.96,112.25 132.96,108.75 135.28,106.43 137.38,106.43 138.06,105.75 139.83,105.75 143.63,101.95 144.33,101.95
  BOTTOM w0.121: U7000.BG38 146.86,101.56 v3(146.84,101.56)
EXP_RXP13: length 29.9
  TOP w0.102: 145.4,102.52 145.42,102.52 145.44,102.53 145.73,102.53 145.87,102.39 146.78,102.39 147.14,102.04 147.86,102.04 v3(148.29,101.61)
  TOP w0.121: 145.4,102.52 145.19,102.52 145.09,102.42 143.77,102.42 141.05,105.14 141.05,105.57 ; 141.05,105.57 141.05,106.14 140.58,106.6 139.73,106.6 139.3,106.17 138.24,106.17 137.55,106.86 135.45,106.86 133.38,108.93 133.38,112.43 131.02,114.79 129.59,114.79 129.13,114.33 129.13,114.18 129.31,114 129.31,113.83 129.23,113.75 C0603.1 ; 141.05,105.57 v1(140.83,105.57)
  BOTTOM w0.121: U7000.BF38 148.24,101.66 148.24,101.66 v3(148.29,101.61)
EXP_RXP14: length 30.3
  TOP w0.102: v3(148.19,103.13) 147.91,103.41 147.46,103.41 147.27,103.22 146.09,103.22 145.37,103.94 144.63,103.94 144.49,103.8 144.22,103.8 144.2,103.82 144.18,103.82
  TOP w0.121: 144.18,103.82 143.65,103.82 141.94,105.52 141.94,106.51 140.69,107.76 135.82,107.76 134.28,109.3 134.28,112.8 131.35,115.73 130.71,115.73 ; 130.71,115.73 127.33,115.73 C0601.1 ; 130.71,115.73 v1(130.71,115.96)
  BOTTOM w0.121: U7000.BF39 148.19,102.89 v3(148.19,103.13)
EXP_RXP15: length 27.3
  TOP w0.121: 143.64,104.67 144.43,104.67 144.82,104.29 145.98,104.29 146.35,103.92 146.35,103.79 v3(146.23,103.66) ; 143.64,104.67 143.39,104.67 142.37,105.7 142.37,106.69 140.87,108.18 136,108.18 134.75,109.43 134.75,112.97 130.82,116.89 129.34,116.89 129.2,116.76 129.2,116.31 129.13,116.24 C0607.1 ; 143.64,104.67 v1(143.64,104.45)
  BOTTOM w0.121: U7000.BH41 146.41,103.91 146.41,103.84 v3(146.23,103.66)
EXP_TXN0: length 18.6
  BOTTOM w0.076: 116.14,108.82 115.59,108.82 115.43,108.97 114.39,108.97 114.36,109 U0300.B10
  BOTTOM w0.121: C7014.2 125.99,101.15 125.86,101.02 125.86,100.57 125.79,100.5 125.57,100.5 125.37,100.7 125.37,101.39 124.36,102.39 124.36,104.24 122.35,106.26 121.8,106.26 121.44,106.61 121.44,107.51 120.33,108.62 119.72,108.62 ; 119.72,108.62 119.44,108.62 119.23,108.82 116.14,108.82 ; 119.72,108.62 v1(119.72,108.84)
EXP_TXN0_C: length 21.1
  BOTTOM w0.102: U7000.BK27 144.94,94.25 144.58,94.61 144.25,94.61 143.99,94.86 143.3,94.86 143.22,94.78 142.9,94.78 142.88,94.8 142.86,94.8
  BOTTOM w0.121: 133.23,96.66 132.36,96.66 128.22,100.8 127.58,100.8 C7014.1 ; 133.23,96.66 v1(133.23,96.88) ; 133.23,96.66 133.99,96.66 135.85,94.8 142.86,94.8
EXP_TXN1: length 16.7
  BOTTOM w0.121: 122.35,107.21 124.82,104.73 124.82,102.8 125.53,102.09 C7005.2 ; 122.35,107.21 v1(122.18,107.04) ; 122.35,107.21 120.12,109.43 116.34,109.43 116.15,109.63 115.12,109.63 115.04,109.71 114.72,109.71 U0300.B11
EXP_TXN1_C: length 21.7
  BOTTOM w0.076: U7000.BL29 144.45,95.43 144.36,95.34 144.14,95.34 143.94,95.14 143.31,95.14 143.3,95.13 143.3,95.13
  BOTTOM w0.121: 143.3,95.13 143.05,95.13 142.96,95.23 136.03,95.23 128.81,102.45 128.81,102.62 128.69,102.74 127.82,102.74 127.73,102.65 127.73,102.52 127.92,102.32 127.92,102.16 127.86,102.09 C7005.1
EXP_TXN2: length 17.5
  BOTTOM w0.076: U0300.B12 114.14,110.85 114,110.71 114,110.59 114.05,110.54 115.36,110.54 115.43,110.46 116.5,110.46 116.6,110.37 116.89,110.37 116.91,110.39 116.93,110.39 116.98,110.44 116.99,110.44
  BOTTOM w0.121: C7010.2 126.04,104.45 125.92,104.45 125.72,104.65 125.72,104.97 126.4,105.65 126.4,106.18 126.14,106.44 124.39,106.44 120.39,110.44 116.99,110.44
EXP_TXN2_C: length 20.7
  BOTTOM w0.121: C7010.1 127.54,104.43 128.93,104.43 129.72,103.64 129.72,102.8 136.4,96.12 143.52,96.12 U7000.BM30
EXP_TXN3: length 12.9
  BOTTOM w0.076: 117.1,110.87 117.07,110.9 116.81,110.9 116.47,111.25 114.76,111.25 U0300.B13
  BOTTOM w0.121: 117.1,110.87 120.58,110.87 124.54,106.92 C7021.2
EXP_TXN3_C: length 25.4
  BOTTOM w0.076: U7000.BK30 144.88,96.08 144.3,96.08 144.1,96.28 144.1,96.51
  BOTTOM w0.121: C7021.1 126.47,107.24 126.83,107.24 127.03,107.04 127.52,107.04 127.72,107.24 127.95,107.24 128.17,107.02 128.17,105.89 130.15,103.92 130.15,103.01 136.46,96.7 143.92,96.7 144.1,96.51
EXP_TXN4: length 15.6
  BOTTOM w0.076: 116.82,112.03 116.81,112.03 116.76,111.99 115.5,111.99 115.38,112.11 114.13,112.11 114.01,112.22 114.01,112.38 114.09,112.45 114.34,112.45 U0300.B14
  BOTTOM w0.121: C7023.2 126.98,108.49 124.29,108.49 120.94,111.84 117.61,111.84 117.42,112.03 116.82,112.03
EXP_TXN4_C: length 23
  BOTTOM w0.102: U7000.BL32 144.45,97.62 144.4,97.57 144.02,97.57 143.83,97.38 143.48,97.38 143.26,97.59 142.7,97.59
  BOTTOM w0.121: 142.7,97.59 136.88,97.59 131.1,103.38 131.1,104.23 129.09,106.24 129.09,107.71 128.66,108.13 128.66,108.74 128.58,108.82 C7023.1
EXP_TXN5: length 12.4
  BOTTOM w0.076: 116.5,112.54 116.5,112.55 116.49,112.55 116.47,112.57 116.16,112.57 115.89,112.84 114.88,112.84 114.5,113.22 U0300.B15
  BOTTOM w0.121: C7025.2 124.06,109.33 121.04,112.34 118.53,112.34 118.33,112.54 116.5,112.54 116.5,112.54
