# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CRITICAL: length 4.1
  TOP w0.254: U9702.9 90.53,181.2 90.39,181.34 R9719.1 89.69,181.74 89.77,181.82 T8715.1 89.97,182.35 90.54,182.93 90.54,183.07 SR9713.1
CSBU_1_R: length 6.6
  TOP w0.076: 296.93,59.44 296.23,59.44 U1201.K8
  TOP w0.102: 296.93,59.44 297.13,59.64 300.1,59.64 301.08,58.67 301.08,58.22 301.16,58.14 SR1204.1
CSBU_2_R: length 5.2
  TOP w0.102: SR1205.1 300.64,58.81 300.01,59.44 297.22,59.44 296.97,59.2 U1201.L8
DCPRTC: length 14.7
  TOP w0.254: v2(236.61,56.71) 236.61,56.67 237.05,56.23 238.61,56.23 239.34,55.5 240.88,55.5 241.32,55.06 243.42,55.06 244.07,55.71 v1(244.07,55.91) 244.36,56.19 244.36,57.04 244.7,57.38 246.54,57.38 246.73,57.58 247.72,57.58 C2623.1
  BOTTOM w0.102: U2000.BA26 236.61,56.76 v2(236.61,56.71)
DDC_GATE: length 20.4
  TOP w0.102: Q7206.6 284.45,118.92 284.55,119.03 284.92,119.03 285.1,118.86 Q7206.5 285.1,117.49 285.31,117.28 286.02,117.28 286.41,117.66 286.41,118.28 287.68,119.55 287.68,121.17 288.51,122 289.15,122 289.54,122.4 289.54,123.5 288.87,124.17 Q7202.1 288.87,125.37 289.72,126.22 289.72,128.35 289.63,128.44 Q7203.1 288.3,128.44 288.24,128.38 R7218.2 v1(287.84,129.37)
DDC_GATE_G: length 10.8
  TOP w0.102: Q4601.2 Q4601.5 287.9,119.23 287.55,118.88 287.55,116.75 v1(287.09,116.28) 286.45,115.65 286.45,114.76 286.1,114.41 R7230.2 285.75,114.75 Q7206.3
DDI1_BKLT_CTL: length 269.4
  TOP w0.102: v1(147.4,56.06) 147.09,55.75 v2(146.78,55.75)
  IN2 w0.102: v2(146.78,55.75) 146.78,55.09 147.31,54.55 148.9,54.55 152.23,51.22 152.23,47.82 155.7,44.36 185.38,44.36 186.39,43.35 191.91,43.35 196.64,48.09 212.1,48.09 212.56,48.55 224.47,48.55 226.29,50.37 226.29,52.07 v2(226.97,52.75)
  IN3 w0.102: v2(128.38,169.4) 128.78,168.99 128.78,168 128.56,167.77 121.2,167.77 117.47,164.05 117.47,154.71 119.77,152.41 120.96,152.41 121.84,151.53 122.96,151.53 123.27,151.21 123.27,149.45 122.84,149.02 122.38,149.02 121.67,148.3 121.67,147.82 121.15,147.3 117.11,147.3 115.02,145.21 115.02,136.42 116.41,135.03 116.41,134.76 116.87,134.31 118.6,134.31 120,132.91 120,130.54 119.56,130.1 119.56,127.93 120.02,127.48 120.97,127.48 124.1,124.35 124.1,111.84 124.75,111.19 124.75,75.14 127.4,72.49 127.4,70.34 129.68,68.06 129.68,67.22 140.72,56.18 141.9,56.18 142.01,56.29 146.23,56.29 v2(146.78,55.75)
  IN4 w0.102: v2(128.38,169.4) 128.25,169.52 128.25,184.69 125.43,187.51 125.43,189.03 v2(124.49,189.97)
  BOTTOM w0.102: U2000.W36 226.87,52.75 v2(226.97,52.75) ; R4596.1 125.03,189.44 v2(124.49,189.97)
DDR_BST: length 2.3
  TOP w0.102: 28.66,54.62 29.34,55.3 v1(29.7,55.3)
  TOP w0.203: U8300.18 27.71,51.8
DDR_BST_R: length 1.9
  TOP w0.102: v1(32.34,53.25) 32.34,53.68 31.77,54.25 C8309.1
DDR_CS: length 2.3
  TOP w0.203: U8300.13 30.03,49.51 v1(30.21,49.33) 30.46,49.59 R8302.1
DDR_FB: length 5
  TOP w0.203: v1(23.43,46.44) 23.91,46.44 23.96,46.39 C8320.2 R8306.2 R8308.1 26.91,46.86 U8300.6
DDR_FB_R: length 83.1
  TOP w0.203: 24.44,44.72 C8320.1 R8306.1 ; 24.44,44.72 C8321.1 ; 24.44,44.72 24.38,44.72 22.64,46.46 22.1,46.46 16.12,52.45 v1(16.12,59.49) 16.12,61.21 v2(18.78,63.86)
  TOP w0.229: v2(37.95,104.5) 36.3,104.5 36.02,104.22 JP8304.2
  IN2 w0.254: v2(18.78,63.86) 18.47,64.17 18.47,68.96 20.24,70.72 29.86,70.72 32.84,73.7 32.84,83.26 37.67,88.1 37.67,104.22 v2(37.95,104.5)
DDR_HG: length 24.9
  TOP w0.203: 28.12,51.53 U8300.17
  IN4 w0.762: v4(28.91,52.33) 27.51,53.73 27.51,58 29.24,59.72 29.24,67.45 25.89,70.8 25.89,73.9
  vias: v1(29.44,52.92) v2(25.63,74.3) v2(26.27,74.3)
DDR_LG: length 17.7
  IN4 w0.762: v4(29.9,50.91) 30.69,50.91 32.01,52.23 32.01,66.22 v4(32.77,66.99)
  vias: v1(33.28,66.35)
DDR_LX: length 22.4
  IN4 w0.762: v4(31.76,74.66) 31.76,72.91 30.61,71.76 30.61,58.12 29.47,56.98 29.47,54.46 30.33,53.6
  vias: v2(30.33,52.64) v2(30.33,52)
DDR_PWRGD: length 174.1
  TOP w0.102: v2(28.68,47.48) 28.52,47.64 U8300.10 ; SR9208.1 163.33,42.29 163.21,42.17 v2(162.69,42.17) 162.67,42.2 T9202.1
  IN2 w0.102: v2(28.68,47.48) 30.38,45.78 30.38,34.75 32.66,32.47 34.09,32.47 34.8,31.76 39.74,31.76 45.13,26.37 108.83,26.37 109.61,25.58 130.32,25.58 132.65,23.25 151.43,23.25 151.64,23.45 153.05,23.45 153.25,23.65 158.05,23.65 158.51,24.12 v2(158.59,24.12)
  BOTTOM w0.102: v2(28.68,47.48) 28.17,47.98 T8300.1 ; v2(158.59,24.12) 158.59,24.55 159.78,25.74 160.38,25.74 160.98,26.33 161.92,26.33 163.28,27.69 163.28,30.46 164.7,31.88 165.53,31.88 165.89,32.25 165.89,36.73 163.58,39.04 163.58,41.28 v2(162.69,42.17)
DDR_RC:
  vias: v1(26.14,68.18)
DDR_VDD: length 7.4
  TOP w0.102: v1(33.62,50.95) 33.76,50.81 33.76,48.81 33.67,48.71 SR8302.2
  TOP w0.203: U8300.12 29.59,49.11
  TOP w0.381: 29.59,49.11 30.3,48.41 SR8303.1 31.06,48.7 C8318.1 32.3,48.71 SR8302.2
DDR_VDDQ: length 85.6
  TOP w0.203: v2(18.75,63) v1(17.62,61.87) 16.67,60.92 16.67,52.66 22.38,46.95 25.74,46.95 26.04,47.25 26.04,48.51 26.24,48.71 U8300.5
  TOP w0.229: v2(37.95,105.14) 36.43,105.14 35.44,104.15 JP8303.2
  IN2 w0.254: v2(37.95,105.14) 37.83,105.14 37.32,104.63 37.32,88.25 32.37,83.29 32.37,73.9 29.66,71.19 20.04,71.19 17.99,69.14 17.99,63.76 v2(18.75,63)
DDR_VID: length 4.1
  TOP w0.203: R8303.1 30.98,47.35 SR8303.2 29.69,47.57 v2(29.24,48.01) 29.06,48.19 U8300.11
  BOTTOM w0.102: v2(29.24,48.01) 29.85,48.01 v1(29.95,48.11)
DDR_VTT_CNTL_R: length 3.4
  BOTTOM w0.102: U0701.2 67.71,107.13 67.57,107.27 67.17,107.27 R0728.2 65.82,107.18 v1(65.82,106.92)
DDR_VTT_CNTRL: length 114.7
  TOP w0.102: v2(60.15,106.33) v1(60.67,106.85) ; v2(32.62,44.45) 32.33,44.74 30.54,44.74 30.41,44.61 R8304.2 R8305.1 28.23,43.24 28.58,42.88 D8300.2 ; v2(22.84,58.4) 22.17,58.4 SR5703.1
  IN1 w0.102: v2(60.15,106.33) 53.5,106.33 47.73,100.57 47.73,94.88 46.56,93.71 42.04,93.71 35.6,87.27 35.6,55.79 v2(34.86,55.05) 34.86,48.64 32.62,46.4 v2(32.62,44.45)
  BOTTOM w0.102: v2(34.86,55.05) 33.56,56.34 25.2,56.34 24.18,57.36 24.13,57.39 23.5,58.02 23.12,58.4 v2(22.84,58.4) ; U0701.4 68.36,103.51 68.14,103.29 R0704.2 R0755.2 68.14,101.97 67.63,101.47 65.02,101.47 v2(60.15,106.33)
DDR_VTT_CNTRL#: length 9.5
  TOP w0.102: v1(17.41,57.92) 16.92,58.4 16.92,59.85 R5712.2 17.51,60.87 19.49,62.85 Q5708.3 19.77,61.96 20.49,61.24 Q5709.1
DDR_VTTSNS: length 3.7
  TOP w0.203: JP8300.2 24.76,51.98 25.18,51.56 v1(25.18,50.27) 25.39,50.06 25.88,50.06 26.02,49.91 U8300.2
DDRA_VREF_CA_R: length 3.3
  BOTTOM w0.305: R1610.2 R1612.1 SR1602.1 SR1601.1
DDRA_VREF_CA_R_W10S12: length 16.1
  TOP w0.305: R0505.1 68.53,101.17 68.74,101.38 C0501.1 v1(68.74,102.83) 68.74,105.82 71.86,108.95 72.62,108.95 73.62,109.94 75.77,109.94 76.16,110.32 76.16,110.51 v3(76.66,111.02)
  BOTTOM w0.254: U0300.BN13 76.34,111.35 v3(76.66,111.02)
DDRA_VREF_CA_W10S12: length 115
  TOP w0.254: v2(85.5,59.93) 85.4,59.93 85.05,60.28 85.05,61.96 85.37,62.29 CON1600.164 85.37,65.79 85.12,66.05 85.12,67.21 85.42,67.51 v2(87.84,67.51)
  TOP w0.305: R0505.2 v1(65.89,100.52) 64.07,100.52 61.83,98.28 56.62,98.28 v2(56.48,98.14) ; v2(88.27,71.72) 81.77,78.21 39.45,78.21 38.7,78.96 v2(38.7,79.26)
  IN4 w0.305: v2(56.48,98.14) 53.12,94.77 53.12,94.28 38.7,79.86 v2(38.7,79.26)
  BOTTOM w0.254: CON1601.164 83.37,57.72 84.49,58.83 84.49,58.91 v2(85.5,59.93)
  BOTTOM w0.305: C1615.2 C1613.2 84.97,69.63 C1612.1 SR1602.2 ; C1615.2 87.11,67.92 87.52,67.51 v2(87.84,67.51) ; C1615.2 87.11,69.32 87.23,69.45 87.94,69.45 88.15,69.65 C1614.1 SR1601.2 88.15,71.59 v2(88.27,71.72)
DDRB_VREF_CA_R: length 3.9
  TOP w0.305: v1(60.05,103.74) 60.36,103.44 R1710.2 SR1701.1 SR1702.1 R1714.1
DDRB_VREF_CA_R_W10S12: length 16.3
  TOP w0.305: v3(73.68,111.91) 73.04,111.26 72.42,111.26 70.54,109.38 70.54,108.74 67.23,105.43 v1(65.55,105.43) 64.99,105.43 64.13,104.56 R0508.1 64.13,103.24 64.12,103.23 C0502.1
  BOTTOM w0.229: U0300.BR13 74.64,111.81 73.78,111.81 v3(73.68,111.91)
DDRB_VREF_CA_W10S12: length 132.6
  TOP w0.305: CON1700.164 85.37,51.45 84.16,50.23 84.16,47.54 83.78,47.16 v2(83.47,47.16) ; v2(58.09,99.27) 58.32,99.04 61.27,99.04 v1(61.32,99.09) 62.13,99.91 C1714.1 C1712.1 SR1702.2 SR1701.2 62.13,103.15 61.88,103.41 C1715.1 62.11,103.97 R0508.2
  IN1 w0.305: v2(58.09,99.27) 58.09,98.66 44.05,84.61 44.05,83.5 38.28,77.73 38.28,45.73 43.39,40.62 v2(62.95,40.62)
  BOTTOM w0.305: v2(83.47,47.16) 83.37,47.06 CON1701.164 C1713.1 83.37,40.49 82.37,39.48 64.09,39.48 v2(62.95,40.62)
DEBUG1: length 8.3
  TOP w0.102: v1(302.57,53.73) 300.95,53.73 R1234.1 298.2,53.32 298.08,53.45 298.08,54 297.57,54.51 297.57,55.35 296.73,56.2 U1201.L2
DEBUG2: length 6.8
  TOP w0.076: 296.72,54.88 296.6,55 296.6,55.23 296.24,55.59 296.24,55.94 U1201.K2
  TOP w0.102: R1233.1 300.11,52.74 v1(299.65,52.74) 299.27,53.12 298.12,53.12 297.87,53.36 297.87,53.92 297.02,54.77 296.83,54.77 296.72,54.88
DEBUG3: length 5.5
  TOP w0.102: R1236.1 298.61,54.21 298.3,54.52 v1(298.3,55.02) 298.3,55.22 296.82,56.7 U1201.L3
DEBUG4: length 4.3
  TOP w0.076: U1201.K3 296.23,56.45 296.78,56.45 296.88,56.34
  TOP w0.102: R1235.1 297.77,54.59 297.77,55.46 296.88,56.34
DEBUGMODE: length 9.5
  TOP w0.102: R3301.1 289.8,96.98 289.8,97.13 287.79,99.14 286.06,99.14 v1(285.81,99.4) 285.59,99.18 284.37,99.18 283.39,100.16 U3300.5
DELAY_ALL_SYSTEM_PWRGD: length 236.9
  TOP w0.102: v2(123.6,27.92) 123.6,28.81 v1(123.35,29.06) 123.35,30.18 123.91,30.74 123.91,38.35 122.75,39.51 122.75,47.07 119.6,50.21 119.54,50.27 v2(119.54,52.79) ; U3002.84 156.06,20.43 156.02,20.48 156.02,21.59 154.13,23.48 153.12,23.48 v2(152.53,24.06)
  IN1 w0.102: v2(248.5,71.91) 248.5,70.09 243.62,65.21 243.62,50.99 243.65,50.96 243.65,45.92 242.31,44.58 240.88,44.58 238.61,42.32 238.61,41.62 237.64,40.65 234.58,40.65 234.15,40.22 232.13,40.22 229.85,37.93 225.14,37.93 224.69,38.39 217.29,38.39 209.95,31.05 209.19,31.05 202.18,24.03 198.51,24.03 197.81,23.34 188.64,23.34 187.19,24.79 153.26,24.79 v2(152.53,24.06) 152.13,24.47 150.15,24.47 v2(149.74,24.06) 149.33,24.47 142.23,24.47 139.31,27.39 127.93,27.39 127.14,28.18 123.86,28.18 v2(123.6,27.92)
  BOTTOM w0.102: v2(248.5,71.91) 248.71,72.12 252.08,72.12 252.7,71.5 253.38,71.5 253.96,70.92 255.65,70.92 255.76,71.03 R2486.1 ; R0756.1 120.38,78.16 121.14,77.4 121.14,75.04 120.81,74.71 119.02,74.71 116.26,71.95 116.26,66.17 116.35,66.08 116.35,60.9 118.27,58.99 118.27,53.65 119.13,52.79 v2(119.54,52.79) ; v2(152.53,24.06) 152.51,24.04 R3003.1 ; SR0701.1 149.7,24.02 v2(149.74,24.06)
DISPA_BCLK_L200MIL: length 5.1
  BOTTOM w0.089: 233.03,70.01 233.03,69.65 232.87,69.5 232.87,69.41 U2000.AM2
  BOTTOM w0.121: 233.03,70.01 233.03,70.15 233.16,70.28 233.16,72.87 v1(233.12,72.91) 232.74,73.29 R2311.2
DISPA_SDO_L200MIL: length 4.6
  BOTTOM w0.102: 232.75,70.22 U2000.AM1
  BOTTOM w0.121: R2307.2 231.9,73.25 232.93,72.22 232.93,70.46 232.75,70.28 232.75,70.22
DMI_RXN0: length 170.4
  IN4 w0.089: v3(112.74,108.1) 112.93,108.3 112.93,108.47 113.19,108.72 114.34,108.72 115.07,107.98 115.07,107.98 115.08,107.97 115.08,107.73
  IN4 w0.102: v2(216.06,57.39) 215.92,57.39 215.43,57.87 207.38,57.87 206.29,56.79 203.02,56.79 197.15,50.92 197.15,47.02 194.79,44.65 194.79,44.35 193.66,43.23 192.7,43.23 192.19,42.72 191.4,42.72 187.64,38.96 151.2,38.96 145.09,45.07 141.74,45.07 129.09,57.72 129.09,64.27 129.09,64.45 126.94,66.59 126.94,73.86 126.94,73.86 126.94,74.38 126.03,75.29 126.03,102.27 123.33,104.97 120.96,104.97 120.14,105.79 119.16,105.79 118.11,106.84 115.97,106.84 115.08,107.73
  BOTTOM w0.089: U0300.E8 112.74,108.03 v3(112.74,108.1)
  BOTTOM w0.121: v2(216.06,57.39) 216.11,57.44 217.81,57.44 218.08,57.17 U2000.C27
DMI_RXN1: length 170.2
  IN4 w0.102: v2(215.4,56.55) 215.25,56.4 214.31,56.4 213.79,56.91 207.33,56.91 206.52,56.1 203.38,56.1 197.77,50.49 197.77,46.76 195.42,44.41 195.42,44.11 193.92,42.6 192.95,42.6 192.44,42.09 191.65,42.09 187.89,38.34 149.18,38.34 143.64,43.87 142.04,43.87 128.4,57.51 128.4,64.25 126.32,66.34 126.32,74.12 125.41,75.03 125.41,101.92 122.97,104.35 120.7,104.35 119.89,105.16 118.9,105.16 117.91,106.15 115.42,106.15 113.87,107.7 112.48,107.7 v3(112.09,107.31)
  BOTTOM w0.089: U2000.B28 217.88,56.67 217.77,56.76 217.58,56.88 217.48,56.94 217.3,56.98 ; v3(112.09,107.31) 112.09,107.26 U0300.F6
  BOTTOM w0.121: 217.3,56.98 216.61,56.98 216.36,56.73 215.84,56.73 215.66,56.55 v2(215.4,56.55)
DMI_RXN2: length 168.2
  IN4 w0.102: v2(216.12,56.07) 215.63,55.58 207.37,55.58 206.53,54.74 202.9,54.74 198.39,50.23 198.39,46.84 198.39,46.5 196.06,44.16 196.06,43.86 194.18,41.98 193.21,41.98 192.7,41.47 191.91,41.47 188.14,37.7 148.8,37.7 143.47,43.03 141.84,43.03 127.69,57.18 127.69,64.08 125.7,66.08 125.7,73.82 124.78,74.74 124.78,99.39 119.63,104.54 118.94,104.54 118.75,104.35 117.23,104.35 116.99,104.59 115.65,104.59 114.28,105.97 114.28,106.61 113.9,106.98 113.2,106.98 v3(112.74,106.52)
  BOTTOM w0.089: U0300.E5 112.41,106.2 v3(112.74,106.52)
  BOTTOM w0.121: v2(216.12,56.07) 216.3,55.9 217.06,55.9 217.23,56.08 U2000.B29
DMI_RXN3: length 171.5
  IN4 w0.076: 112.72,105.97 112.71,105.99 112.67,105.99 112.3,106.36 112.3,106.56 111.56,107.3 111.56,108.29 111.19,108.66 110.99,108.66 v3(110.75,108.9)
  IN4 w0.102: 112.72,105.97 115.19,103.5 119.5,103.5 120.92,102.08 120.92,101.19 124.16,97.95 124.16,74.33 125.06,73.43 125.06,65.48 127.03,63.51 127.03,56.22 141.04,42.21 143.25,42.21 148.84,36.62 187.14,36.62 187.14,36.62 187.17,36.62 187.63,37.08 188.44,37.08 192.21,40.85 192.96,40.85 193.47,41.36 194.43,41.36 196.51,43.44 196.56,43.44 196.9,43.44 199.09,45.63 199.09,48.83 204.34,54.07 206.77,54.07 207.65,54.95 v2(214.61,54.95)
  BOTTOM w0.089: U0300.J9 110.63,108.9 v3(110.75,108.9)
  BOTTOM w0.121: v2(214.61,54.95) 215.11,54.95 215.76,55.6 217.07,55.6 217.18,55.71 217.56,55.71 217.81,55.46 U2000.B30
DMI_RXP0: length 170.3
  IN4 w0.089: 114.93,107.58 114.9,107.61 114.9,107.91 114.26,108.54 113.26,108.54 113.11,108.39 113.11,108.19 113.2,108.1 v3(113.39,108.1)
  IN4 w0.102: v2(215.37,57.16) 215.55,57.33 215.55,57.45 215.34,57.66 207.47,57.66 206.38,56.57 203.1,56.57 197.36,50.83 197.36,46.93 195,44.57 195,44.26 193.75,43.01 192.79,43.01 192.28,42.5 191.49,42.5 187.73,38.74 151.11,38.74 145,44.85 141.65,44.85 128.87,57.63 128.87,64.36 126.73,66.51 126.73,73.95 126.73,73.95 126.73,74.29 125.81,75.2 125.81,102.18 123.24,104.76 120.87,104.76 120.05,105.57 119.07,105.57 118.02,106.62 115.88,106.62 114.93,107.58
  BOTTOM w0.089: U0300.D8 113.06,107.77 v3(113.39,108.1)
  BOTTOM w0.121: U2000.B27 217.64,57.2 216.51,57.2 216.26,56.95 215.58,56.95 v2(215.37,57.16)
DMI_RXP1: length 170.2
  IN4 w0.102: v3(112.74,107.31) 112.92,107.49 113.78,107.49 115.33,105.94 117.82,105.94 118.81,104.95 119.8,104.95 120.61,104.13 122.88,104.13 125.19,101.83 125.19,74.94 126.1,74.03 126.1,66.25 128.19,64.16 128.19,57.42 141.95,43.66 143.55,43.66 149.09,38.12 187.98,38.12 191.74,41.88 192.53,41.88 193.04,42.39 194.01,42.39 195.64,44.02 195.64,44.32 197.98,46.67 197.98,50.4 203.47,55.89 206.61,55.89 207.42,56.69 213.7,56.69 214.22,56.18 214.9,56.18 v2(215.09,55.99)
  BOTTOM w0.089: v3(112.74,107.31) 112.74,107.06 112.6,106.92 U0300.E6
  BOTTOM w0.121: U2000.A28 217.34,56.74 216.71,56.74 216.46,56.5 215.94,56.5 215.68,56.23 215.68,55.89 215.17,55.38 215.08,55.38 215,55.46 215,55.9 v2(215.09,55.99)
DMI_RXP2: length 168.2
  IN4 w0.102: v3(113.39,106.52) 113.39,106.6 113.56,106.77 113.81,106.77 114.06,106.52 114.06,105.88 115.56,104.38 116.9,104.38 117.14,104.13 118.84,104.13 119.03,104.32 119.54,104.32 124.57,99.3 124.57,74.65 125.48,73.74 125.48,65.99 127.48,64 127.48,57.09 141.75,42.82 143.38,42.82 148.71,37.48 188.23,37.48 192,41.26 192.79,41.26 193.3,41.77 194.27,41.77 196.27,43.77 196.27,44.07 198.61,46.41 198.61,46.93 198.61,50.14 202.99,54.53 206.62,54.53 207.46,55.37 215.72,55.37 215.8,55.44 215.81,55.44 215.97,55.61 216.24,55.61 216.88,56.26 v2(216.88,56.32)
  BOTTOM w0.089: U0300.D5 113.39,106.45 v3(113.39,106.52)
  BOTTOM w0.121: v2(216.88,56.32) 216.89,56.32 217.99,56.32 218.23,56.08 U2000.C29
DMI_RXP3: length 171.5
  IN4 w0.076: 112.57,105.82 112.55,105.83 112.55,105.87 112.13,106.29 112.13,106.49 111.4,107.23 111.4,108.22 111.13,108.49 110.85,108.49 110.79,108.43 v3(110.79,108.1)
  IN4 w0.102: 112.57,105.82 112.87,105.52 115.1,103.28 119.41,103.28 120.71,101.99 120.71,101.1 123.95,97.86 123.95,74.24 124.84,73.34 124.84,65.39 126.82,63.42 126.82,56.13 140.95,41.99 143.16,41.99 148.75,36.4 187.23,36.4 187.23,36.41 187.26,36.41 187.72,36.86 188.53,36.86 192.3,40.63 193.05,40.63 193.56,41.14 194.52,41.14 196.6,43.22 196.99,43.22 199.31,45.54 199.31,45.72 199.31,48.74 204.43,53.86 206.86,53.86 207.74,54.73 213.79,54.73 v2(214.03,54.49)
  BOTTOM w0.089: U0300.J8 110.47,108.1 v3(110.79,108.1)
  BOTTOM w0.121: U2000.A30 217.26,55.46 217.16,55.36 215.86,55.36 215.21,54.71 214.99,54.71 214.59,54.31 214.2,54.31 v2(214.03,54.49)
DMI_TXN0: length 176.5
  IN4 w0.102: v2(221.42,57.76) 221.42,57.5 221.36,57.45 221,57.45 220.94,57.5 220.94,58.03 220.48,58.48 218.77,58.48 216.97,60.28 207.85,60.28 207.49,59.91 202,59.91 195.28,53.19 195.28,47.79 193.71,46.22 192.26,46.22 187.75,41.71 155,41.71 154.62,42.09 150.98,42.09 145.47,47.61 142.44,47.61 141.23,48.82 140.91,48.82 139.52,50.2 139.52,50.58 138.08,52.03 137.93,52.03 136.42,53.54 136.42,53.68 136.05,54.05 135.91,54.05 132.68,57.27 132.68,57.42 131.27,58.82 131.27,65.93 129.23,67.98 129.23,71.23 128.93,71.52 128.93,75.12 127.89,76.16 127.89,84.49 128.35,84.94 128.35,87.38 127.89,87.83 127.89,103.54 122.48,108.95 118.6,108.95 118.32,108.67 118.32,107.82 118.27,107.77 117.92,107.77 117.85,107.7 v2(117.85,107.27)
  BOTTOM w0.076: 116.14,107.8 116.12,107.8 116.08,107.83 115.6,107.83 115.41,108.02 114.83,108.02 114.74,107.93 114.69,107.89 114.69,107.64 114.75,107.58 114.89,107.58 U0300.A8
  BOTTOM w0.121: U2000.L27 222,57.19 221.68,57.51 221.66,57.51 v2(221.42,57.76) ; 116.14,107.8 118.08,107.8 118.19,107.68 118.19,107.52 117.95,107.27 v2(117.85,107.27)
DMI_TXN1: length 174.7
  IN4 w0.102: v2(219.2,58.93) 219.48,59.2 219.48,59.28 219.29,59.46 218.66,59.46 217.39,60.73 212.24,60.73 210.84,62.12 203.5,62.12 194.87,53.5 194.87,47.96 193.54,46.63 192.09,46.63 187.58,42.12 163.44,42.12 162.97,42.59 151.1,42.59 145.51,48.18 143.2,48.18 132.98,58.4 132.98,60.84 131.76,62.06 131.76,66.02 129.64,68.14 129.64,71.39 129.34,71.69 129.34,75.35 128.3,76.38 128.3,82.24 128.75,82.69 128.75,87.55 128.3,88 128.3,103.77 122.44,109.63 118.52,109.63 116.84,107.95 116.84,107.81 116.91,107.74 117.3,107.74 117.41,107.63 117.41,107.55 v3(117.19,107.34)
  BOTTOM w0.076: U0300.B6 114.15,106.92 114.08,106.99 114.08,107.19 114.12,107.23 115.36,107.23 115.82,106.77 116.8,106.77 116.99,106.96 116.99,107.14 v3(117.19,107.34)
  BOTTOM w0.121: v2(219.2,58.93) 219.26,58.87 U2000.E24
DMI_TXN2: length 171
  IN4 w0.102: v2(119.86,107.26) 119.86,107.9 120.07,108.11 122.05,108.11 127.06,103.11 127.06,75.81 128.09,74.77 128.09,71.17 128.39,70.88 128.39,67.63 130.35,65.67 130.35,57.94 141.83,46.45 143.61,46.45 145.32,46.45 150.89,40.88 188.1,40.88 192.61,45.38 194.06,45.38 196.12,47.44 196.12,52.79 202.37,59.04 207.6,59.04 207.72,58.92 216.83,58.92 218.31,57.45 219.86,57.45 v2(220.22,57.81)
  BOTTOM w0.121: U0300.A5 115.13,106.27 117.71,106.27 117.99,106.55 119.16,106.55 119.87,107.26 v2(119.86,107.26) ; U2000.G27 220.02,57.61 v2(220.22,57.81)
DMI_TXN3: length 173.5
  IN4 w0.102: v2(222.61,56.42) 222.22,56.81 220.82,56.81 220.6,57.04 217.65,57.04 216.19,58.5 206.3,58.5 205.95,58.15 202.34,58.15 196.52,52.33 196.52,47.27 194.23,44.98 193.56,44.98 191.93,43.34 191.14,43.34 188.27,40.47 150.72,40.47 150.48,40.71 145.29,45.9 141.8,45.9 129.81,57.89 129.81,65.63 127.98,67.46 127.98,70.71 127.69,71.01 127.69,74.6 126.65,75.64 126.65,102.65 122.15,107.15 v2(120.64,107.15)
  BOTTOM w0.076: U0300.B4 113.9,105.56 113.9,105.67 113.97,105.75 114.59,105.75 114.69,105.85 115.88,105.85
  BOTTOM w0.121: U2000.L29 222.61,56.31 v2(222.61,56.42) ; v2(120.64,107.15) 120.47,106.98 120.21,106.98 119.08,105.85 115.88,105.85
DMI_TXP0: length 176.6
  IN4 w0.102: v2(118.53,107.27) 118.53,108.58 118.69,108.73 122.4,108.73 127.68,103.45 127.68,87.74 128.13,87.29 128.13,85.03 127.68,84.58 127.68,76.07 128.72,75.03 128.72,71.43 129.01,71.14 129.01,67.89 131.06,65.84 131.06,58.74 132.47,57.33 132.47,57.18 135.82,53.83 135.96,53.83 136.2,53.59 136.2,53.45 137.84,51.81 137.99,51.81 139.31,50.49 139.31,50.11 140.82,48.6 141.14,48.6 142.35,47.39 145.38,47.39 150.9,41.88 154.53,41.88 154.91,41.5 187.84,41.5 192.35,46 193.8,46 195.5,47.7 195.5,53.1 202.09,59.7 207.58,59.7 207.94,60.07 216.88,60.07 218.68,58.27 220.4,58.27 220.73,57.94 220.73,57.41 220.91,57.23 221.52,57.23 v2(222.04,57.76)
  BOTTOM w0.076: U0300.B8 114.47,107.81 114.47,107.9 114.62,108.05 114.76,108.19 115.48,108.19 115.67,108 116.08,108 116.12,108.03 116.14,108.03
  BOTTOM w0.121: v2(222.04,57.76) 222.28,57.53 222.45,57.53 222.79,57.19 U2000.N27 ; 116.14,108.03 118.18,108.03 118.43,107.78 118.43,107.38 v2(118.53,107.27)
DMI_TXP1: length 174.8
  IN4 w0.102: v2(219.86,58.93) 219.69,59.1 219.69,59.37 219.38,59.68 218.74,59.68 217.48,60.94 212.32,60.94 210.93,62.34 203.41,62.34 194.66,53.59 194.66,48.05 193.45,46.84 192,46.84 187.49,42.34 163.53,42.34 163.06,42.81 151.19,42.81 145.6,48.39 143.29,48.39 133.19,58.49 133.19,60.93 131.97,62.15 131.97,66.11 129.85,68.23 129.85,71.48 129.55,71.78 129.55,75.44 128.52,76.47 128.52,82.15 128.97,82.6 128.97,87.64 128.52,88.09 128.52,103.86 122.53,109.84 118.43,109.84 116.62,108.04 v3(116.62,107.31)
  BOTTOM w0.076: v3(116.62,107.31) 116.75,107.31 116.82,107.24 116.82,107.03 116.73,106.94 115.89,106.94 115.42,107.4 114.05,107.4 113.91,107.26 113.91,107.12 U0300.C6
  BOTTOM w0.121: U2000.G24 219.86,58.45 v2(219.86,58.93)
DMI_TXP2: length 171
  IN4 w0.102: v2(219.59,57.86) 219.4,57.67 218.4,57.67 216.92,59.14 207.81,59.14 207.69,59.25 202.28,59.25 195.9,52.88 195.9,47.53 193.97,45.6 192.52,45.6 188.01,41.09 150.98,41.09 145.41,46.67 141.92,46.67 130.56,58.03 130.56,65.76 128.61,67.72 128.61,70.97 128.31,71.26 128.31,74.86 127.27,75.9 127.27,103.2 122.14,108.33 119.98,108.33 119.65,107.99 119.65,107.65 v2(119.25,107.26)
  BOTTOM w0.121: v2(219.59,57.86) 219.59,57.51 U2000.E26 ; v2(119.25,107.26) 119.25,106.97 119.07,106.79 117.89,106.79 117.61,106.51 114.89,106.51 114.51,106.13 U0300.B5
DMI_TXP3: length 173.5
  IN4 w0.102: v2(120.36,106.51) 120.36,106.65 120.4,106.69 120.75,106.69 120.81,106.74 120.81,106.74 121,106.94 122.06,106.94 126.43,102.56 126.43,75.55 127.47,74.51 127.47,70.92 127.77,70.62 127.77,67.37 129.6,65.54 129.6,57.81 141.71,45.69 145.2,45.69 150.27,40.62 150.63,40.25 188.36,40.25 191.23,43.12 192.02,43.12 193.65,44.76 194.32,44.76 196.74,47.18 196.74,52.24 202.43,57.93 206.04,57.93 206.39,58.29 216.1,58.29 217.56,56.83 220.51,56.83 220.73,56.6 221.71,56.6 v2(221.92,56.39)
  BOTTOM w0.076: 115.84,105.61 115.77,105.68 114.76,105.68 114.18,105.1 113.54,105.1 U0300.D4
  BOTTOM w0.121: U2000.K29 221.85,56 221.92,56.08 v2(221.92,56.39) ; v2(120.36,106.51) 120.07,106.51 119.18,105.61 115.84,105.61
DMIC_CLK: length 525.3
  TOP w0.254: CON4500.28 108.75,189.72 108.49,189.97 v2(108.24,189.97) ; v2(44.56,21.01) 44.56,20.89 41.88,18.21 38.78,18.21 37.83,17.25 33.78,17.25 33.09,16.57 32.67,16.57 31.88,15.78 28,15.78 26.63,14.41 24.9,14.41 v1(24.33,14.98) 24.06,15.26 18.62,15.26 18.37,15 10.12,15 8.9,16.21 8.02,16.21 7.1,17.13 7.1,21.07 7.1,21.07 7.14,21.12 7.14,22.03 C3627.1 6.84,22.69 6.84,23.3 R3611.1 ; v2(205.21,19.54) 205.21,19.92 204.86,20.27 204.86,23.7 206.33,25.17 206.33,27 213.91,34.58 216.8,34.58 218.75,36.53 220.86,36.53 222.18,37.85 227.52,37.85 228.96,39.29 228.96,44.61 R2376.1
  IN1 w0.254: v2(52.43,132.06) 50.15,132.06 48.37,130.28 48.37,129.44 43.82,124.89 43.82,119.6 46.51,116.91 46.51,111.13 39.05,103.66 39.05,93.55 32.4,86.91 32.4,75.84 32.87,75.37 32.87,73.67 31.02,71.81 20.06,71.81 17.72,69.48 17.72,64.86 17.11,64.25 17.11,60.49 16.59,59.97 16.59,55.07 25.13,46.54 26.8,46.54 27.74,45.6 27.74,44.81 29.09,43.47 29.09,41.79 29.37,41.51 29.37,37.88 30.21,37.04 30.21,31.12 28.85,29.76 28.85,27.62 30.87,25.6 30.87,23.99 31.66,23.2 39.43,23.2 42.05,20.58 44.13,20.58 v2(44.56,21.01) 45.02,21.47 46.29,21.47 47.16,20.61 54.15,20.61 55.21,21.66 66.31,21.66 67.93,20.05 113.62,20.05 118.37,24.79 121.86,24.79 122.89,23.76 128.93,23.76 131.95,20.73 132.72,20.73 133.64,19.82 133.64,17.54 134.33,16.85 136.55,16.85 137.24,16.16 137.24,15.38 137.64,14.98 140.35,14.98 141.71,16.34 145.52,16.34 148.37,19.18 165.39,19.18 166.63,17.95 204.51,17.95 205.21,18.65 v2(205.21,19.54)
  IN4 w0.254: v2(108.24,189.97) 108.11,189.97 107.7,189.57 107.7,189.19 106.05,187.54 98.18,187.54 97.85,187.87 89.41,187.87 88.55,187 87.17,187 85.92,185.76 74.5,185.76 66.4,177.66 66.4,173.08 66.64,172.85 66.64,167.24 65.6,166.2 62.07,166.2 60.72,164.85 58.71,164.85 57.96,164.1 57.96,156.26 56.01,154.31 56.01,151.19 56.93,150.27 56.93,148.37 56.28,147.72 56.28,134.86 53.48,132.06 v2(52.43,132.06)
DMIC_DATA: length 529.5
  TOP w0.254: CON4500.30 107.75,189.14 107.68,189.21 107.68,189.47 107.12,190.02 106.79,190.02 v2(106.79,190.02) ; R2375.2 229.95,44.33 229.47,43.85 229.47,39.08 227.73,37.35 222.46,37.35 221.11,36 219.08,36 217.1,34.02 214.07,34.02 206.84,26.79 206.84,24.96 205.37,23.49 205.37,20.5 205.85,20.02 v2(205.85,19.54) ; v2(45.4,20.96) 45.4,20.79 42.21,17.6 39.11,17.6 38.26,16.74 33.99,16.74 33.2,15.96 32.82,15.96 32.14,15.27 29.24,15.27 v1(29.06,15.09) 28.03,15.09 26.84,13.9 24.48,13.9 23.63,14.75 18.83,14.75 18.58,14.49 9.91,14.49 8.69,15.7 7.81,15.7 6.59,16.92 6.59,17.88 5.19,19.28 5.19,21.83 5.82,22.46 C3628.1 5.82,22.84 5.95,22.97 R3610.1
  IN1 w0.254: v2(52.46,132.75) 50.12,132.75 47.86,130.49 47.86,129.65 43.31,125.1 43.31,119.39 46.01,116.7 46.01,111.36 38.53,103.89 38.53,93.76 31.82,87.04 31.82,75.71 32.37,75.16 32.37,73.97 30.71,72.32 19.85,72.32 17.21,69.69 17.21,65.07 16.6,64.46 16.6,60.7 16.08,60.18 16.08,54.86 24.92,46.03 26.59,46.03 27.24,45.39 27.24,44.6 28.58,43.26 28.58,41.51 28.86,41.23 28.86,37.67 29.7,36.83 29.7,31.33 28.34,29.97 28.34,27.28 30.36,25.26 30.36,23.78 31.45,22.69 39.22,22.69 41.84,20.07 44.51,20.07 v2(45.4,20.96) 46.08,20.96 46.95,20.1 54.36,20.1 55.42,21.15 66.08,21.15 67.7,19.54 113.83,19.54 118.58,24.28 121.65,24.28 122.68,23.25 128.72,23.25 131.74,20.23 132.51,20.23 133.13,19.61 133.13,17.33 134.12,16.34 136.34,16.34 136.68,16 136.68,15.22 137.43,14.47 140.56,14.47 141.92,15.83 145.78,15.83 148.62,18.68 165.18,18.68 166.42,17.44 204.73,17.44 205.85,18.57 v2(205.85,19.54)
  IN4 w0.254: v2(106.79,190.02) 106.63,189.87 106.63,188.84 105.84,188.04 98.39,188.04 98.06,188.37 89.19,188.37 88.32,187.51 86.95,187.51 85.71,186.27 74.29,186.27 65.89,177.87 65.89,172.83 66.13,172.59 66.13,167.45 65.39,166.71 61.86,166.71 60.51,165.36 58.5,165.36 57.45,164.31 57.45,156.47 55.51,154.53 55.51,150.98 56.42,150.06 56.42,148.58 55.77,147.93 55.77,135.21 53.3,132.75 v2(52.46,132.75)
DP2_TXN0_C: length 4.1
  TOP w0.108: 259.77,48.67 v1(259.77,48.45) ; 259.77,48.67 259.62,48.67 259.39,48.9 259.39,49.56 258.83,50.12 258.53,50.12 C1401.2 ; 259.77,48.67 260.21,48.67 260.32,48.79 260.57,48.79 260.72,48.64 U1401.39
DP2_TXN1_C: length 3.5
  TOP w0.108: U1401.42 260.69,47.14 260.54,47.3 259.89,47.3 259.39,46.79 ; 259.39,46.79 259.12,46.52 258.61,46.52 C1402.2 ; 259.39,46.79 v1(259.54,46.64)
DP2_TXN2_C: length 3.8
  TOP w0.108: C1403.2 258.61,44.48 258.88,44.48 259.21,44.81 259.21,45.38 259.61,45.78 260.34,45.78 260.47,45.64 U1401.45
DP2_TXN3_C: length 4.3
  TOP w0.108: 259.12,42.65 258.93,42.47 258.62,42.47 C1406.2 ; 259.12,42.65 v1(259.29,42.48) ; 259.12,42.65 259.52,43.05 259.52,43.69 260.1,44.28 260.34,44.28 260.47,44.14 U1401.48
DP2_TXP0_C: length 4.2
  TOP w0.108: 259.26,50.02 v1(259.42,50.19) ; 259.26,50.02 259.63,49.66 259.63,49 259.72,48.91 260.11,48.91 260.23,49.03 260.56,49.03 260.67,49.14 U1401.38 ; 259.26,50.02 258.93,50.36 258.57,50.36 C1405.2
DP2_TXP1_C: length 3.2
  TOP w0.108: U1401.41 260.67,47.64 260.56,47.53 259.8,47.53 259.02,46.76 258.56,46.76 C1410.2
DP2_TXP2_C: length 3.8
  TOP w0.108: C1409.2 258.62,44.72 258.79,44.72 258.98,44.91 258.98,45.48 259.51,46.01 260.35,46.01 260.47,46.14 U1401.44
DP2_TXP3_C: length 4.3
  TOP w0.108: v1(259.72,44.56) 259.89,44.39 ; 259.89,44.39 260,44.51 260.34,44.51 260.47,44.64 U1401.47 ; 259.89,44.39 259.28,43.79 259.28,43.15 258.84,42.71 258.6,42.71 C1404.2
DP_AUXN: length 31
  TOP w0.108: R1415.2 266.14,51.63 v2(266.14,51.16) 265.92,50.94 265.92,50.58 266.02,50.48 U1401.27
  IN1 w0.095: v2(277.66,46.35) 277.42,46.11 274.93,46.11 272.86,48.19 271.48,48.19 269.29,50.38 266.05,50.38 265.93,50.51 265.93,50.95 v2(266.14,51.16)
  BOTTOM w0.108: v1(276.46,45.07) 276.68,45.07 ; 276.68,45.07 276.68,45.8 277,46.11 277.42,46.11 v2(277.66,46.35) ; 276.68,45.07 276.68,44.22 278.96,41.94 282.12,41.94 283.25,40.82 285.25,40.82 285.55,40.52 285.55,40.27 285.78,40.04 C1146.1
DP_AUXP: length 31
  TOP w0.108: U1401.28 265.52,50.48 265.68,50.65 265.68,50.99 v2(265.52,51.16) 265.55,51.19 265.55,51.66 R1416.1
  IN1 w0.095: v2(265.52,51.16) 265.69,50.99 265.69,50.41 265.95,50.15 269.19,50.15 271.38,47.96 272.76,47.96 274.83,45.88 277.53,45.88 v2(277.67,45.74)
  BOTTOM w0.108: v2(277.67,45.74) 277.53,45.88 277.1,45.88 276.92,45.7 276.92,44.31 279.05,42.18 282.22,42.18 283.34,41.05 283.8,41.05 ; 283.8,41.05 285.35,41.05 285.79,40.62 285.79,40.36 285.88,40.28 286.22,40.28 286.26,40.32 286.26,40.44 286.19,40.52 286.19,40.68 286.26,40.75 C1147.1 ; 283.8,41.05 v1(283.8,41.28)
DP_CEXT: length 2.7
  TOP w0.102: C1411.1 260.94,42.07 v1(261.12,42.25) 262.02,43.15 U1401.2
DP_CFG0: length 4.3
  TOP w0.102: U1401.5 263.52,42.56 v1(263.35,42.4) 262.89,41.93 262.8,41.93 262.65,41.78 262.65,41.05 R1406.1 R1403.2
DP_CFG1: length 4.7
  TOP w0.254: v1(256.39,48.11) 256.57,47.93 R1404.1 R1402.2 258.87,47.93 258.91,47.88 260.15,47.88 260.41,48.14 U1401.40
DP_DATA0: length 19.3
  TOP w0.108: v1(271.25,49.2) 271.25,48.98 ; 271.25,48.98 272.99,48.98 273.74,48.24 274.44,48.24 277.96,44.72 283.13,44.72 283.67,44.18 284.32,44.18 C1138.1 ; 271.25,48.98 268.15,48.98 267.99,49.14 U1401.23
DP_DATA0#: length 19.3
  TOP w0.108: v1(269.17,48.52) 269.17,48.74 ; 269.17,48.74 268.18,48.74 268.08,48.64 U1401.22 ; 269.17,48.74 272.89,48.74 273.64,48 274.34,48 277.86,44.48 283.04,44.48 283.57,43.95 284.34,43.95 C1139.1
DP_DATA1: length 19.8
  TOP w0.108: 282.25,43.14 283.31,43.14 283.76,42.7 284.57,42.7 C1140.1 ; 282.25,43.14 278.33,43.14 274.09,47.38 273.38,47.38 272.96,47.81 269.78,47.81 269.47,47.51 268.26,47.51 268.12,47.64 U1401.20 ; 282.25,43.14 v1(282.25,43.37)
DP_DATA1#: length 19.8
  TOP w0.108: v1(280.57,42.68) 280.57,42.91 ; 280.57,42.91 283.22,42.91 283.66,42.47 284.62,42.47 C1141.1 ; 280.57,42.91 278.23,42.91 273.99,47.15 273.28,47.15 272.86,47.57 269.88,47.57 269.57,47.27 268.2,47.27 268.07,47.14 U1401.19
DP_DATA2: length 20.1
  TOP w0.108: 278.77,42.04 283.19,42.04 284.04,41.2 284.61,41.2 C1142.1 ; 278.77,42.04 278.22,42.04 273.78,46.49 271,46.49 270.5,45.99 267.97,45.99 267.81,46.14 U1401.17 ; 278.77,42.04 v1(278.77,42.27)
DP_DATA2#: length 20
  TOP w0.108: U1401.16 267.82,45.64 267.93,45.75 270.59,45.75 271.1,46.25 273.68,46.25 278.13,41.81 282.56,41.81 ; C1143.1 284.71,40.97 283.94,40.97 283.1,41.81 282.56,41.81 ; v1(282.56,41.58) 282.56,41.81
DP_DATA3: length 20.6
  TOP w0.108: U1401.14 268.02,44.64 268.15,44.51 269.17,44.51 ; C1144.1 284.76,39.76 284.64,39.76 284.36,40.04 282.73,40.04 281.66,41.11 277.95,41.11 273.47,45.6 271.58,45.6 270.49,44.51 269.17,44.51 ; 269.17,44.51 v1(269.17,44.73)
DP_DATA3#: length 20.6
  TOP w0.108: C1145.1 284.74,39.52 284.54,39.52 284.26,39.81 282.63,39.81 281.56,40.88 280.45,40.88 ; v1(280.45,40.65) 280.45,40.88 ; 280.45,40.88 277.86,40.88 273.37,45.37 271.68,45.37 270.59,44.27 268.07,44.27 267.94,44.14 U1401.13
DP_DDI3_AUXN_C: length 4.6
  TOP w0.108: U1401.29 265.02,50.49 264.93,50.58 264.93,51.4 264.25,52.08 264.25,53.08 264.11,53.22 ; 264.11,53.22 263.78,53.54 263.6,53.54 263.38,53.77 C1408.2 ; 264.11,53.22 v1(264.29,53.4)
DP_DDI3_AUXP_C: length 4.6
  TOP w0.108: 264.21,51.79 264.7,51.3 264.7,50.62 264.52,50.45 U1401.30 ; 264.21,51.79 264.01,51.98 264.01,52.98 263.69,53.31 263.44,53.31 263.38,53.25 C1407.2 ; 264.21,51.79 v1(264.04,51.62)
DP_IFPC_DATA0: length 248.7
  TOP w0.108: C4622.1 289.98,115.09 v2(289.88,114.99)
  IN1 w0.095: v2(289.88,114.99) 290.28,114.59 290.28,110.4 286.82,106.94 286.82,103.33 278.52,95.03 277.25,95.03 275.06,92.84 271.01,92.84 265.88,87.71 261.82,87.71 257.47,83.35 253.46,83.35 251.54,81.43 245.26,81.43 243.1,79.27 242.16,79.27 241.23,78.34 239.2,78.34 238.86,77.99 236.67,77.99 235.53,76.86 224.71,76.86 220.4,72.55 215.55,72.55 215.06,72.06 205.92,72.06 193.66,59.8 193.66,52.9 190.55,49.78 190.55,45.15 187.74,42.35 163.33,42.35 163.1,42.58 153.35,42.58 152.74,42.58 132.18,63.13 132.18,80.55 138.36,86.73 141.16,86.73 144.07,89.64 148.57,89.64 148.85,89.37 148.85,89.15 148.97,89.03 v3(149,89)
  BOTTOM w0.108: v3(149,89) U7000.BE20
DP_IFPC_DATA0#: length 248.7
  TOP w0.108: v6(289.88,114.31) 289.88,114.39 290.34,114.86 290.5,114.86 290.61,114.75 290.61,113.98 290.68,113.9 290.85,113.9 C4623.1
  IN1 w0.095: v3(148.3,89) 148.53,89 148.62,89.08 148.62,89.27 148.48,89.41 144.17,89.41 141.26,86.49 138.46,86.49 132.42,80.45 132.42,63.23 152.83,42.81 153.25,42.81 153.25,42.81 163.2,42.81 163.43,42.58 187.64,42.58 190.31,45.25 190.31,49.88 193.43,52.99 193.43,59.9 205.82,72.29 214.96,72.29 215.45,72.78 220.3,72.78 224.62,77.1 235.44,77.1 236.57,78.23 238.76,78.23 239.11,78.58 241.13,78.58 242.07,79.51 243.01,79.51 245.17,81.67 251.44,81.67 253.36,83.59 257.37,83.59 261.73,87.94 265.78,87.94 270.91,93.08 274.96,93.08 277.15,95.26 278.42,95.26 286.59,103.43 286.59,107.04 290.05,110.5 290.05,114.14 v6(289.88,114.31)
  BOTTOM w0.108: v3(148.3,89) 148.3,89.68 148.23,89.75 148.02,89.75 147.95,89.68 U7000.BF20
DP_IFPC_DATA0#_C: length 5.5
  TOP w0.108: 294.65,114.86 292.92,114.86 292.58,114.53 292.34,114.53 C4623.2 ; 294.65,114.86 295.64,114.86 295.87,114.63 296.48,114.63 296.61,114.5 U4601.5 ; 294.65,114.86 v1(294.65,114.63)
DP_IFPC_DATA0_C: length 5.5
  TOP w0.108: 293.05,115.09 295.74,115.09 295.97,114.87 296.37,114.87 296.51,115 U4601.4 ; 293.05,115.09 v1(293.05,115.32) ; 293.05,115.09 292.82,115.09 292.49,114.76 292.34,114.76 C4622.2
DP_IFPC_DATA1: length 246.3
  TOP w0.108: v2(287.9,113.36) 288.2,113.06 288.63,113.06 C4624.1
  IN1 w0.095: v3(146.21,89.01) 146.05,88.84 145.92,88.84 145.7,89.07 144.61,89.07 141.33,85.78 138.46,85.78 132.92,80.24 132.92,63.44 153.04,43.31 161.86,43.31 162,43.46 169.62,43.46 170,43.08 187.43,43.08 189.81,45.46 189.81,50.09 191.47,51.74 191.47,55.15 191.56,55.25 192.35,55.25 192.59,55.48 192.59,56.05 192.36,56.29 191.56,56.29 191.47,56.38 191.47,56.76 191.56,56.86 192.36,56.86 192.59,57.09 192.59,57.67 192.36,57.9 191.56,57.9 191.47,57.99 191.47,58.65 205.61,72.8 214.4,72.8 215.43,73.82 215.43,75.5 215.96,76.03 220.55,76.03 222.43,77.9 230.8,77.9 231.63,78.73 238.55,78.73 238.9,79.08 240.57,79.08 243.9,82.41 243.9,83.3 244.68,84.08 249.9,84.08 250.16,84.34 254.38,84.34 255.35,85.31 256.6,85.31 257.74,86.44 258.93,86.44 261.27,88.77 265.84,88.77 270.7,93.63 274.58,93.63 277.43,96.48 277.43,98.64 278.44,99.64 278.71,99.64 279.15,100.08 279.15,100.34 279.83,101.02 281.71,101.02 286.07,105.37 286.07,107.46 288.81,110.2 288.81,112.9 288.55,113.16 288.09,113.16 v2(287.9,113.36)
  BOTTOM w0.108: v3(146.21,89.01) 146.21,89.01 U7000.BH20
DP_IFPC_DATA1#: length 246.2
  TOP w0.108: C4625.1 288.48,112.83 287.96,112.83 v2(287.88,112.75)
  IN1 w0.095: v3(146.9,89) 146.51,88.61 145.82,88.61 145.6,88.83 144.71,88.83 141.43,85.55 138.56,85.55 133.15,80.14 133.15,63.53 153.14,43.55 161.76,43.55 161.91,43.7 169.71,43.7 170.1,43.32 187.34,43.32 189.57,45.56 189.57,50.18 191.23,51.84 191.23,55.25 191.47,55.48 192.26,55.48 192.35,55.58 192.35,55.96 192.26,56.05 191.47,56.05 191.23,56.28 191.23,56.86 191.47,57.09 192.26,57.09 192.35,57.19 192.35,57.57 192.26,57.66 191.47,57.66 191.23,57.9 191.23,58.75 205.52,73.03 214.3,73.03 215.2,73.92 215.2,75.6 215.86,76.26 220.46,76.26 222.33,78.14 230.7,78.14 231.53,78.97 238.45,78.97 238.8,79.31 240.47,79.31 243.67,82.51 243.67,83.4 244.58,84.31 249.81,84.31 250.06,84.57 254.28,84.57 255.26,85.55 256.51,85.55 257.64,86.68 258.84,86.68 261.17,89.01 265.75,89.01 270.6,93.87 274.48,93.87 277.2,96.58 277.2,98.74 278.34,99.88 278.62,99.88 278.92,100.18 278.92,100.43 279.73,101.25 281.62,101.25 285.83,105.47 285.83,107.55 288.58,110.3 288.58,112.81 288.45,112.93 288.06,112.93 v2(287.88,112.75)
  BOTTOM w0.108: v3(146.9,89) 146.9,89.6 146.95,89.65 147.17,89.65 147.25,89.57 U7000.BG20
DP_IFPC_DATA1#_C: length 7.8
  TOP w0.108: v1(293.3,112.79) 293.3,113.02 ; 293.3,113.02 295.86,113.02 295.99,113.14 296.48,113.14 296.61,113 U4601.8 ; 293.3,113.02 292.64,113.02 292.28,112.65 290.66,112.65 290.56,112.76 290.07,112.76 C4625.2
DP_IFPC_DATA1_C: length 7.8
  TOP w0.108: U4601.7 296.59,113.5 296.45,113.37 295.89,113.37 295.77,113.25 292.55,113.25 292.18,112.88 291.5,112.88 ; C4624.2 290.07,112.99 290.65,112.99 290.76,112.88 291.5,112.88 ; 291.5,112.88 v1(291.5,113.11)
DP_IFPC_DATA2: length 246.2
  TOP w0.108: C4618.1 288.86,111.21 287.53,111.21 287.11,111.63 287.11,111.82 v6(287.38,112.1)
  IN1 w0.095: v6(287.38,112.1) 287.13,111.85 287.13,110.17 283.55,106.59 283.55,104.89 281.08,102.41 279.78,102.41 279.36,101.99 279.36,101.74 278.64,101.02 277.78,101.02 276.33,99.57 276.33,98.3 274.79,96.76 274.79,96.43 272.73,94.37 270.21,94.37 265.86,90.02 261.42,90.02 258.68,87.28 257.34,87.28 256.22,86.16 254.44,86.16 253.76,85.47 252.08,85.47 251.17,86.39 244.78,86.39 241.63,83.23 241.63,81.66 239.79,79.82 230.01,79.82 228.86,78.67 222.13,78.67 220.23,76.77 214.08,76.77 210.84,73.53 204.88,73.53 202.34,70.99 201.68,70.99 198.88,68.19 198.88,68.06 199.17,67.77 199.17,67.44 198.76,67.03 198.43,67.03 198.14,67.32 198.01,67.32 197.74,67.05 197.74,66.92 198.05,66.6 198.05,66.27 197.64,65.87 197.31,65.87 197,66.18 196.86,66.18 196.59,65.91 196.59,65.78 196.91,65.46 196.91,65.13 196.5,64.73 196.17,64.73 195.86,65.04 195.72,65.04 195.45,64.77 195.45,64.64 195.77,64.32 195.77,63.99 195.36,63.59 195.03,63.59 194.72,63.9 194.58,63.9 194.31,63.63 194.31,63.5 194.63,63.18 194.63,62.85 194.22,62.44 193.89,62.44 193.57,62.76 193.16,62.76 190.7,60.3 190.7,52.02 189.07,50.39 189.07,45.76 187.13,43.82 170.3,43.82 169.92,44.2 161.68,44.2 161.53,44.05 153.39,44.05 143.02,54.43 143.02,55.52 142.63,55.91 141.49,55.91 133.65,63.74 133.65,79.89 134.9,81.13 136.65,81.13 138.51,82.99 139.17,82.99 140.29,84.11 142.17,84.11 143.21,85.14 143.21,86.44 144.51,87.75 144.89,87.75 145.2,88.05 146.65,88.05 v3(146.9,88.3)
  BOTTOM w0.108: v3(146.9,88.3) U7000.BG18
DP_IFPC_DATA2#: length 246.3
  TOP w0.108: C4620.1 288.96,110.97 287.44,110.97 286.87,111.54 286.87,111.92 v2(286.7,112.1)
  IN1 w0.095: v2(286.7,112.1) 286.9,111.9 286.9,110.27 283.32,106.69 283.32,104.99 280.98,102.65 279.69,102.65 279.13,102.09 279.13,101.84 278.54,101.25 277.68,101.25 276.1,99.67 276.1,98.4 274.55,96.86 274.55,96.53 272.63,94.6 270.11,94.6 265.76,90.25 261.32,90.25 258.58,87.52 257.24,87.52 256.12,86.39 254.35,86.39 253.66,85.71 252.18,85.71 251.27,86.62 244.68,86.62 241.39,83.33 241.39,81.75 239.69,80.06 229.91,80.06 228.77,78.91 222.03,78.91 220.13,77 213.98,77 210.75,73.77 204.78,73.77 202.24,71.23 201.58,71.23 198.64,68.29 198.64,67.96 198.93,67.67 198.93,67.54 198.66,67.27 198.53,67.27 198.24,67.56 197.91,67.56 197.5,67.15 197.5,66.82 197.81,66.51 197.81,66.37 197.55,66.1 197.41,66.1 197.1,66.42 196.77,66.42 196.36,66.01 196.36,65.68 196.67,65.37 196.67,65.23 196.4,64.96 196.27,64.96 195.95,65.28 195.63,65.28 195.22,64.87 195.22,64.54 195.53,64.22 195.53,64.09 195.26,63.82 195.13,63.82 194.81,64.14 194.48,64.14 194.08,63.73 194.08,63.4 194.39,63.08 194.39,62.95 194.12,62.68 193.99,62.68 193.67,62.99 193.07,62.99 190.47,60.4 190.47,52.12 188.84,50.49 188.84,45.86 187.03,44.05 170.4,44.05 170.02,44.44 161.58,44.44 161.43,44.29 153.49,44.29 143.25,54.53 143.25,55.62 142.73,56.14 141.59,56.14 133.89,63.84 133.89,79.79 134.99,80.89 136.74,80.89 138.61,82.76 139.27,82.76 140.39,83.88 142.27,83.88 143.44,85.05 143.44,86.34 144.61,87.51 144.99,87.51 145.29,87.81 147.12,87.81 v3(147.62,88.31)
  BOTTOM w0.108: U7000.BF18 147.75,87.95 147.62,88.08 v3(147.62,88.31)
DP_IFPC_DATA2#_C: length 7.6
  TOP w0.108: 293.43,111.25 292.91,111.25 292.51,110.85 290.79,110.85 290.61,111.03 290.43,111.03 C4620.2 ; 293.43,111.25 295.63,111.25 296.01,111.64 296.48,111.64 296.61,111.5 U4601.11 ; 293.43,111.25 v1(293.43,111.03)
DP_IFPC_DATA2_C: length 7.6
  TOP w0.108: C4618.2 290.42,111.27 290.7,111.27 290.89,111.08 291.5,111.08 ; 291.5,111.08 292.41,111.08 292.82,111.49 295.53,111.49 295.92,111.87 296.45,111.87 296.58,112 U4601.10 ; 291.5,111.08 v1(291.5,111.31)
DP_IFPC_DATA3: length 246.9
  TOP w0.108: C4619.1 286.59,109.8 ; 286.59,109.8 v1(286.59,110.02) ; 286.59,109.8 286.25,109.8 285.91,110.14 v2(285.91,110.98)
  IN1 w0.095: v3(149,86.9) 149,86.9 148.86,87.04 148.86,87.38 148.67,87.56 145.6,87.56 144.3,86.26 144.3,85.02 142.45,83.17 140.41,83.17 139.49,82.26 138.82,82.26 136.88,80.32 135.74,80.32 135.45,80.02 134.94,80.02 134.39,79.48 134.39,67.32 135.72,66 135.72,64.32 136.64,63.4 138.39,63.4 138.58,63.21 138.58,61.4 143.26,56.72 143.26,56.55 143.66,56.15 143.76,56.05 143.76,54.75 153.73,44.79 161.22,44.79 161.37,44.94 170.23,44.94 170.56,44.61 186.3,44.61 188.23,46.53 188.23,52.69 189.94,54.41 189.94,61.5 193.01,64.57 193.14,64.57 193.51,64.2 193.84,64.2 194.25,64.61 194.25,64.94 193.88,65.3 193.88,65.44 194.15,65.71 194.28,65.71 194.65,65.34 194.98,65.34 195.39,65.75 195.39,66.08 195.02,66.44 195.02,66.58 195.29,66.85 195.42,66.85 195.79,66.48 196.12,66.48 196.53,66.89 196.53,67.22 196.16,67.59 196.16,67.72 196.43,67.99 196.56,67.99 196.93,67.62 197.26,67.62 197.67,68.03 197.67,68.36 197.3,68.73 197.3,68.86 197.57,69.13 197.71,69.13 198.07,68.76 198.4,68.76 198.81,69.17 198.81,69.5 198.44,69.87 198.44,70 200.17,71.73 202.01,71.73 204.55,74.27 210.46,74.27 213.7,77.5 219.87,77.5 221.99,79.62 228.7,79.62 229.65,80.58 239.4,80.58 240.89,82.06 240.89,83.54 244.61,87.26 251.36,87.26 252.02,86.6 253.59,86.6 255.11,88.12 258.43,88.12 261.12,90.81 265.49,90.81 269.8,95.12 272.44,95.12 274.03,96.71 274.03,98.41 278.21,102.59 278.64,102.59 279.18,103.14 279.18,103.54 279.55,103.91 281.33,103.91 282.82,105.4 282.82,107.1 285.76,110.04 285.76,110.83 v2(285.91,110.98)
  BOTTOM w0.108: U7000.BE17 149,86.9 v3(149,86.9)
DP_IFPC_DATA3#: length 246.9
  TOP w0.108: 288.83,109.56 289.41,109.56 289.46,109.51 289.46,109.05 289.61,108.91 C4621.1 ; 288.83,109.56 286.16,109.56 285.67,110.04 285.67,110.58 v2(285.27,110.98) ; 288.83,109.56 v1(288.83,109.34)
  IN1 w0.095: v3(148.3,86.9) 148.56,86.9 148.62,86.97 148.62,87.28 148.58,87.33 145.7,87.33 144.53,86.16 144.53,84.92 142.55,82.94 140.51,82.94 139.59,82.02 138.91,82.02 136.98,80.09 135.84,80.09 135.54,79.79 135.03,79.79 134.63,79.38 134.63,67.42 135.95,66.09 135.95,64.42 136.73,63.63 138.49,63.63 138.82,63.3 138.82,61.5 143.5,56.82 143.5,56.64 143.76,56.38 144,56.14 144,54.85 153.82,45.02 161.12,45.02 161.27,45.17 170.33,45.17 170.65,44.84 186.21,44.84 187.99,46.63 187.99,52.79 189.71,54.5 189.71,61.6 192.91,64.8 193.24,64.8 193.61,64.43 193.74,64.43 194.01,64.7 194.01,64.84 193.64,65.21 193.64,65.54 194.05,65.94 194.38,65.94 194.75,65.58 194.88,65.58 195.15,65.84 195.15,65.98 194.78,66.35 194.78,66.68 195.19,67.08 195.52,67.08 195.89,66.72 196.02,66.72 196.29,66.99 196.29,67.12 195.93,67.49 195.93,67.82 196.33,68.23 196.66,68.23 197.03,67.86 197.16,67.86 197.43,68.13 197.43,68.26 197.07,68.63 197.07,68.96 197.47,69.37 197.8,69.37 198.17,69 198.31,69 198.58,69.27 198.58,69.4 198.21,69.77 198.21,70.1 200.07,71.97 201.91,71.97 204.45,74.5 210.37,74.5 213.6,77.74 219.77,77.74 221.89,79.86 228.6,79.86 229.55,80.81 239.31,80.81 240.66,82.16 240.66,83.64 244.51,87.49 251.46,87.49 252.12,86.83 253.49,86.83 255.01,88.35 258.33,88.35 261.02,91.05 265.39,91.05 269.7,95.36 272.34,95.36 273.79,96.81 273.79,98.51 278.11,102.83 278.54,102.83 278.95,103.23 278.95,103.64 279.46,104.15 281.24,104.15 282.58,105.49 282.58,107.2 285.52,110.14 285.52,110.73 v2(285.27,110.98)
  BOTTOM w0.108: U7000.BF17 148.2,87.25 148.3,87.15 v3(148.3,86.9)
DP_IFPC_DATA3#_C: length 6.8
  TOP w0.108: C4621.2 291.15,109.26 292.13,109.26 ; U4601.14 296.61,110 296.48,110.14 293.6,110.14 292.72,109.26 292.13,109.26 ; 292.13,109.26 v1(292.13,109.03)
DP_IFPC_DATA3_C: length 6.8
  TOP w0.108: 295.18,110.37 296.48,110.37 296.61,110.5 U4601.13 ; 295.18,110.37 v1(295.18,110.59) ; 295.18,110.37 293.5,110.37 292.63,109.49 291.1,109.49 C4619.2
DP_IFPD_AUXN: length 166.8
  TOP w0.108: C1408.1 R7229.1 261.37,53.42 257.9,53.42 257.71,53.6 257.27,53.6 v2(257.26,53.61)
  IN2 w0.095: v3(142.96,81.5) 142.81,81.35 142.81,80.42 142.31,79.93 142.31,78.3 142.56,78.05 142.56,71.62 141.76,70.82 141.76,66.81 140.95,65.99 140.95,60.44 143.95,57.44 143.95,54.95 145.3,53.6 145.3,53.18 151.11,47.36 151.11,47.36 155.24,43.24 162.77,43.24 163.57,42.44 165.5,42.44 166.4,43.34 167.72,43.34 168.62,42.44 169.64,42.44 170.62,43.42 177.38,43.42 178.27,42.53 178.72,42.53 179.04,42.85 179.04,43.15 179.31,43.42 180.37,43.42 180.61,43.18 180.61,42.6 180.76,42.45 181.18,42.45 181.31,42.57 181.31,43.02 181.7,43.42 182.48,43.42 182.77,43.13 182.77,42.62 182.91,42.48 183.32,42.48 183.44,42.6 183.44,43.15 183.73,43.44 184.49,43.44 184.8,43.13 184.8,42.55 184.9,42.44 192.28,42.44 192.57,42.72 197.18,42.72 198.31,43.85 199.08,43.85 199.32,43.62 199.32,43.29 199.41,43.19 199.79,43.19 199.89,43.29 199.89,43.62 200.12,43.85 242.76,43.85 243.09,44.18 244.82,44.18 251.08,50.45 251.08,51.89 251.9,52.71 254.73,52.71 255.14,53.12 256.72,53.12 256.78,53.18 256.78,53.76 256.94,53.92 257.13,53.92 257.26,53.79 v2(257.26,53.61)
  BOTTOM w0.108: U7000.BM9 143.41,81.31 143.14,81.31 v3(142.96,81.5)
DP_IFPD_AUXP: length 166.9
  TOP w0.108: C1407.1 R7201.1 261.37,53.19 257.67,53.19 v2(257.58,53.09)
  IN2 w0.095: v3(142.4,81.49) 142.57,81.32 142.57,80.52 142.08,80.03 142.08,78.2 142.32,77.96 142.32,71.71 141.53,70.92 141.53,66.9 140.72,66.09 140.72,60.34 143.71,57.34 143.71,54.85 145.07,53.5 145.07,53.08 150.88,47.27 155.14,43.01 162.67,43.01 163.47,42.21 165.6,42.21 166.5,43.1 167.63,43.1 168.52,42.21 169.74,42.21 170.72,43.18 177.28,43.18 178.17,42.29 178.82,42.29 179.28,42.75 179.28,43.05 179.41,43.18 180.27,43.18 180.37,43.08 180.37,42.5 180.66,42.22 181.28,42.22 181.54,42.48 181.54,42.93 181.79,43.18 182.38,43.18 182.53,43.03 182.53,42.53 182.81,42.25 183.42,42.25 183.67,42.5 183.67,43.05 183.83,43.21 184.39,43.21 184.56,43.03 184.56,42.45 184.81,42.21 192.38,42.21 192.66,42.49 197.28,42.49 198.41,43.62 198.99,43.62 199.08,43.52 199.08,43.19 199.31,42.96 199.89,42.96 200.12,43.19 200.12,43.52 200.22,43.62 242.86,43.62 243.19,43.95 244.91,43.95 251.31,50.35 251.31,51.8 252,52.48 254.83,52.48 255.24,52.88 256.82,52.88 257.03,53.09 v2(257.58,53.09)
  BOTTOM w0.108: U7000.BM8 143.62,81.08 142.81,81.08 v3(142.4,81.49)
DP_IFPD_DATA0: length 167.4
  TOP w0.108: v2(256.75,50.36) 257.09,50.7 C1405.1
  IN2 w0.095: v2(256.75,50.36) 257.63,50.36 257.86,50.13 257.86,48.77 257.12,48.03 250.67,48.03 248.69,46.05 248.06,46.05 246.69,44.68 246.69,44.05 245.78,43.14 243.62,43.14 243.28,42.8 202.64,42.8 202.55,42.7 202.55,42.33 202.31,42.09 201.74,42.09 201.5,42.33 201.5,42.7 201.41,42.8 200.89,42.8 199.84,41.75 192.97,41.75 192.69,41.47 177.44,41.47 177.19,41.72 177.19,42.23 176.97,42.44 176.21,42.44 176.05,42.29 176.05,41.76 175.8,41.51 175.16,41.51 174.83,41.84 174.83,42.14 174.53,42.44 171.07,42.44 170.1,41.47 155.09,41.47 151.76,44.8 151.76,45.34 144.12,52.98 144.12,53.38 142.98,54.52 142.98,56.96 139.85,60.08 139.85,66.08 139.6,66.33 139.6,73 141.17,74.58 141.17,80.02 140.26,80.94 140.26,82.09 141.6,83.44 141.6,84.48 141.61,84.49 v3(141.61,84.74)
  BOTTOM w0.108: v3(141.61,84.74) 142.03,85.16 142.61,85.16 142.96,84.82 143.92,84.82 144.15,85.05 144.35,85.05 U7000.BL14
DP_IFPD_DATA0#: length 167.4
  TOP w0.108: C1401.1 256.71,49.81 v2(256.65,49.75)
  IN2 w0.095: v2(256.65,49.75) 256.65,49.56 256.75,49.46 257.03,49.46 257.13,49.56 257.13,50.07 257.19,50.13 257.53,50.13 257.63,50.03 257.63,48.87 257.03,48.27 250.58,48.27 248.6,46.29 247.96,46.29 246.46,44.78 246.46,44.15 245.68,43.37 243.52,43.37 243.19,43.03 202.54,43.03 202.31,42.8 202.31,42.43 202.21,42.33 201.83,42.33 201.74,42.43 201.74,42.8 201.51,43.03 200.79,43.03 199.74,41.98 192.87,41.98 192.59,41.7 177.54,41.7 177.42,41.82 177.42,42.32 177.07,42.68 176.11,42.68 175.82,42.39 175.82,41.86 175.7,41.75 175.26,41.75 175.07,41.94 175.07,42.24 174.63,42.68 170.97,42.68 170,41.7 155.19,41.7 152,44.89 152,45.43 144.35,53.08 144.35,53.47 143.21,54.62 143.21,57.06 140.09,60.18 140.09,66.17 139.83,66.43 139.83,72.9 141.41,74.48 141.41,80.12 140.49,81.03 140.49,82 141.84,83.34 141.84,84.39 v3(142.2,84.74)
  BOTTOM w0.108: U7000.BK14 144.81,84.81 144.25,84.81 144.02,84.58 142.86,84.58 142.52,84.93 142.38,84.93 v3(142.2,84.74)
DP_IFPD_DATA1: length 167.9
  TOP w0.108: v2(256.7,46.83) 256.96,47.1 C1410.1
  IN2 w0.095: v2(256.7,46.83) 256.61,46.92 255.89,46.92 255.45,47.36 253.01,47.36 251.86,46.21 249.71,46.21 245.7,42.2 242.73,42.2 242.4,41.87 240.17,41.87 239.48,41.18 209.99,41.18 209.23,41.94 208.36,41.94 207.6,41.18 206.92,41.18 206.81,41.28 206.81,41.89 206.43,42.27 205.75,42.27 205.49,42.02 205.49,41.28 205.39,41.18 204.53,41.18 204.4,41.31 204.4,42.02 204.12,42.3 203.46,42.3 203.23,42.07 203.23,41.28 203.13,41.18 193.11,41.18 192.9,40.97 172.99,40.97 172.9,41.06 172.9,41.64 172.6,41.94 171.86,41.94 171.58,41.66 171.58,41.1 171.44,40.97 154.88,40.97 151.26,44.59 151.26,45.13 143.51,52.88 143.51,53.23 140.06,56.67 140.06,58.58 138.56,60.08 138.56,61.22 138.84,61.5 138.84,77.27 139.59,78.01 139.59,79.55 139.2,79.94 139.2,82 139.99,82.79 139.99,84.27 v2(140.42,84.69)
  BOTTOM w0.108: v2(140.42,84.69) 140.42,84.36 140.47,84.31 144.02,84.31 144.25,84.08 144.26,84.08 144.56,84.08 144.89,83.75 U7000.BK12
DP_IFPD_DATA1#: length 168
  TOP w0.108: v2(256.06,46.41) 256.78,46.41 257.06,46.13 C1402.1
  IN2 w0.095: v2(256.06,46.41) 255.35,47.12 253.1,47.12 251.96,45.97 249.81,45.97 245.8,41.96 242.83,41.96 242.5,41.64 240.26,41.64 239.57,40.95 209.89,40.95 209.13,41.71 208.46,41.71 207.7,40.95 206.82,40.95 206.58,41.19 206.58,41.79 206.33,42.04 205.84,42.04 205.73,41.92 205.73,41.19 205.49,40.95 204.43,40.95 204.17,41.21 204.17,41.92 204.02,42.06 203.56,42.06 203.47,41.97 203.47,41.19 203.23,40.95 193.21,40.95 192.99,40.73 172.89,40.73 172.67,40.96 172.67,41.54 172.5,41.71 171.96,41.71 171.81,41.56 171.81,41 171.54,40.73 154.79,40.73 151.03,44.49 151.03,45.03 143.27,52.79 143.27,53.13 139.83,56.58 139.83,58.48 138.33,59.98 138.33,61.32 138.61,61.6 138.61,77.37 139.35,78.11 139.35,79.46 138.96,79.84 138.96,82.1 139.76,82.89 v2(139.76,84.69)
  BOTTOM w0.108: U7000.BL12 144.25,83.75 143.93,84.08 140.37,84.08 140.18,84.26 140.18,84.27 v2(139.76,84.69)
