# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHB_DQ16: length 88.1
  TOP w0.165: v2(52.1,49.11) 52.35,49.35 53.52,49.35 54.87,50.71 CON1700.50
  IN4 w0.076: v3(80.81,110.21) 80.27,109.67 80.27,108.2 78.78,106.71 78.63,106.71 78.39,106.47 78.39,104.86 78.17,104.65 77.37,104.65
  IN4 w0.114: 77.37,104.65 73.09,100.36 72.82,100.36 72.42,99.96 71.9,99.96 52.1,80.17 52.1,76.8 50.86,75.55 50.86,66.5 47.91,63.56 47.91,58.32 50.08,56.15 50.08,53.2 51.76,51.52 51.76,50.12 51.69,50.05 51.69,49.52 v2(52.1,49.11)
  BOTTOM w0.076: U0300.BG11 80.66,110.21 v3(80.81,110.21)
  BOTTOM w0.165: CON1701.45 51.62,51.59 51.82,51.39 51.98,51.39 52.15,51.22 52.15,50.76 51.97,50.58 51.85,50.58 51.62,50.36 51.62,49.59 v2(52.1,49.11)
M_CHB_DQ17: length 86.7
  TOP w0.165: v2(52.1,49.74) 53.22,49.74 53.87,50.4 CON1700.46
  IN4 w0.076: 77.49,104.29 77.68,104.48 78.24,104.48 78.8,105.04 78.8,105.74 79.34,106.27 79.34,106.62 79.98,107.26 79.98,107.68 80.43,108.13 80.43,109.45 80.56,109.57 v3(80.81,109.57)
  IN4 w0.114: 77.49,104.29 77.3,104.29 72.63,99.62 72.04,99.62 52.44,80.02 52.44,76.65 51.2,75.41 51.2,75.16 51.37,74.99 52.25,74.99 52.37,74.88 52.37,74.65 52.25,74.53 51.37,74.53 51.2,74.36 51.2,66.36 48.26,63.41 48.26,58.46 50.43,56.29 50.43,53.34 52.1,51.66 v2(52.1,49.74)
  BOTTOM w0.076: v3(80.81,109.57) 80.51,109.57 80.35,109.42 U0300.BG10
  BOTTOM w0.165: v2(52.1,49.74) 52.64,49.74 52.76,49.87 52.76,51.49 52.62,51.63 CON1701.49
M_CHB_DQ18: length 87.4
  TOP w0.165: CON1700.49 54.62,45.62 54.78,45.77 54.78,46.49 54.34,46.92 53.83,46.92 53.25,47.51 52.46,47.51 v2(52.13,47.84)
  IN4 w0.076: 78.08,104.06 79.03,105.01 79.03,105.73 79.52,106.22 79.52,106.57 80.14,107.19 80.14,107.61 v3(80.81,108.27)
  IN4 w0.114: v2(52.13,47.84) 52.13,48.55 52.52,48.94 52.52,51.73 50.77,53.48 50.77,56.44 48.6,58.61 48.6,63.27 51.54,66.22 51.54,73.05 52.05,73.56 52.05,73.72 51.91,73.87 51.91,74.03 52.07,74.19 52.23,74.19 52.38,74.04 52.54,74.04 52.79,74.29 52.79,79.88 72.12,99.21 72.7,99.21 73.67,100.18 74.73,100.18 76.18,101.63 76.18,102.16 78.08,104.06
  BOTTOM w0.076: U0300.BG8 80.35,108.18 80.44,108.27 v3(80.81,108.27)
  BOTTOM w0.165: v2(52.13,47.84) 51.32,47.84 51.14,47.66 51.14,47.26 51.55,46.85 51.55,46.39 51.88,46.06 CON1701.46
M_CHB_DQ19: length 88.2
  TOP w0.165: v2(55.13,49.03) 56.14,48.02 56.14,47.49 58.12,45.51 CON1700.63
  IN4 w0.076: v3(81.72,108.27) 81.72,108.19 82.09,107.82 82.09,107.47 80.58,105.96 80.58,104.15 80.11,103.68 79.56,103.68 78.73,102.86 78.73,102.04 76.74,100.05 76.54,100.05 76.36,99.86
  IN4 w0.114: 76.36,99.86 74.96,98.46 74.15,98.46 54.75,79.07 54.75,70.38 54.38,70 54.02,70 53.82,69.8 53.82,65.35 53.64,65.17 53.28,65.17 52.86,64.75 52.86,63.83 52.97,63.72 53.27,63.72 53.52,63.96 53.85,63.96 54,63.82 54,62.87 53.88,62.75 53.57,62.75 53.3,63.02 52.74,63.02 52.21,62.5 52.21,60.85 52.52,60.55 52.52,57.47 53.56,56.43 53.56,53.19 54.28,52.47 54.28,50.7 55.13,49.86 v2(55.13,49.03)
  BOTTOM w0.076: v3(81.72,108.27) 81.59,108.27 U0300.BF8
  BOTTOM w0.165: v2(55.13,49.03) 55.88,48.28 CON1701.62
M_CHB_DQ20: length 85.5
  TOP w0.165: v2(55.77,50.33) 55.97,50.53 55.97,50.71 56.96,51.69 56.96,51.92 56.87,52 CON1700.58
  IN4 w0.076: 79.58,101.56 79.72,101.69 80.18,101.69 80.56,102.08 80.56,103.17 80.91,103.52 80.91,105.82 82.42,107.33 82.42,108.04 82.27,108.19 82.27,109.66 v3(81.72,110.21)
  IN4 w0.114: 79.58,101.56 77.72,99.7 76.77,99.7 75.12,98.05 74.71,98.05 56.88,80.22 56.88,78.83 56.55,78.5 55.57,78.5 55.45,78.39 55.45,78.16 55.57,78.04 56.77,78.04 56.88,77.93 56.88,77.7 56.77,77.59 55.58,77.59 55.47,77.47 55.47,77.24 55.58,77.13 56.77,77.13 56.88,77.02 56.88,76.62 55.44,75.18 55.44,70.09 54.68,69.34 54.68,60.88 53.9,60.1 53.9,58.28 53.54,57.92 53.54,57.42 54.24,56.72 54.24,53.77 54.59,53.42 54.77,53.42 54.97,53.22 54.97,50.99 55.63,50.33 v2(55.77,50.33)
  BOTTOM w0.076: U0300.BF11 81.57,110.21 v3(81.72,110.21)
  BOTTOM w0.165: CON1701.63 56.13,50.68 v2(55.77,50.33)
M_CHB_DQ21: length 86.4
  TOP w0.165: v2(55.77,49.69) 56.2,49.69 56.37,49.87 56.37,50.55 57,51.18 57.39,51.18 57.87,51.66 CON1700.62
  IN4 w0.076: v3(81.72,109.57) 82.09,109.2 82.09,108.14 82.25,107.97 82.25,107.4 80.75,105.89 80.75,104.08 80.18,103.51 79.62,103.51 78.9,102.79 78.9,101.97 76.81,99.88 76.67,99.88 76.41,99.63
  IN4 w0.114: 76.41,99.63 75.04,98.25 74.43,98.25 55.94,79.77 55.94,79.6 56.21,79.33 56.21,79.17 56.05,79.01 55.89,79.01 55.62,79.28 55.45,79.28 55.1,78.92 55.1,76.79 55.21,76.67 55.97,76.67 56.09,76.55 56.09,76.32 55.99,76.21 55.21,76.21 55.1,76.1 55.1,70.23 54.34,69.48 54.34,64.94 54.23,64.82 53.65,64.82 53.54,64.71 53.54,64.48 53.65,64.37 54.23,64.37 54.34,64.25 54.34,61.04 53.56,60.26 53.56,58.42 53.2,58.07 53.2,57.28 53.9,56.57 53.9,53.33 54.62,52.61 54.62,50.84 55.77,49.69 v2(55.77,49.69)
  BOTTOM w0.076: v3(81.72,109.57) 81.59,109.57 U0300.BF10
  BOTTOM w0.165: CON1701.59 55.13,50.34 v2(55.77,49.69)
M_CHB_DQ22: length 85.9
  TOP w0.165: v2(52.33,46.6) 52.65,46.91 52.99,46.91 53.62,46.28 CON1700.45
  IN4 w0.076: 78.17,103.86 79.21,104.9 79.21,105.68 79.68,106.16 79.68,106.5 v3(80.81,107.62)
  IN4 w0.114: v2(52.33,46.6) 52.33,46.28 52.48,46.13 53.14,46.13 53.37,46.36 53.37,47.12 52.58,47.91 52.58,48.52 52.86,48.8 52.86,51.88 51.11,53.62 51.11,56.58 49.99,57.7 49.99,60.87 49.05,61.81 49.05,63.24 51.89,66.07 51.89,72.91 53.13,74.15 53.13,79.74 72.1,98.71 72.49,98.71 73.65,99.87 74.71,99.87 75.68,100.84 76.4,100.84 77.85,102.29 77.85,103.54 78.17,103.86
  BOTTOM w0.076: U0300.BG7 80.67,107.62 v3(80.81,107.62)
  BOTTOM w0.165: CON1701.50 52.88,46.68 52.77,46.78 52.52,46.78 v2(52.33,46.6)
M_CHB_DQ23: length 86.9
  TOP w0.165: CON1700.59 57.12,45.95 55.57,47.5 55.57,47.83 v2(55.08,48.32)
  IN4 w0.076: 76.25,100.04 76.42,100.21 76.67,100.21 78.57,102.11 78.57,102.92 79.49,103.84 80.04,103.84 80.42,104.21 80.42,106.21 81.72,107.51 v3(81.72,107.62)
  IN4 w0.114: v2(55.08,48.32) 55.08,47.05 54.94,46.91 54.19,46.91 53.96,47.13 53.96,48.05 54.66,48.75 54.66,49.84 53.94,50.56 53.94,52.32 53.22,53.05 53.22,56.29 52.17,57.33 52.17,60.41 51.87,60.71 51.87,64.24 53.48,65.85 53.48,70.03 54.41,70.96 54.41,79.21 74.02,98.81 75.02,98.81 76.25,100.04
  BOTTOM w0.076: U0300.BF7 81.26,107.42 81.47,107.62 v3(81.72,107.62)
  BOTTOM w0.165: v2(55.08,48.32) 54.88,48.12 CON1701.58
M_CHB_DQ24: length 82.4
  TOP w0.165: CON1700.79 62.12,45.42 62.54,45.84 62.54,46.11 61.8,46.85 61.15,46.85 v2(60.87,46.57)
  IN4 w0.076: 85.16,106.91 85.16,108.01 85,108.18 85,109.69 v3(84.46,110.22)
  IN4 w0.114: 85.16,106.91 84.58,106.33 84.58,101.6 81.13,98.15 80.59,98.15 60.97,78.53 60.97,67.18 60.45,66.65 60.45,53.6 60.87,53.18 60.87,48.83 61.86,47.84 61.86,47 61.43,46.57 v2(60.87,46.57)
  BOTTOM w0.076: v3(84.46,110.22) 84.33,110.22 U0300.BB11
  BOTTOM w0.165: CON1701.84 61.38,46.06 v2(60.87,46.57)
M_CHB_DQ25: length 84.1
  TOP w0.165: CON1700.70 59.87,50.83 58.78,49.74 v2(56.93,49.74)
  IN4 w0.076: v3(83.55,110.21) 83.16,109.82 83.16,109.63 83,109.46 83,108.2 82.76,107.95 82.76,107.44 81.66,106.33 81.66,104.03 80.73,103.1 80.73,102.01 80.23,101.51 80.09,101.51
  IN4 w0.114: 80.09,101.51 79.83,101.51 77.81,99.49 76.89,99.49 74.73,97.34 74.73,97.01 57.63,79.91 57.63,76.31 56.19,74.87 56.19,74.07 56.5,73.76 56.5,73.08 56.19,72.77 56.19,69.78 55.43,69.02 55.43,60.57 54.65,59.79 54.65,58.16 55.69,57.12 55.69,53.45 56.52,52.63 56.52,49.82 56.59,49.74 v2(56.93,49.74)
  BOTTOM w0.076: U0300.BC11 83.4,110.21 v3(83.55,110.21)
  BOTTOM w0.165: CON1701.71 58.13,50.94 v2(56.93,49.74)
M_CHB_DQ26: length 85.6
  TOP w0.165: CON1700.84 63.37,51.95 61.2,49.77 61.2,48.87 60.42,48.09 v2(59.6,48.09)
  IN4 w0.076: v3(84.46,108.27) 84.46,108.17 84.83,107.81 84.83,107.39 84.56,107.12 84.28,107.12 83.95,106.79 83.76,106.79 83.47,106.49 83.47,104.22 83.39,104.15 83.39,101.18 81.86,99.65 81.7,99.65
  IN4 w0.114: 81.7,99.65 80.66,98.6 78.98,98.6 78.41,98.03 78.27,98.03 77.74,97.51 77.74,96.26 60.29,78.81 60.29,67.46 59.77,66.94 59.77,62 59.26,61.5 59.26,58.59 59.77,58.08 59.77,53.31 60.18,52.9 60.18,48.68 v2(59.6,48.09)
  BOTTOM w0.076: U0300.BB8 84.33,108.27 v3(84.46,108.27)
  BOTTOM w0.165: v2(59.6,48.09) 59.16,48.53 59.16,49.61 60.13,50.57 CON1701.79
M_CHB_DQ27: length 84.2
  TOP w0.165: CON1700.71 60.12,45.81 60.43,46.11 60.43,46.55 59.86,47.12 58.62,47.12 57.77,47.97 v2(57.38,47.97)
  IN4 w0.076: v3(83.55,108.27) 83.54,108.27 83.18,107.91 83.18,107.39 82.63,106.84 82.63,104.81 82.38,104.55
  IN4 w0.108: 80.33,101.12 81.15,101.94
  IN4 w0.114: v2(57.38,47.97) 56.8,47.97 56.52,48.24 56.52,48.75 57.38,49.62 57.38,52.73 56.38,53.74 56.38,58.83 56.12,59.09 56.12,68.74 56.88,69.5 56.88,71.62 58.32,73.06 58.32,79.63 75.42,96.73 75.42,97.29 77.22,99.09 77.98,99.09 80.01,101.12 80.33,101.12 ; 81.15,101.94 81.71,101.94 82.38,102.61 82.38,104.55
  BOTTOM w0.076: U0300.BC8 83.42,108.27 v3(83.55,108.27)
  BOTTOM w0.165: CON1701.66 56.88,46.47 56.87,46.47 56.87,47.7 57.14,47.97 v2(57.38,47.97)
M_CHB_DQ28: length 83
  TOP w0.165: CON1700.66 58.87,51.03 58.76,50.91 58.25,50.91 58.12,50.78 58.12,50.22 58.04,50.14 57.57,50.14 57.33,50.38 v2(56.93,50.38)
  IN4 w0.076: v3(83.55,109.57) 83.18,109.2 83.18,108.14 82.94,107.91 82.94,107.39 81.82,106.26 81.82,103.96 80.89,103.03 80.89,101.94 80.26,101.31 79.91,101.31
  IN4 w0.114: 79.91,101.31 77.89,99.29 76.99,99.29 75.08,97.38 75.08,96.87 57.98,79.77 57.98,75.93 56.97,74.92 56.97,74.69 57.08,74.58 57.76,74.58 57.87,74.46 57.87,74.23 57.76,74.12 57.08,74.12 56.97,74.01 56.97,73.78 57.08,73.66 57.86,73.66 57.98,73.55 57.98,73.21 56.53,71.76 56.53,69.64 55.78,68.88 55.78,60.43 54.99,59.64 54.99,58.31 56.03,57.27 56.03,53.6 56.93,52.7 v2(56.93,50.38)
  BOTTOM w0.076: v3(83.55,109.57) 83.42,109.57 U0300.BC10
  BOTTOM w0.165: CON1701.67 57.13,50.57 v2(56.93,50.38)
M_CHB_DQ29: length 83.2
  TOP w0.165: CON1700.83 63.12,46.08 61.97,47.24 v2(60.36,47.24)
  IN4 w0.076: v3(84.46,109.57) 84.83,109.2 84.83,108.11 85,107.94 85,107.16 84.38,106.54
  IN4 w0.114: 84.38,106.54 84.38,101.69 81.04,98.35 79.02,98.35 78.08,97.41 78.08,96.12 60.63,78.67 60.63,67.32 60.11,66.8 60.11,53.45 60.52,53.04 60.52,48.68 61.23,47.98 61.23,47.45 61.02,47.24 v2(60.36,47.24)
  BOTTOM w0.076: v3(84.46,109.57) 84.33,109.57 U0300.BB10
  BOTTOM w0.165: CON1701.80 60.38,47.23 v2(60.36,47.24)
M_CHB_DQ30: length 83.4
  TOP w0.165: v2(57.31,47.33) 57.48,47.51 57.68,47.51 58.01,47.17 58.01,46.83 58.12,46.72 59.17,46.72 59.29,46.6 59.29,46.44 59.12,46.27 CON1700.67
  IN4 w0.076: v3(83.55,107.7) 83.55,107.53 82.8,106.77 82.8,104.64 82.63,104.48
  IN4 w0.114: v2(57.31,47.33) 57.31,46.82 57.51,46.62 57.74,46.62 57.86,46.74 57.86,48.07 57.46,48.47 57.46,49.21 57.86,49.61 57.86,52.74 56.72,53.88 56.72,55.49 57.22,55.99 57.22,71.48 58.66,72.92 58.66,79.49 75.76,96.59 75.76,97.34 77.3,98.88 78.06,98.88 80.1,100.92 80.42,100.92 81.21,101.71 81.87,101.71 82.63,102.47 82.63,104.48
  BOTTOM w0.076: U0300.BC7 83.22,107.42 83.35,107.42 83.55,107.62 v3(83.55,107.7)
  BOTTOM w0.165: v2(57.31,47.33) 57.31,46.32 57.88,45.75 CON1701.70
M_CHB_DQ31: length 85
  TOP w0.165: v2(59.6,48.73) 59.84,48.49 60.23,48.49 60.57,48.83 60.57,49.05 60.31,49.31 60.31,49.61 60.85,50.15 61.02,50.15 62.37,51.51 CON1700.80
  IN4 w0.076: v3(84.46,107.62) 84.46,107.61 83.83,106.97 83.72,106.97 83.3,106.56 83.3,104.39 83.22,104.3 83.22,101.26 82.35,100.39
  IN4 w0.114: v2(59.6,48.73) 59.84,48.97 59.84,52.76 59.42,53.17 59.42,55.99 59.31,56.11 59.1,56.11 58.96,56.24 58.96,56.42 59.1,56.56 59.31,56.56 59.42,56.68 59.42,56.91 59.31,57.02 58.81,57.02 58.71,57.13 58.71,57.36 58.83,57.48 59.31,57.48 59.42,57.59 59.42,57.94 58.92,58.44 58.92,62.92 58.6,63.23 58.6,63.9 59.42,64.73 59.42,67.09 59.94,67.62 59.94,78.95 77.39,96.4 77.39,97.71 77.92,98.24 78.33,98.24 78.9,98.81 80.58,98.81 81.62,99.85 81.81,99.85 82.35,100.39
  BOTTOM w0.159: v3(84.46,107.62) 84.33,107.62 U0300.BB7
  BOTTOM w0.165: CON1701.83 61.13,50.26 v2(59.6,48.73)
M_CHB_DQ32: length 79
  TOP w0.165: CON1700.183 90.12,45.42 89.9,45.65 89.9,45.81 90.1,46.01 90.1,46.34 90.03,46.41 v2(89.73,46.41)
  IN4 w0.076: 102.31,100.56 102.31,106.67 101.71,107.27 101.71,107.85 101.47,108.09 101.47,109.68 v3(100.92,110.22)
  IN4 w0.114: 102.31,100.56 102.31,98.86 106.78,94.38 106.78,82.65 97.19,73.06 97.19,64.18 96.48,63.46 96.48,57.28 94.72,55.53 94.72,54.26 91.91,51.45 91.91,48.6 91.11,47.8 91.11,46.71 90.81,46.41 v2(89.73,46.41)
  BOTTOM w0.076: U0300.AA11 100.79,110.22 v3(100.92,110.22)
  BOTTOM w0.165: v2(89.73,46.41) 88.88,45.56 CON1701.186
M_CHB_DQ33: length 80.7
  TOP w0.165: CON1700.187 91.12,46.19 91.52,46.59 91.52,46.87 91.32,47.08 v2(90.21,47.08)
  IN4 w0.076: 102,100.51 102.14,100.65 102.14,106.6 101.52,107.22 101.52,107.8 101.3,108.02 101.3,109.19 v3(100.92,109.57)
  IN4 w0.114: v2(90.21,47.08) 90.63,47.08 90.77,47.21 90.77,47.48 90.58,47.67 90.58,47.84 91.57,48.82 91.57,51.59 94.37,54.4 94.37,55.67 96.13,57.42 96.13,63.6 96.85,64.32 96.85,71.92 96.4,72.37 96.4,72.75 106.44,82.79 106.44,94.44 102,98.88 102,100.51
  BOTTOM w0.076: v3(100.92,109.57) 100.79,109.57 U0300.AA10
  BOTTOM w0.165: CON1701.182 87.88,45.43 89.52,47.08 v2(90.21,47.08)
M_CHB_DQ34: length 80.8
  TOP w0.165: CON1700.173 87.62,45.56 87.77,45.7 87.77,45.91 87.31,46.36 87.31,46.63 87.39,46.71 87.62,46.71 87.74,46.82 87.74,47.03 87.05,47.72 v2(86.79,47.72)
  IN4 w0.076: v3(100.01,110.22) 99.47,109.68 99.47,109.47 99.46,109.46 99.46,108.36 99.31,108.21 99.31,106.99 99.46,106.84 99.46,104.88 100.17,104.17 100.17,100.25 99.85,99.92
  IN4 w0.114: v2(86.79,47.72) 87.32,47.72 88.27,48.67 88.27,52.54 89.45,53.72 89.45,54.99 92.44,57.98 92.44,62.97 92.32,63.09 92.32,65.28 92.49,65.45 92.49,67.52 92.65,67.68 92.65,73.24 97.98,78.57 97.98,79.3 103.44,84.76 103.44,94.51 99.85,98.1 99.85,99.92
  BOTTOM w0.076: U0300.AC11 99.88,110.22 v3(100.01,110.22)
  BOTTOM w0.165: CON1701.170 84.88,45.81 v2(86.79,47.72)
M_CHB_DQ35: length 79.2
  TOP w0.165: CON1700.169 86.62,45.42 86.48,45.56 86.48,45.67 86.65,45.83 86.65,45.98 86.48,46.14 86.48,46.32 86.58,46.42 v2(86.88,46.42)
  IN4 w0.076: v3(100.01,109.57) 99.63,109.19 99.63,108.24 99.48,108.08 99.48,107.4 100.34,106.54 100.34,100.13 100.05,99.85
  IN4 w0.114: 100.05,99.85 100.05,98.18 103.78,94.45 103.78,84.62 98.33,79.16 98.33,78.43 92.99,73.09 92.99,67.53 92.83,67.37 92.83,65.3 92.66,65.14 92.66,63.23 92.79,63.11 92.79,57.84 89.79,54.85 89.79,53.58 88.61,52.4 88.61,47.13 88.5,47.02 88.02,47.02 87.67,47.37 87.49,47.37 87.33,47.21 87.33,47 87.49,46.84 87.49,46.54 87.37,46.42 v2(86.88,46.42)
  BOTTOM w0.076: U0300.AC10 99.88,109.57 v3(100.01,109.57)
  BOTTOM w0.165: v2(86.88,46.42) 86.87,46.42 85.88,45.42 CON1701.174
M_CHB_DQ36: length 80.1
  TOP w0.165: v2(90.81,50.68) 89.85,50.68 89.52,51.01 89.52,51.4 89.87,51.76 CON1700.182
  IN4 w0.076: 101.48,100.61 101.81,100.94 101.81,106.46 101.06,107.21 101.06,107.48 v3(100.92,107.62)
  IN4 w0.114: 101.48,100.61 101.48,98.51 105.75,94.23 105.75,83.07 105.51,82.83 105.35,82.83 105.15,83.03 104.98,83.03 104.82,82.87 104.82,82.71 105.02,82.51 105.02,82.35 104.86,82.18 104.7,82.18 104.5,82.39 104.34,82.39 104.18,82.22 104.18,82.06 104.38,81.86 104.38,81.7 104.22,81.54 104.05,81.54 103.85,81.74 103.69,81.74 103.53,81.58 103.53,81.42 103.73,81.21 103.73,81.05 103.57,80.89 103.41,80.89 103.21,81.09 103.04,81.09 102.88,80.93 102.88,80.77 103.08,80.57 103.08,80.4 102.92,80.24 102.76,80.24 102.56,80.45 102.4,80.45 102.24,80.28 102.24,80.12 102.44,79.92 102.44,79.76 102.28,79.6 102.11,79.6 101.91,79.8 101.75,79.8 101.59,79.64 101.59,79.48 101.79,79.27 101.79,79.11 101.63,78.95 101.47,78.95 101.27,79.15 101.1,79.15 100.94,78.99 100.94,78.83 101.14,78.63 101.14,78.46 101.01,78.33 100.5,78.33 100.29,78.12 100.29,77.61 94.96,72.28 94.96,71.08 95.45,70.59 95.45,70.02 94.98,69.55 94.98,68.08 95.69,67.36 96.02,67.36 96.16,67.22 96.16,66.78 96.06,66.68 95.76,66.68 95.45,66.36 95.45,57.71 93.69,55.95 93.69,54.68 90.88,51.88 90.88,50.75 v2(90.81,50.68)
  BOTTOM w0.076: U0300.AA7 100.79,107.62 v3(100.92,107.62)
  BOTTOM w0.165: CON1701.187 89.13,51.4 89.85,50.68 v2(90.81,50.68)
M_CHB_DQ37: length 81.8
  TOP w0.165: v2(90.96,50.05) 91.08,50.16 91.4,50.16 91.72,49.84 92.01,49.84 92.2,50.03 92.2,50.56 91.48,51.28 91.05,51.28 90.87,51.45 CON1700.186
  IN4 w0.076: 101.68,100.28 101.68,100.58 101.98,100.87 101.98,106.53 101.34,107.16 101.34,107.75 100.92,108.17 v3(100.92,108.27)
  IN4 w0.114: 101.68,100.28 101.68,98.78 106.1,94.36 106.1,82.93 95.79,72.62 95.79,72.14 95.9,72.03 96.13,72.03 96.25,71.91 96.25,71.68 96.13,71.57 95.9,71.57 95.79,71.46 95.79,69.2 95.94,69.04 96.38,69.04 96.51,68.92 96.51,68.67 96.37,68.54 95.94,68.54 95.79,68.38 95.79,67.82 95.9,67.71 96.32,67.71 96.51,67.52 96.51,66.52 96.32,66.33 95.9,66.33 95.79,66.22 95.79,65.99 95.9,65.88 96.32,65.88 96.44,65.76 96.44,65.53 96.32,65.42 95.9,65.42 95.79,65.31 95.79,65.08 95.9,64.96 96.32,64.96 96.44,64.85 96.44,64.39 95.79,63.74 95.79,57.57 94.03,55.81 94.03,54.54 91.22,51.74 91.22,50.31 v2(90.96,50.05)
  BOTTOM w0.076: U0300.AA8 100.79,108.27 v3(100.92,108.27)
  BOTTOM w0.165: CON1701.183 88.13,51.67 89.5,50.29 90.57,50.29 90.81,50.05 v2(90.96,50.05)
M_CHB_DQ38: length 84.2
  TOP w0.165: v2(89.06,47.96) 87.13,49.89 87.13,50.1 87.31,50.27 87.84,50.27 88.03,50.46 88.03,50.74 87.9,50.87 87.04,50.87 86.65,51.26 86.65,51.52 86.87,51.75 CON1700.170
  IN4 w0.076: v3(100.01,108.27) 99.64,107.9 99.64,107.47 100.5,106.61 100.5,99.99 100.25,99.75 100.25,99.63
  IN4 w0.114: 100.25,99.63 100.25,98.27 104.13,94.39 104.13,84.48 98.67,79.02 98.67,78.29 93.33,72.95 93.33,67.39 93.17,67.23 93.17,63.71 93.13,63.67 93.13,57.7 90.13,54.7 90.13,53.44 88.95,52.25 88.95,48.07 v2(89.06,47.96)
  BOTTOM w0.159: U0300.AC8 99.68,107.95 v3(100.01,108.27)
  BOTTOM w0.165: v2(89.06,47.96) 88.59,47.96 86.65,49.9 86.65,50.25 85.76,51.14 85.2,51.14 84.63,51.71 CON1701.169
M_CHB_DQ39: length 83
  TOP w0.165: CON1700.174 87.87,51.98 88.42,51.43 88.42,50.63 88.63,50.43 88.98,50.43 89.16,50.25 89.16,49.92 89,49.77 88.32,49.77 88.17,49.61 88.17,49.43 89.08,48.52 v2(89.39,48.52)
  IN4 w0.076: v3(100.01,107.62) 100.01,107.42 100.67,106.77 100.67,99.83 100.5,99.66
  IN4 w0.114: v2(89.39,48.52) 89.53,48.38 89.53,47.83 89.66,47.71 89.89,47.71 89.99,47.81 89.99,48.53 89.29,49.23 89.29,52.11 90.48,53.29 90.48,54.56 93.47,57.56 93.47,63.41 93.52,63.46 93.52,67.08 93.68,67.24 93.68,72.81 99.01,78.15 99.01,78.87 104.47,84.33 104.47,94.34 100.46,98.35 100.46,99.62 100.5,99.66
  BOTTOM w0.076: U0300.AC7 99.88,107.62 v3(100.01,107.62)
  BOTTOM w0.165: v2(89.39,48.52) 89.36,48.5 88.78,48.5 85.63,51.65 CON1701.173
M_CHB_DQ40: length 82.1
  TOP w0.165: CON1700.195 93.12,46.31 93.66,46.84 93.66,47.35 v2(92.56,48.44)
  IN4 w0.076: v3(102.76,108.29) 102.75,108.28 102.75,108.14 102.38,107.77 102.38,107.32 102.8,106.9 102.8,101.34 103.13,101.02
  IN4 w0.114: 103.13,101.02 103.13,98.96 108.22,93.87 108.22,81.79 99.99,73.56 99.99,70.93 99.67,70.62 99.67,66.96 98.63,65.92 98.63,63.58 98.06,63.01 98.06,56.84 96.76,55.54 96.76,54.27 93.51,51.02 93.51,47.58 93.43,47.5 93.11,47.5 92.98,47.63 92.98,48.03 v2(92.56,48.44)
  BOTTOM w0.076: U0300.W8 102.63,108.29 v3(102.76,108.29)
  BOTTOM w0.165: CON1701.190 89.88,45.91 90.83,46.87 90.83,48.01 91.55,48.72 92.28,48.72 v2(92.56,48.44)
M_CHB_DQ41: length 80.9
  TOP w0.165: v2(92.56,47.78) 92.56,46.46 92.12,46.02 CON1700.191
  IN4 w0.076: v3(102.75,107.62) 102.75,107.23 102.97,107.02 102.97,101.45 103.4,101.03 103.4,100.81
  IN4 w0.114: 103.4,100.81 103.4,98.98 108.58,93.79 108.58,81.67 100.33,73.42 100.33,70.79 100.01,70.47 100.01,66.82 98.97,65.78 98.97,63.44 98.4,62.87 98.4,56.69 97.1,55.4 97.1,54.13 93.85,50.88 93.85,47.13 93.06,46.34 92.46,46.34 92.13,46.67 92.13,47.35 v2(92.56,47.78)
  BOTTOM w0.076: v3(102.75,107.62) 102.62,107.62 U0300.W7
  BOTTOM w0.165: v2(92.56,47.78) 91.59,47.78 91.27,47.46 91.27,46.49 91.02,46.24 91.02,45.68 90.88,45.53 CON1701.194
M_CHB_DQ42: length 81.8
  TOP w0.165: v2(94.55,47.31) 95.07,47.31 96.12,46.25 CON1700.207
  IN4 w0.076: 105.35,100.3 105.25,100.4 105.25,102.78 104.51,103.52 104.51,106.12 104.5,106.13 104.5,106.97 104.4,107.07 104.4,108.04 104.05,108.4 104.05,109.19 v3(103.67,109.57)
  IN4 w0.114: v2(94.55,47.31) 95.16,47.31 95.76,47.91 95.76,48.52 96.81,49.56 96.81,50.93 99.58,53.71 99.58,55.09 101.4,56.9 101.4,63.76 103.12,65.49 103.12,67.52 104.04,68.44 104.04,70.69 104.33,70.98 104.33,73.89 104.76,74.32 104.76,75.07 110.55,80.86 110.55,94.05 105.35,99.26 105.35,100.3
  BOTTOM w0.076: U0300.V10 103.53,109.57 v3(103.67,109.57)
  BOTTOM w0.165: CON1701.204 93.38,45.42 93.12,45.67 93.12,46.4 93.87,47.15 93.87,47.59 94.09,47.81 94.88,47.81 95.04,47.64 95.04,47.47 94.88,47.31 v2(94.55,47.31)
M_CHB_DQ43: length 80.1
  TOP w0.165: v2(94.55,46.67) 95.12,46.09 CON1700.203
  IN4 w0.076: 105.67,100.25 105.41,100.5 105.41,102.85 105.25,103.02 105.25,106.46 104.56,107.14 104.56,108.24 104.21,108.59 104.21,109.68 v3(103.67,110.22)
  IN4 w0.114: v2(94.55,46.67) 95.11,46.67 96.12,47.68 96.12,48.24 97.15,49.27 97.15,50.79 99.93,53.57 99.93,54.95 102.27,57.29 102.27,64.15 103.46,65.35 103.46,66.69 104.38,67.61 104.38,70.55 104.83,71 104.83,73.21 105.34,73.72 105.34,75.16 110.9,80.71 110.9,94.2 105.67,99.43 105.67,100.25
  BOTTOM w0.076: U0300.V11 103.53,110.22 v3(103.67,110.22)
  BOTTOM w0.165: CON1701.208 94.38,45.42 94.13,45.67 93.74,45.67 93.55,45.85 93.55,46.28 94.16,46.88 94.34,46.88 v2(94.55,46.67)
M_CHB_DQ44: length 81.1
  TOP w0.165: v2(93.1,49.65) 93.55,50.11 93.55,50.48 92.87,51.16 CON1700.194
  IN4 w0.076: v3(102.75,110.22) 102.22,109.69 102.22,108.08 102.05,107.91 102.05,107.15 102.47,106.74 102.47,100.84 102.63,100.69 102.63,100.54
  IN4 w0.114: 102.63,100.54 102.63,98.89 107.53,93.98 107.53,82.34 98.11,72.91 98.11,68.63 98.41,68.33 98.73,68.33 98.98,68.08 98.98,67.25 97.94,66.2 97.94,63.86 97.37,63.3 97.37,57.12 96.08,55.82 96.08,54.56 92.66,51.14 92.66,48.96 92.73,48.89 92.96,48.89 93.1,49.03 v2(93.1,49.65)
  BOTTOM w0.076: v3(102.75,110.22) 102.62,110.22 U0300.W11
  BOTTOM w0.165: CON1701.191 90.13,51.82 90.33,51.62 90.65,51.62 92.61,49.65 v2(93.1,49.65)
M_CHB_DQ45: length 80.8
  TOP w0.165: CON1700.190 91.87,51.49 v2(93.07,50.29)
  IN4 w0.076: v3(102.79,109.61) 102.38,109.2 102.38,108.01 102.22,107.84 102.22,107.22 102.64,106.8 102.64,100.98 102.74,100.88
  IN4 w0.114: 102.74,100.88 102.86,100.76 102.86,98.94 107.87,93.93 107.87,82.19 99.64,73.96 99.64,73.28 99.53,73.16 99.17,73.16 99.05,73.05 99.05,72.82 99.16,72.71 99.53,72.71 99.64,72.6 99.64,72.37 99.53,72.25 98.74,72.25 98.61,72.12 98.61,71.89 98.7,71.8 99.53,71.8 99.64,71.68 99.64,71.08 99.09,70.52 99.09,70.17 98.97,70.06 98.56,70.06 98.45,69.94 98.45,69.72 98.56,69.6 98.97,69.6 99.09,69.49 99.09,69.26 98.97,69.14 98.67,69.14 98.55,69.03 98.55,68.8 98.67,68.69 99.04,68.69 99.33,68.4 99.33,67.1 98.28,66.06 98.28,63.72 97.72,63.16 97.72,56.98 96.42,55.68 96.42,54.41 93.07,51.07 v2(93.07,50.29)
  BOTTOM w0.076: U0300.W10 102.66,109.61 v3(102.79,109.61)
  BOTTOM w0.165: v2(93.07,50.29) 92.53,50.29 92.23,50.59 92.23,50.86 92.41,51.04 92.41,51.2 92.25,51.37 92.03,51.37 91.83,51.18 91.65,51.18 91.13,51.7 CON1701.195
M_CHB_DQ46: length 80.7
  TOP w0.165: v2(95.64,50.02) 95.98,50.36 95.98,51.17 95.37,51.77 CON1700.204
  IN4 w0.076: v3(103.69,107.62) 103.52,107.45 103.52,103.56 104.06,103.03 104.54,103.03 104.89,102.67 104.89,101.25
  IN4 w0.114: v2(95.64,50.02) 96,50.02 96.12,50.14 96.12,51.22 98.9,54 98.9,55.37 100.71,57.19 100.71,63.08 100.6,63.2 100.37,63.2 100.25,63.31 100.25,63.54 100.37,63.65 100.6,63.65 100.71,63.77 100.71,64 100.6,64.11 100.37,64.11 100.25,64.23 100.25,64.45 100.37,64.57 100.6,64.57 100.71,64.68 100.71,65.33 101.01,65.63 101.31,65.63 102.43,66.74 102.43,68.09 102.31,68.2 101.73,68.2 101.61,68.32 101.61,68.55 101.73,68.66 102.31,68.66 102.43,68.78 102.43,69 102.31,69.12 101.73,69.12 101.61,69.23 101.61,69.46 101.73,69.58 102.31,69.58 102.43,69.69 102.43,70.05 103.24,70.86 103.24,71.45 103.13,71.56 102.19,71.56 102.06,71.69 102.06,71.99 103.16,73.09 103.16,73.3 103.05,73.41 102.82,73.41 102.71,73.53 102.71,73.98 109.87,81.14 109.87,94.04 104.81,99.1 104.81,101.16 104.89,101.25
  BOTTOM w0.076: U0300.V7 103.53,107.62 v3(103.69,107.62)
  BOTTOM w0.165: CON1701.207 94.13,51.53 94.84,50.81 94.84,50.2 95.23,49.82 95.43,49.82 v2(95.64,50.02)
M_CHB_DQ47: length 81.5
  TOP w0.165: CON1700.208 96.37,49.72 96.02,49.36 v2(95.64,49.36)
  IN4 w0.076: v3(103.68,108.27) 104.23,107.72 104.23,106.95 104.34,106.85 104.34,106.06 104.35,106.05 104.35,103.45 105.08,102.72 105.08,99.68
  IN4 w0.114: 105.08,99.68 105.08,99.18 110.21,94.05 110.21,81 104.42,75.21 104.42,74.46 103.99,74.03 103.99,71.13 102.77,69.9 102.77,69.55 102.88,69.44 103.58,69.44 103.7,69.32 103.7,69.1 103.58,68.98 102.88,68.98 102.77,68.87 102.77,66.6 102.45,66.28 102.45,66.12 102.78,65.79 102.78,65.63 102.62,65.47 102.46,65.47 102.13,65.8 101.97,65.8 101.8,65.63 101.8,65.47 102.13,65.14 102.13,64.98 101.97,64.82 101.81,64.82 101.48,65.15 101.32,65.15 101.05,64.88 101.05,57.05 99.24,55.23 99.24,53.85 96.46,51.08 96.46,49.82 96,49.36 v2(95.64,49.36)
  BOTTOM w0.076: v3(103.68,108.27) 103.53,108.27 U0300.V8
  BOTTOM w0.165: v2(95.64,49.36) 95.13,49.36 94.38,50.11 93.74,50.11 93.58,50.27 93.58,50.74 93,51.33 93,51.65 93.13,51.77 CON1701.203
M_CHB_DQ48: length 85.1
  TOP w0.165: CON1700.212 97.37,51.74 97.18,51.54 97.18,49.76 97.3,49.64 97.59,49.64 v2(97.9,49.95)
  IN4 w0.076: 106.02,100.09 106.02,100.23 105.58,100.67 105.58,102.92 105.41,103.09 105.41,106.56 104.8,107.18 104.8,108.02 104.95,108.17 104.95,109.34 105.11,109.5 105.11,109.84 v3(105.5,110.22)
  IN4 w0.114: 106.02,100.09 106.02,99.68 111.65,94.05 111.65,80.4 106.19,74.95 106.19,71.3 105.13,70.24 105.13,66.6 104.45,65.92 104.45,65.11 105.16,64.4 105.16,64.24 104.99,64.08 104.83,64.08 104.12,64.78 103.96,64.78 103.8,64.62 103.8,64.48 104.1,64.19 104.1,64.02 103.94,63.86 103.77,63.86 103.5,64.14 103.32,64.14 103.02,63.84 103.02,63.34 103.14,63.23 103.71,63.23 103.84,63.09 103.84,62.87 103.74,62.77 103.14,62.77 103.02,62.65 103.02,62.43 103.14,62.31 103.77,62.31 103.89,62.19 103.89,61.96 103.78,61.85 103.14,61.85 103.02,61.74 103.02,56.98 102.58,56.54 102.58,56.28 102.14,55.84 101.87,55.84 101.41,55.37 101.41,55.03 101.53,54.92 102.16,54.92 102.28,54.79 102.28,54.57 101.37,53.66 101.07,53.66 99.48,52.07 99.48,51.37 98.57,50.45 98.18,50.45 97.9,50.17 v2(97.9,49.95)
  BOTTOM w0.076: v3(105.5,110.22) 105.36,110.22 U0300.R11
  BOTTOM w0.165: CON1701.215 96.13,51.54 97.71,49.95 v2(97.9,49.95)
M_CHB_DQ49: length 85.3
  TOP w0.165: CON1700.225 100.62,45.62 100.48,45.76 100.48,47.32 v2(101.12,47.96)
  IN4 w0.076: 110.79,102.59 109.89,103.49 108.8,103.49 108.24,104.04 108.24,106.36 107.18,107.43 107.18,108.43 106.96,108.66 106.96,109.68 106.82,109.81 v3(106.41,110.22)
  IN4 w0.114: v2(101.12,47.96) 103.03,49.87 103.03,50.74 106.29,53.99 106.29,54.67 107.44,55.83 107.44,61.08 110.03,63.67 110.03,73.17 114.51,77.65 114.56,77.7 115.19,78.33 115.19,88.72 118.01,91.54 118.01,94.39 118.5,94.87 118.5,97.9 116.44,99.96 113.41,99.96 110.79,102.59
  BOTTOM w0.076: v3(106.41,110.22) 106.28,110.22 U0300.P11
  BOTTOM w0.165: CON1701.228 99.38,46.35 100.98,47.96 v2(101.12,47.96)
M_CHB_DQ50: length 85
  TOP w0.165: v2(101.68,50.4) 101.05,50.4 100.37,51.07 CON1700.224
  IN4 w0.076: v3(106.41,107.62) 106.41,107.5 107.75,106.16 107.75,101.98 108.41,101.32
  IN4 w0.114: v2(101.68,50.4) 101.81,50.4 102,50.6 102,51.16 105.26,54.42 105.26,55.86 106.41,57.02 106.41,61.51 109,64.1 109,67.36 108.4,67.96 108.4,68.18 108.52,68.3 108.89,68.3 109,68.41 109,68.64 108.89,68.76 108.52,68.76 108.4,68.87 108.4,69.1 108.52,69.21 108.89,69.21 109,69.33 109,69.56 108.89,69.67 108.52,69.67 108.4,69.78 108.4,70.01 108.52,70.13 108.89,70.13 109,70.24 109,70.47 108.89,70.59 108.52,70.59 108.4,70.7 108.4,70.93 108.52,71.04 108.89,71.04 109,71.16 109,71.39 108.89,71.5 108.52,71.5 108.4,71.61 108.4,71.84 108.52,71.96 108.89,71.96 109,72.07 109,72.3 108.4,72.9 108.4,73.21 113.67,78.48 114.16,78.97 114.16,91.5 114.68,92.02 116.28,92.02 116.99,92.73 116.99,94.82 117.61,95.45 117.61,97.32 116.14,98.79 110.94,98.79 108.41,101.32
  BOTTOM w0.076: v3(106.41,107.62) 106.28,107.62 U0300.P7
  BOTTOM w0.165: CON1701.229 99.63,51.8 101.02,50.4 v2(101.68,50.4)
M_CHB_DQ51: length 84.9
  TOP w0.165: CON1700.215 98.12,46.08 97.64,46.57 v2(96.43,46.57)
  IN4 w0.076: v3(105.5,108.27) 105.5,108.16 105.13,107.8 105.13,107.43 105.75,106.82 105.75,103.22 105.92,103.05 105.92,100.84 106.58,100.17
  IN4 w0.114: v2(96.43,46.57) 96.73,46.87 97.15,46.87 97.58,46.45 97.58,45.99 97.14,45.56 97.14,45.08 97.36,44.86 99.04,44.86 99.41,45.23 99.41,47.12 98.7,47.83 98.7,49.61 99.9,50.82 100.17,51.08 100.17,51.78 101.36,52.97 101.65,52.97 103.27,54.58 103.27,56.16 103.73,56.63 103.73,60.84 106.02,63.13 106.02,67.54 106.88,68.4 106.88,74.67 112.33,80.12 112.33,94.19 106.58,99.94 106.58,100.17
  BOTTOM w0.076: U0300.R8 105.36,108.27 v3(105.5,108.27)
  BOTTOM w0.165: CON1701.212 95.38,45.56 95.12,45.81 95.12,46.2 95.49,46.57 v2(96.43,46.57)
M_CHB_DQ52: length 86.1
  TOP w0.165: v2(97.9,49.31) 98.43,49.31 98.91,49.78 98.91,50.18 98.37,50.71 CON1700.216
  IN4 w0.076: 106.3,99.88 106.3,100.22 105.76,100.76 105.76,102.98 105.58,103.16 105.58,106.68 104.96,107.3 104.96,107.91 105.13,108.08 105.13,109.2 v3(105.5,109.57)
  IN4 w0.114: 106.3,99.88 106.3,99.74 111.99,94.05 111.99,80.26 106.54,74.81 106.54,68.54 105.68,67.69 105.68,64.28 104.9,63.5 104.9,62.49 103.39,60.98 103.39,56.77 102.92,56.3 102.92,54.73 101.51,53.31 101.22,53.31 99.83,51.93 99.83,51.22 98.36,49.75 98.36,47.68 98.88,47.16 98.88,46.57 98.65,46.34 98.24,46.34 97.9,46.68 97.9,47.35 97.67,47.58 97.67,48.59 97.9,48.82 v2(97.9,49.31)
  BOTTOM w0.076: v3(105.5,109.57) 105.36,109.57 U0300.R10
  BOTTOM w0.165: v2(97.9,49.31) 97.53,49.31 95.13,51.71 CON1701.211
M_CHB_DQ53: length 86.7
  TOP w0.165: CON1700.229 101.62,45.8 101.49,45.93 101.49,46.98 102.22,47.71 102.22,48.29 101.86,48.65 v2(101.17,48.65)
  IN4 w0.076: v3(106.41,109.57) 106.78,109.2 106.78,108.57 106.99,108.35 106.99,107.38 108.08,106.29 108.08,103.27 108.32,103.02
  IN4 w0.114: v2(101.17,48.65) 102.69,50.16 102.69,50.88 105.94,54.13 105.94,55.58 107.1,56.73 107.1,61.22 109.69,63.81 109.69,73.39 114.85,78.55 114.85,88.86 117.67,91.69 117.67,94.53 118.22,95.08 118.22,97.57 116.19,99.6 113.49,99.6 110.66,102.43 108.92,102.43 108.32,103.02
  BOTTOM w0.076: v3(106.41,109.57) 106.28,109.57 U0300.P10
  BOTTOM w0.165: CON1701.224 98.38,46.17 100.85,48.65 v2(101.17,48.65)
M_CHB_DQ54: length 83.6
  TOP w0.165: v2(96.71,45.93) 96.93,46.16 97.29,46.16 97.41,46.04 97.41,45.71 97.12,45.42 CON1700.211
  IN4 w0.076: 106.6,103.34 106.3,103.34 105.91,103.73 105.91,106.98 105.5,107.4 v3(105.5,107.62)
  IN4 w0.114: v2(96.71,45.93) 95.74,44.97 95.74,44.63 95.86,44.52 99.18,44.52 100.52,45.86 100.52,46.49 99.04,47.97 99.04,49.47 100.51,50.94 100.51,51.64 101.5,52.63 101.8,52.63 103.61,54.44 103.61,56.02 104.08,56.49 104.08,60.7 106.36,62.98 106.36,67.4 107.22,68.26 107.22,73.84 109.2,75.82 109.2,76.31 112.67,79.78 112.67,94.34 108.29,98.72 108.29,100.36 106.84,101.81 106.84,103.11 106.6,103.34
  BOTTOM w0.076: v3(105.5,107.62) 105.36,107.62 U0300.R7
  BOTTOM w0.165: v2(96.71,45.93) 96.59,46.05 96.27,46.05 96.09,45.88 96.09,45.7 96.38,45.42 CON1701.216
M_CHB_DQ55: length 86.3
  TOP w0.165: CON1700.228 101.37,51.42 102.61,50.18 102.61,49.46 102.44,49.28 102.19,49.28 v2(101.68,49.79)
  IN4 w0.076: 108.23,102.83 107.91,103.14 107.91,106.23 106.8,107.34 106.8,107.88 v3(106.41,108.27)
  IN4 w0.114: v2(101.68,49.79) 101.83,49.79 102.35,50.31 102.35,51.02 105.6,54.28 105.6,55.72 106.76,56.87 106.76,61.36 109.35,63.96 109.35,73.58 114.5,78.74 114.5,89.41 114.62,89.53 115.03,89.53 115.14,89.64 115.14,89.87 115.03,89.99 114.62,89.99 114.5,90.1 114.5,90.33 114.62,90.44 114.87,90.44 114.98,90.55 114.98,90.78 114.86,90.9 114.62,90.9 114.5,91.01 114.5,91.36 114.82,91.67 116.9,91.67 117.33,92.11 117.33,94.67 117.94,95.28 117.94,97.43 116.24,99.13 113.37,99.13 110.28,102.22 108.84,102.22 108.23,102.83
  BOTTOM w0.076: v3(106.41,108.27) 106.28,108.27 U0300.P8
  BOTTOM w0.165: CON1701.225 98.63,51.32 99.3,50.65 100.14,50.65 101,49.79 v2(101.68,49.79)
M_CHB_DQ56: length 86.2
  TOP w0.165: CON1700.245 105.62,45.68 106.15,46.21 106.15,46.41 106.56,46.82 106.56,47.1 106.41,47.25 v2(106.15,47.25)
  IN4 w0.076: v3(109.12,110.21) 109.59,109.74 109.59,109.34 109.66,109.27 109.66,108.61 111.62,106.64 111.62,106.35
  IN4 w0.114: 111.62,106.35 114.92,103.05 117.46,103.05 122.23,98.29 122.23,96.67 123.2,95.7 123.2,85.1 120.64,82.54 120.64,77.99 114.64,72 114.64,57.98 112.55,55.89 112.55,52.75 111.59,51.79 111.59,50.47 110.69,49.58 110.04,49.58 109.38,48.92 109.38,48.47 108.16,47.25 v2(106.15,47.25)
  BOTTOM w0.076: U0300.L11 109,110.21 v3(109.12,110.21)
  BOTTOM w0.165: v2(106.15,47.25) 105.75,47.25 104.88,46.37 CON1701.250
M_CHB_DQ57: length 85.8
  TOP w0.165: CON1700.232 102.37,51.55 103.42,50.5 v2(103.71,50.5)
  IN4 w0.076: 109.05,103.74 108.77,103.74 108.41,104.11 108.41,106.43 107.47,107.37 107.47,108.48 107.7,108.71 107.7,109.35 107.85,109.5 107.85,109.84 v3(108.24,110.22)
  IN4 w0.114: 109.05,103.74 109.92,103.74 113.34,100.32 116.37,100.32 118.76,97.92 118.76,91.37 118.89,91.24 119.69,91.24 119.86,91.06 119.86,89.99 119.71,89.84 118.28,89.84 117.98,89.54 117.82,89.54 117.53,89.83 117.36,89.83 117.2,89.67 117.2,89.51 117.5,89.22 117.5,89.05 117.33,88.89 117.17,88.89 116.88,89.19 116.72,89.19 116.56,89.03 116.56,88.86 116.85,88.57 116.85,88.41 115.94,87.5 115.94,78.02 110.78,72.86 110.78,63.36 109.51,62.09 109.51,59.88 108.22,58.59 108.22,55.36 107.88,55.02 107.88,54.72 108.22,54.38 108.22,53.69 108.02,53.49 106.96,53.49 103.97,50.5 v2(103.71,50.5)
  BOTTOM w0.076: U0300.M11 108.11,110.22 v3(108.24,110.22)
  BOTTOM w0.165: CON1701.237 101.63,51.98 103.1,50.5 v2(103.71,50.5)
M_CHB_DQ58: length 86.5
  TOP w0.165: CON1700.246 105.87,51.54 105.59,51.26 105.59,50.93 105.77,50.76 106.08,50.76 106.2,50.63 v2(106.2,49.49)
  IN4 w0.076: v3(109.11,107.67) 109.1,107.66 109.1,107.6 110.25,106.45 110.25,105.53 110.51,105.28
  IN4 w0.114: 110.51,105.28 113.49,102.29 116.76,102.29 121.2,97.86 121.2,96.24 122.17,95.27 122.17,85.53 120.85,84.21 118.71,84.21 118.26,83.76 118.26,83.41 118.37,83.3 119.1,83.3 119.21,83.18 119.21,82.96 119.1,82.84 118.37,82.84 118.26,82.73 118.26,82.5 118.37,82.38 119.1,82.38 119.21,82.27 119.21,82.04 119.1,81.93 118.37,81.93 118.26,81.81 118.26,77.07 113.61,72.42 113.61,58.41 111.52,56.31 111.52,53.54 109.79,51.8 109.79,50.84 109.19,50.24 107.76,50.24 107,49.49 v2(106.2,49.49)
  BOTTOM w0.076: U0300.L7 108.99,107.67 v3(109.11,107.67)
  BOTTOM w0.165: v2(106.2,49.49) 104.63,51.06 CON1701.249
M_CHB_DQ59: length 88.7
  TOP w0.165: v2(103.77,49.18) 104.27,49.18 104.37,49.09 104.37,48.79 103.94,48.37 103.94,48.01 104.37,47.59 104.37,47.28 103.62,46.53 CON1700.237
  IN4 w0.076: 109.48,104.76 109.35,104.88 109.35,106.4 108.99,106.76 108.55,106.76 107.8,107.51 107.8,107.87 108.2,108.27 v3(108.18,108.27)
  IN4 w0.114: 109.48,104.76 113.21,101.03 116.23,101.03 119.45,97.81 119.45,95.13 119.99,94.59 119.99,94.36 119.45,93.82 119.45,93.28 119.74,92.99 120.39,92.99 120.55,92.83 120.55,89.51 120.19,89.15 118.57,89.15 116.63,87.22 116.63,77.74 111.57,72.68 111.57,60.14 109.52,58.08 109.52,53.74 108.59,52.81 107.24,52.81 103.77,49.33 v2(103.77,49.18)
  BOTTOM w0.076: U0300.M8 108.11,108.27 v3(108.18,108.27)
  BOTTOM w0.165: v2(103.77,49.18) 103.27,49.18 102.73,48.64 102.73,48.57 100.49,46.34 100.49,45.77 100.38,45.65 CON1701.232
M_CHB_DQ60: length 87.6
  TOP w0.165: CON1700.249 106.62,46.14 106.8,46.32 107.17,46.32 107.6,46.75 107.6,47.15 106.91,47.84 v2(106.46,47.84)
  IN4 w0.076: 111.37,106.44 111.37,106.66 109.49,108.54 109.49,109.2 v3(109.13,109.57)
  IN4 w0.114: 111.37,106.44 111.37,105.56 114.15,102.78 117.25,102.78 121.88,98.14 121.88,96.53 122.86,95.55 122.86,85.25 120.29,82.68 120.29,78.13 114.3,72.14 114.3,58.12 112.21,56.03 112.21,52.89 111.25,51.93 111.25,50.61 110.55,49.92 109.89,49.92 109.53,49.56 108.04,49.56 106.46,47.97 v2(106.46,47.84)
  BOTTOM w0.076: U0300.L10 109.02,109.57 v3(109.13,109.57)
  BOTTOM w0.165: v2(106.46,47.84) 105.78,47.84 105.17,47.23 104.32,47.23 103.88,46.78 CON1701.246
M_CHB_DQ61: length 87.2
  TOP w0.165: CON1700.236 103.37,51.46 104.43,50.41 104.43,49.69 104.31,49.58 103.95,49.58 v2(103.69,49.84)
  IN4 w0.076: v3(108.24,109.57) 107.88,109.21 107.88,108.65 107.63,108.41 107.63,107.44 108.57,106.5 108.57,104.18 108.79,103.97 109.14,103.97 109.14,103.97
  IN4 w0.114: v2(103.69,49.84) 103.79,49.84 107.1,53.15 108.17,53.15 108.56,53.54 108.56,57.61 111.23,60.28 111.23,72.83 116.29,77.88 116.29,87.36 118.42,89.5 120.05,89.5 120.2,89.65 120.2,91.47 120.09,91.58 119.3,91.58 119.18,91.7 119.18,91.93 119.3,92.04 119.59,92.04 119.7,92.15 119.7,92.38 119.58,92.5 119.22,92.5 119.11,92.61 119.11,97.86 116.31,100.66 113.29,100.66 109.98,103.97 109.14,103.97
  BOTTOM w0.076: v3(108.24,109.57) 108.11,109.57 U0300.M10
  BOTTOM w0.165: v2(103.69,49.84) 103.06,49.84 101.16,51.74 100.86,51.74 100.63,51.98 CON1701.233
M_CHB_DQ62: length 87.4
  TOP w0.165: CON1700.233 102.62,46.53 103.55,47.46 103.55,48.46 v2(103.36,48.65)
  IN4 w0.076: 109.63,104.9 109.52,105.01 109.52,106.47 109.06,106.93 108.63,106.93 108.19,107.37 v3(108.19,107.64)
  IN4 w0.114: v2(103.36,48.65) 103.82,48.65 104.35,49.18 104.35,49.43 107.39,52.46 108.73,52.46 109.86,53.6 109.86,57.94 111.92,59.99 111.92,72.54 116.97,77.6 116.97,87.08 118.71,88.81 120.33,88.81 120.89,89.37 120.89,93.22 120.78,93.33 119.91,93.33 119.79,93.45 119.79,93.67 119.91,93.79 120.78,93.79 120.89,93.9 120.89,94.25 119.79,95.34 119.79,97.82 116.14,101.48 113.04,101.48 109.63,104.9
  BOTTOM w0.076: U0300.M7 108.12,107.64 v3(108.19,107.64)
  BOTTOM w0.165: CON1701.236 101.38,45.64 101.48,45.74 101.48,46.77 v2(103.36,48.65)
M_CHB_DQ63: length 87.5
  TOP w0.165: CON1700.250 106.87,51.48 106.6,51.2 106.6,50.29 106.89,49.99 106.89,49.56 106.2,48.87 v2(106.2,48.72)
  IN4 w0.076: v3(109.13,108.27) 109.52,107.88 109.52,107.42 109.76,107.18 110.13,107.18
  IN4 w0.114: v2(106.2,48.72) 106.73,48.72 107.9,49.9 109.39,49.9 109.75,50.26 110.41,50.26 110.9,50.76 110.9,52.07 111.86,53.04 111.86,56.17 113.96,58.27 113.96,72.28 118.75,77.08 118.75,78.77 118.6,78.92 118.6,80.07 118.82,80.29 119.7,80.29 119.95,80.54 119.95,82.03 119.84,82.14 119.67,82.14 119.56,82.26 119.56,82.49 119.67,82.6 119.84,82.6 119.95,82.72 119.95,83.55 120.27,83.87 121,83.87 122.52,85.39 122.52,95.41 121.54,96.39 121.54,98 117.02,102.52 113.94,102.52 111.07,105.39 111.07,106.45 110.34,107.18 110.13,107.18
  BOTTOM w0.076: U0300.L8 109,108.27 v3(109.13,108.27)
  BOTTOM w0.165: v2(106.2,48.72) 106.11,48.72 103.63,51.21 CON1701.245
M_CHB_DQS0: length 94.6
  TOP w0.146: v2(43.66,48.34) 43.47,48.15 43.47,47.97 43.67,47.78 43.92,47.78 45.52,46.18 45.52,45.52 45.62,45.41 CON1700.13
  IN4 w0.127: v2(43.66,48.34) 43.24,48.75 43.24,49.02 42.17,50.1 42.17,51.26 37.08,56.35 37.08,58.95 36.9,59.13 36.9,62.83 41.34,67.27 41.34,74.73 44.06,77.45 44.06,81.4 65.21,102.55 65.69,102.55 67.14,103.99 67.14,104.49 71.4,108.74 72.59,108.74 73.45,109.61 74.05,109.61 74.84,110.4 75.65,110.4 75.78,110.26 75.78,109.97 75.68,109.87 75.23,109.87 75.15,109.79 75.15,109.65 v3(75.36,109.44)
  BOTTOM w0.076: U0300.BR9 75.36,109.37 v3(75.36,109.44)
  BOTTOM w0.146: CON1701.13 43.63,51.78 43.49,51.64 43.49,50.25 43.14,49.9 43.14,49.43 43.49,49.07 43.49,48.51 v2(43.66,48.34)
M_CHB_DQS0#: length 94.6
  TOP w0.146: CON1700.11 45.12,45.41 45.27,45.55 45.27,46.08 43.82,47.53 43.57,47.53 43.23,47.87 43.23,48.13 v2(43.02,48.34)
  IN4 w0.127: v2(43.02,48.34) 43.02,48.93 41.94,50 41.94,51.16 36.85,56.26 36.85,58.85 36.67,59.03 36.67,62.92 41.12,67.37 41.12,74.82 43.83,77.54 43.83,81.5 65.11,102.78 65.6,102.78 66.91,104.09 66.91,104.58 71.3,108.97 72.5,108.97 73.36,109.84 73.96,109.84 74.75,110.63 75.74,110.63 76.01,110.36 v3(76.01,109.44)
  BOTTOM w0.076: v3(76.01,109.44) 76.01,109.37 U0300.BP9
  BOTTOM w0.146: v2(43.02,48.34) 43.24,48.57 43.24,48.97 42.89,49.33 42.89,50 43.24,50.36 43.24,51.62 43.13,51.74 CON1701.11
M_CHB_DQS1: length 89.6
  TOP w0.146: v2(49.45,48.86) 49.24,49.07 49.24,50.22 49.59,50.57 50.33,50.57 50.87,51.12 CON1700.34
  IN4 w0.076: v3(78.13,108.92) 78.33,108.72 78.33,108.61 78.21,108.49 78.1,108.49 78.05,108.54 77.92,108.54 77.86,108.48 77.86,107.64 77.53,107.31 76.26,107.31 76.05,107.1 76.05,107.06
  IN4 w0.127: v2(49.45,48.86) 49.03,49.28 48.23,49.28 48.07,49.44 48.07,51.81 46.05,53.83 46.05,55.64 44.58,57.11 44.58,59.04 44.98,59.44 44.98,63.94 48.15,67.11 48.15,79.58 70.4,101.83 72.03,101.83 72.41,102.21 73.48,102.21 75.78,104.5 75.78,106.79 76.05,107.06
  BOTTOM w0.076: U0300.BJ9 78.21,108.6 78.13,108.67 v3(78.13,108.92)
  BOTTOM w0.146: v2(49.45,48.86) 49.27,48.68 49.27,47.64 48.75,47.12 48.75,45.74 48.88,45.62 CON1701.34
M_CHB_DQS1#: length 89.7
  TOP w0.146: v2(48.8,48.86) 48.99,49.05 48.99,50.33 49.48,50.82 50.22,50.82 50.63,51.22 50.63,51.45 50.37,51.71 CON1700.32
  IN4 w0.076: 75.89,107.22 75.9,107.24 75.93,107.24 76.18,107.49 77.46,107.49 77.68,107.71 77.68,109.17 v3(78.09,109.57)
  IN4 w0.127: 75.89,107.22 75.55,106.89 75.55,104.6 73.39,102.44 72.32,102.44 71.93,102.05 70.3,102.05 47.92,79.67 47.92,67.21 44.75,64.03 44.75,59.53 44.35,59.14 44.35,57.02 45.82,55.55 45.82,53.73 47.84,51.71 47.84,49.34 48.13,49.05 48.61,49.05 v2(48.8,48.86)
  BOTTOM w0.076: U0300.BL9 78.09,109.5 v3(78.09,109.57)
  BOTTOM w0.146: v2(48.8,48.86) 49.02,48.64 49.02,47.74 48.5,47.22 48.5,45.75 48.38,45.62 CON1701.32
M_CHB_DQS2: length 87.7
  TOP w0.146: v2(53.97,48.74) 53.81,48.58 53.81,48.09 54.09,47.8 54.44,47.8 54.45,47.8 54.47,47.8 55.99,46.28 55.99,45.54 56.12,45.41 CON1700.55
  IN4 w0.076: v3(81.72,108.92) 81.52,108.72 81.42,108.72 81.35,108.66 81.35,107.38 80.25,106.28 80.25,104.8 79.91,104.45 79.61,104.45 78.79,103.64 78.79,103.64 78.76,103.6 78.76,103.56 78.75,103.56
  IN4 w0.127: 78.75,103.56 78.29,103.1 78.29,102.11 76.58,100.4 76.22,100.4 75.06,99.24 73.7,99.24 53.88,79.43 53.88,73.08 53.62,72.82 52.87,72.82 52.74,72.7 52.74,72.19 52.87,72.06 53.62,72.06 53.88,71.8 53.88,71.18 52.64,69.93 52.64,65.76 50.73,63.85 50.73,60.03 51.72,59.05 51.72,57.04 52.17,56.59 52.17,53.49 53.51,52.15 53.51,49.59 53.77,49.33 53.77,48.95 v2(53.97,48.74)
  BOTTOM w0.076: v3(81.72,108.92) 81.59,108.92 U0300.BF9
  BOTTOM w0.146: v2(53.97,48.74) 53.8,48.92 53.8,50.29 54.01,50.5 54.01,51.87 54.13,51.99 CON1701.55
M_CHB_DQS2#: length 87.7
  TOP w0.146: CON1700.53 55.62,45.41 55.75,45.53 55.75,46.18 54.37,47.55 54.34,47.55 54.34,47.56 53.99,47.56 53.56,47.99 53.56,48.54 v2(53.36,48.74)
  IN4 w0.076: v3(80.81,108.92) 81.17,108.55 81.17,107.45 80.07,106.35 80.07,104.87 79.83,104.63 79.53,104.63 78.62,103.72 78.59,103.72
  IN4 w0.127: 78.59,103.72 78.06,103.19 78.06,102.21 76.49,100.63 76.13,100.63 74.96,99.47 73.6,99.47 53.66,79.52 53.66,73.18 53.53,73.05 52.78,73.05 52.52,72.79 52.52,72.09 52.78,71.83 53.53,71.83 53.66,71.7 53.66,71.27 52.41,70.03 52.41,65.86 50.51,63.95 50.51,59.94 51.49,58.95 51.49,56.95 51.94,56.49 51.94,53.39 53.29,52.05 53.29,49.49 53.54,49.24 53.54,48.93 v2(53.36,48.74)
  BOTTOM w0.076: v3(80.81,108.92) 80.67,108.92 U0300.BG9
  BOTTOM w0.146: CON1701.53 53.62,51.99 53.76,51.86 53.76,50.6 53.55,50.39 53.55,48.94 v2(53.36,48.74)
M_CHB_DQS3: length 84.4
  TOP w0.146: v2(58.88,48.08) 58.66,48.31 58.66,48.62 61.27,51.23 61.27,51.84 61.37,51.95 CON1700.76
  IN4 w0.076: v3(84.46,108.92) 84.1,108.55 84.1,107.47 83.76,107.14 83.65,107.14 83.14,106.63 83.14,104.48 83.02,104.36 83.02,101.33 81.73,100.03 81.51,100.03 81.47,100
  IN4 w0.127: 81.47,100 81.17,100 80.18,99.02 78.81,99.02 78.24,98.45 77.64,98.45 76.52,97.33 76.52,96.27 59.42,79.17 59.42,72.61 57.97,71.16 57.97,70.13 58.38,69.72 58.38,69.11 57.97,68.71 57.97,53.77 58.67,53.08 58.67,48.3 v2(58.88,48.08)
  BOTTOM w0.076: v3(84.46,108.92) 84.33,108.92 U0300.BB9
  BOTTOM w0.146: v2(58.88,48.08) 58.69,47.89 58.69,46.94 59.25,46.38 59.25,45.75 59.38,45.62 CON1701.76
M_CHB_DQS3#: length 84.5
  TOP w0.146: CON1700.74 60.87,51.99 61.02,51.84 61.02,51.33 58.41,48.72 58.41,48.22 v2(58.27,48.08)
  IN4 w0.076: 81.41,100.23 81.43,100.21 81.66,100.21 82.85,101.4 82.85,104.44 82.96,104.55 82.96,106.7 83.57,107.32 83.69,107.32 83.92,107.55 83.92,108.55 v3(83.55,108.92)
  IN4 w0.127: 81.41,100.23 81.08,100.23 80.09,99.24 78.72,99.24 78.15,98.67 77.54,98.67 76.29,97.42 76.29,96.37 59.19,79.27 59.19,72.7 57.75,71.26 57.75,70.03 58.15,69.63 58.15,69.21 57.75,68.8 57.75,53.67 58.44,52.98 58.44,48.25 v2(58.27,48.08)
  BOTTOM w0.076: v3(83.55,108.92) 83.42,108.92 U0300.BC9
  BOTTOM w0.146: v2(58.27,48.08) 58.44,47.92 58.44,46.84 59,46.28 59,45.77 58.88,45.64 CON1701.74
M_CHB_DQS4: length 84
  TOP w0.146: v2(90.84,49.41) 91.47,49.41 91.78,49.11 91.78,48.62 90.72,47.56 90.09,47.56 89.3,46.77 89.3,45.92 89.12,45.74 CON1700.179
  IN4 w0.076: v3(100.92,108.92) 100.77,109.07 100.61,109.07 100.45,108.9 100.45,108.74 100.56,108.63 100.56,107.43 101.05,106.94 101.05,99.85 101.17,99.73 101.17,99.63
  IN4 w0.127: v2(90.84,49.41) 90.21,49.41 89.95,49.67 89.95,51.55 92.37,53.97 92.37,55.38 94.15,57.17 94.15,58.7 95.02,59.57 95.02,63.99 94.9,64.11 94.9,66.86 94.53,67.23 94.53,72.6 99.77,77.83 99.77,78.56 105.23,84.02 105.23,94.2 101.17,98.26 101.17,99.63
  BOTTOM w0.076: v3(100.92,108.92) 100.79,108.92 U0300.AA9
  BOTTOM w0.146: CON1701.179 87.13,51.74 86.87,51.49 86.87,51.33 87.41,50.8 88.07,50.8 89.89,48.98 90.33,48.98 90.43,49.08 90.43,49.31 90.53,49.41 v2(90.84,49.41)
M_CHB_DQS4#: length 84
  TOP w0.146: CON1700.177 88.62,45.8 88.73,45.9 88.93,45.9 89.05,46.02 89.05,46.87 89.99,47.81 90.61,47.81 91.53,48.73 91.53,49 91.37,49.16 91.22,49.16 v2(90.84,48.78)
  IN4 w0.076: 100.94,99.63 100.94,99.71 100.87,99.78 100.87,106.86 100.38,107.36 100.38,108.55 v3(100.01,108.92)
  IN4 w0.127: 100.94,99.63 100.94,98.16 105,94.11 105,84.11 99.54,78.66 99.54,77.93 94.3,72.69 94.3,67.14 94.67,66.77 94.67,64.02 94.79,63.89 94.79,59.67 93.92,58.8 93.92,57.26 92.14,55.48 92.14,54.06 89.72,51.64 89.72,49.58 90.12,49.18 90.43,49.18 v2(90.84,48.78)
  BOTTOM w0.076: v3(100.01,108.92) 99.88,108.92 U0300.AC9
  BOTTOM w0.146: CON1701.177 86.63,51.23 87.3,50.55 87.97,50.55 89.79,48.73 90.79,48.73 v2(90.84,48.78)
M_CHB_DQS5: length 82.8
  TOP w0.146: v2(94.52,48.37) 95.08,48.93 95.08,51.03 94.37,51.73 CON1700.200
  IN4 w0.076: v3(103.68,108.92) 103.31,108.55 103.31,101.65 103.78,101.18 103.82,101.18 103.93,101.07 103.93,101.02 103.96,100.99 103.96,100.98
  IN4 w0.127: v2(94.52,48.37) 95.11,48.96 95.11,50.81 98.47,54.17 98.47,55.69 99.69,56.91 99.69,58.64 99.45,58.89 99.45,59.57 99.66,59.78 99.66,64.88 100.81,66.03 100.81,66.3 101.19,66.68 101.19,70.09 101.21,70.12 101.75,70.12 102.1,70.46 102.1,70.99 101.75,71.34 101.21,71.34 101.09,71.46 101.09,71.8 102.18,72.9 102.18,74.2 109.34,81.36 109.34,93.92 103.96,99.31 103.96,100.98
  BOTTOM w0.076: v3(103.68,108.92) 103.53,108.92 U0300.V9
  BOTTOM w0.146: v2(94.52,48.37) 94.02,48.37 93.92,48.47 93.92,48.74 93.8,48.86 93.46,48.86 93.31,48.71 93.31,47.38 92.25,46.32 92.25,45.54 92.38,45.41 CON1701.200
M_CHB_DQS5#: length 82.8
  TOP w0.146: v2(94.39,48.98) 94.78,48.98 94.83,49.03 94.83,50.93 94.49,51.26 94.03,51.26 93.87,51.42 CON1700.198
  IN4 w0.076: v3(102.75,108.92) 102.94,109.11 103.13,109.11 103.25,108.98 103.25,108.75 103.13,108.63 103.13,101.58 103.73,100.98
  IN4 w0.127: 103.73,100.98 103.73,99.21 109.11,93.83 109.11,81.46 101.95,74.3 101.95,72.99 100.86,71.9 100.86,71.37 101.12,71.11 101.66,71.11 101.87,70.9 101.87,70.56 101.66,70.35 101.12,70.35 100.96,70.19 100.96,66.77 100.58,66.39 100.58,66.12 99.43,64.98 99.43,60.01 99.22,59.8 99.22,58.79 99.46,58.55 99.46,57.01 98.24,55.79 98.24,54.27 94.88,50.91 94.88,49.19 94.67,48.98 v2(94.39,48.98)
  BOTTOM w0.076: U0300.W9 102.62,108.92 v3(102.75,108.92)
  BOTTOM w0.146: v2(94.39,48.98) 94.27,49.1 93.35,49.1 93.06,48.81 93.06,47.49 92,46.42 92,45.53 91.88,45.41 CON1701.198
M_CHB_DQS6: length 86.7
  TOP w0.146: CON1700.221 99.62,45.41 99.5,45.53 99.5,47.77 100.42,48.68 100.42,49.14 v2(100.62,49.33)
  IN4 w0.076: 107.14,104.33 107,104.47 107,106.64 106.42,107.22 106.27,107.22 106.04,107.45 106.04,108.87 106.09,108.92 v3(106.41,108.92)
  IN4 w0.127: 107.14,104.33 107.47,104 107.47,101.96 108.82,100.61 108.82,99.41 110.81,97.41 111.21,97.41 111.65,97.86 112.2,97.86 112.69,97.36 112.69,96.83 112.36,96.5 112.36,95.89 114.14,94.11 116.02,94.11 116.46,93.68 116.46,92.94 116.06,92.54 114.1,92.54 113.63,92.08 113.63,79.19 113.3,78.85 107.88,73.43 107.88,67.85 107.3,67.27 107.3,65.91 108.2,65.01 108.2,63.89 105.49,61.19 105.49,59.04 105.36,58.9 105.36,56.71 104.73,56.08 104.73,54.49 101.58,51.34 101.58,51.03 100.48,49.93 100.48,49.47 v2(100.62,49.33)
  BOTTOM w0.076: v3(106.41,108.92) 106.28,108.92 U0300.P9
  BOTTOM w0.146: v2(100.62,49.33) 99.86,50.09 99.17,50.09 97.63,51.64 CON1701.221
M_CHB_DQS6#: length 86.7
  TOP w0.146: v2(99.98,49.36) 100.17,49.17 100.17,48.79 99.26,47.87 99.26,45.54 99.12,45.41 CON1700.219
  IN4 w0.076: 106.98,104.17 106.82,104.32 106.82,106.57 106.35,107.04 106.19,107.04 105.86,107.37 105.86,108.82 105.76,108.92 v3(105.5,108.92)
  IN4 w0.127: v2(99.98,49.36) 100.26,49.63 100.26,50.03 101.35,51.12 101.35,51.44 104.5,54.59 104.5,56.17 105.13,56.8 105.13,59 105.26,59.13 105.26,61.28 107.97,63.99 107.97,64.92 107.07,65.82 107.07,67.36 107.65,67.94 107.65,73.52 113.4,79.28 113.4,92.17 114,92.77 115.96,92.77 116.23,93.04 116.23,93.58 115.93,93.88 114.05,93.88 112.13,95.8 112.13,96.59 112.47,96.93 112.47,97.26 112.1,97.63 111.75,97.63 111.3,97.18 110.72,97.18 108.59,99.31 108.59,100.52 107.24,101.87 107.24,103.9 106.98,104.17
  BOTTOM w0.076: U0300.R9 105.36,108.92 v3(105.5,108.92)
  BOTTOM w0.146: v2(99.98,49.36) 99.98,49.62 99.76,49.84 99.07,49.84 97.44,51.48 97.26,51.48 97.13,51.61 CON1701.219
M_CHB_DQS7: length 87.9
  TOP w0.146: CON1700.242 104.87,51.8 105.13,51.54 105.13,50.58 105.74,49.97 105.74,48.47 v2(105.31,48.04)
  IN4 w0.076: v3(109.13,108.92) 108.91,108.71 108.91,108.61 108.74,108.44 108.74,107.43 108.87,107.3 109.17,107.3 109.99,106.48 109.99,106.16 110.04,106.11
  IN4 w0.127: v2(105.31,48.04) 105.31,48.4 105.72,48.81 105.72,49.6 107.83,51.71 109.09,51.71 110.89,53.51 110.89,54.83 111.1,55.04 111.1,58.09 112.67,59.66 112.67,72.23 117.73,77.28 117.73,83.83 118.63,84.74 120.37,84.74 121.65,86.01 121.65,94.56 120.61,95.59 120.61,97.7 116.3,102.01 113.3,102.01 110.04,105.28 110.04,106.11
  BOTTOM w0.076: U0300.L9 109.02,108.92 v3(109.13,108.92)
  BOTTOM w0.146: v2(105.31,48.04) 105.18,48.17 104.6,48.17 103.65,47.22 102.72,46.29 102.72,45.76 102.88,45.6 CON1701.242
