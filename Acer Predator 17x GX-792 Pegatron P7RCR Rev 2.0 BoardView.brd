# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Nets (continued)
DDR_PWRGD: SR9208.1 T8300.1 T9202.1 U8300.10(PGOOD)
DDR_RC: C8314.1 R8301.2
DDR_VDD: C8318.1 SR8302.2 SR8303.1 U8300.12(VDD)
DDR_VDDQ: JP8303.2 U8300.5(VDDQ)
DDR_VID: R8303.1 SR8303.2 U8300.11(VID)
DDR_VTT_CNTL_R: R0728.2 U0701.2(A)
DDR_VTT_CNTRL: D8300.2(CATHODE) R0704.2 R0755.2 R8304.2 R8305.1 SR5703.1 U0701.4(Y)
DDR_VTT_CNTRL#: Q5708.3(DRAIN) Q5709.1(GATE) R5712.2
DDR_VTTSNS: JP8300.2 U8300.2(VTTSNS)
DDRA_VREF_CA_R: R1610.2 R1612.1 SR1601.1 SR1602.1
DDRA_VREF_CA_R_W10S12: C0501.1 R0505.1 U0300.BN13(DDR_VREF_CA)
DDRA_VREF_CA_W10S12: C1612.1 C1613.2 C1614.1 C1615.2 CON1600.164(VREFCA) CON1601.164(VREFCA) R0505.2 SR1601.2 SR1602.2
DDRB_VREF_CA_R: R1710.2 R1714.1 SR1701.1 SR1702.1
DDRB_VREF_CA_R_W10S12: C0502.1 R0508.1 U0300.BR13(DDR1_VREF_DQ)
DDRB_VREF_CA_W10S12: C1712.1 C1713.1 C1714.1 C1715.1 CON1700.164(VREFCA) CON1701.164(VREFCA) R0508.2 SR1701.2 SR1702.2
DEBUG1: R1234.1 U1201.L2(DEBUG1)
DEBUG2: R1233.1 U1201.K2(DEBUG2)
DEBUG3: R1236.1 U1201.L3(DEBUG3)
DEBUG4: R1235.1 U1201.K3(DEBUG4)
DEBUGMODE: R3301.1 U3300.5(DEBUGMODE[0])
DELAY_ALL_SYSTEM_PWRGD: R0756.1 R2486.1 R3003.1 SR0701.1 U3002.84(EGCLK/GPE3)
DISPA_BCLK_L200MIL: R2311.2 U2000.AM2(DISPA_BCLK)
DISPA_SDO_L200MIL: R2307.2 U2000.AM1(DISPA_SDO)
DMI_RXN0: U0300.E8(DMI_RXN[0]) U2000.C27(DMI_TXN0)
DMI_RXN1: U0300.F6(DMI_RXN[1]) U2000.B28(DMI_TXN1)
DMI_RXN2: U0300.E5(DMI_RXN[2]) U2000.B29(DMI_TXN2)
DMI_RXN3: U0300.J9(DMI_RXN[3]) U2000.B30(DMI_TXN3)
DMI_RXP0: U0300.D8(DMI_RXP[0]) U2000.B27(DMI_TXP0)
DMI_RXP1: U0300.E6(DMI_RXP[1]) U2000.A28(DMI_TXP1)
DMI_RXP2: U0300.D5(DMI_RXP[2]) U2000.C29(DMI_TXP2)
DMI_RXP3: U0300.J8(DMI_RXP[3]) U2000.A30(DMI_TXP3)
DMI_TXN0: U0300.A8(DMI_TXN[0]) U2000.L27(DMI_RXN0)
DMI_TXN1: U0300.B6(DMI_TXN[1]) U2000.E24(DMI_RXN1)
DMI_TXN2: U0300.A5(DMI_TXN[2]) U2000.G27(DMI_RXN2)
DMI_TXN3: U0300.B4(DMI_TXN[3]) U2000.L29(DMI_RXN3)
DMI_TXP0: U0300.B8(DMI_TXP[0]) U2000.N27(DMI_RXP0)
DMI_TXP1: U0300.C6(DMI_TXP[1]) U2000.G24(DMI_RXP1)
DMI_TXP2: U0300.B5(DMI_TXP[2]) U2000.E26(DMI_RXP2)
DMI_TXP3: U0300.D4(DMI_TXP[3]) U2000.K29(DMI_RXP3)
DMIC_CLK: C3627.1 CON4500.28 R2376.1 R3611.1
DMIC_DATA: C3628.1 CON4500.30 R2375.2 R3610.1
DP2_TXN0_C: C1401.2 U1401.39(IN0N)
DP2_TXN1_C: C1402.2 U1401.42(IN1N)
DP2_TXN2_C: C1403.2 U1401.45(IN2N)
DP2_TXN3_C: C1406.2 U1401.48(IN3N)
DP2_TXP0_C: C1405.2 U1401.38(IN0P)
DP2_TXP1_C: C1410.2 U1401.41(IN1P)
DP2_TXP2_C: C1409.2 U1401.44(IN2P)
DP2_TXP3_C: C1404.2 U1401.47(IN3P)
DP_AUXN: C1146.1 R1415.2 U1401.27(AUX_SNKN)
DP_AUXP: C1147.1 R1416.1 U1401.28(AUX_SNKP)
DP_CEXT: C1411.1 U1401.2(CEXT)
DP_CFG0: R1403.2 R1406.1 U1401.5(SDA_CTL/CFG0)
DP_CFG1: R1402.2 R1404.1 U1401.40(CFG1)
DP_DATA0: C1138.1 U1401.23(OUT0P)
DP_DATA0#: C1139.1 U1401.22(OUT0N)
DP_DATA1: C1140.1 U1401.20(OUT1P)
DP_DATA1#: C1141.1 U1401.19(OUT1N)
DP_DATA2: C1142.1 U1401.17(OUT2P)
DP_DATA2#: C1143.1 U1401.16(OUT2N)
DP_DATA3: C1144.1 U1401.14(OUT3P)
DP_DATA3#: C1145.1 U1401.13(OUT3N)
DP_DDI3_AUXN_C: C1408.2 U1401.29(AUX_SRCN)
DP_DDI3_AUXP_C: C1407.2 U1401.30(AUX_SRCP)
DP_IFPC_DATA0: C4622.1 U7000.BE20(IFPC_L0)
DP_IFPC_DATA0#: C4623.1 U7000.BF20(IFPC_L0_N)
DP_IFPC_DATA0#_C: C4623.2 U4601.5(IN0N)
DP_IFPC_DATA0_C: C4622.2 U4601.4(IN0P)
DP_IFPC_DATA1: C4624.1 U7000.BH20(IFPC_L1)
DP_IFPC_DATA1#: C4625.1 U7000.BG20(IFPC_L1_N)
DP_IFPC_DATA1#_C: C4625.2 U4601.8(IN1N)
DP_IFPC_DATA1_C: C4624.2 U4601.7(IN1P)
DP_IFPC_DATA2: C4618.1 U7000.BG18(IFPC_L2)
DP_IFPC_DATA2#: C4620.1 U7000.BF18(IFPC_L2_N)
DP_IFPC_DATA2#_C: C4620.2 U4601.11(IN2N)
DP_IFPC_DATA2_C: C4618.2 U4601.10(IN2P)
DP_IFPC_DATA3: C4619.1 U7000.BE17(IFPC_L3)
DP_IFPC_DATA3#: C4621.1 U7000.BF17(IFPC_L3_N)
DP_IFPC_DATA3#_C: C4621.2 U4601.14(IN3N)
DP_IFPC_DATA3_C: C4619.2 U4601.13(IN3P)
DP_IFPD_AUXN: C1408.1 R7229.1 U7000.BM9(IFPF_AUX_SDA_N)
DP_IFPD_AUXP: C1407.1 R7201.1 U7000.BM8(IFPF_AUX_SCL)
DP_IFPD_DATA0: C1405.1 U7000.BL14(IFPF_L0)
DP_IFPD_DATA0#: C1401.1 U7000.BK14(IFPF_L0_N)
DP_IFPD_DATA1: C1410.1 U7000.BK12(IFPF_L1)
DP_IFPD_DATA1#: C1402.1 U7000.BL12(IFPF_L1_N)
DP_IFPD_DATA2: C1409.1 U7000.BM12(IFPF_L2)
DP_IFPD_DATA2#: C1403.1 U7000.BM11(IFPF_L2_N)
DP_IFPD_DATA3: C1404.1 U7000.BL11(IFPF_L3)
DP_IFPD_DATA3#: C1406.1 U7000.BK11(IFPF_L3_N)
DP_IFRC_AUXN: C4627.1 Q4601.4(S) R7213.1 SR7208.1 U7000.BL9(IFPC_AUX_SDA_N)
DP_IFRC_AUXP: C4626.1 Q4601.1(S) R7214.1 SR7207.1 U7000.BK9(IFPC_AUX_SCL)
DP_OUT_DATA0: C4629.1 U4601.35(OUT0P)
DP_OUT_DATA0#: C4631.1 U4601.34(OUT0N)
DP_OUT_DATA0#_CON: C4631.2 CON4601.3
DP_OUT_DATA0_CON: C4629.2 CON4601.1
DP_OUT_DATA1: C4628.1 U4601.32(OUT1P)
DP_OUT_DATA1#: C4630.1 U4601.31(OUT1N)
DP_OUT_DATA1#_CON: C4630.2 CON4601.6
DP_OUT_DATA1_CON: C4628.2 CON4601.4
DP_OUT_DATA2: C4632.1 U4601.29(OUT2P)
DP_OUT_DATA2#: C4633.1 U4601.28(OUT2N)
DP_OUT_DATA2#_CON: C4633.2 CON4601.9
DP_OUT_DATA2_CON: C4632.2 CON4601.7
DP_OUT_DATA3: C4634.1 U4601.26(OUT3P)
DP_OUT_DATA3#: C4635.1 U4601.25(OUT3N)
DP_OUT_DATA3#_CON: C4635.2 CON4601.12
DP_OUT_DATA3_CON: C4634.2 CON4601.10
DP_PD#: R1414.2 U1401.26(PD#)
DP_REQ: R1401.1 R1405.2 U1401.4(SCL_CTL/PEQ)
DP_REXT: R1411.1 U1401.7(REXT)
DPSRC1_AUX_N: C1146.2 U1101.W11(DPSNK0_AUX_N)
DPSRC1_AUX_P: C1147.2 U1101.Y11(DPSNK0_AUX_P)
DPSRC1_ML0_N: C1139.2 U1101.AC7(DPSNK0_ML0_N)
DPSRC1_ML0_P: C1138.2 U1101.AB7(DPSNK0_ML0_P)
DPSRC1_ML1_N: C1141.2 U1101.AC9(DPSNK0_ML1_N)
DPSRC1_ML1_P: C1140.2 U1101.AB9(DPSNK0_ML1_P)
DPSRC1_ML2_N: C1143.2 U1101.AC11(DPSNK0_ML2_N)
DPSRC1_ML2_P: C1142.2 U1101.AB11(DPSNK0_ML2_P)
DPSRC1_ML3_N: C1145.2 U1101.AC13(DPSNK0_ML3_N)
DPSRC1_ML3_P: C1144.2 U1101.AB13(DPSNK0_ML3_P)
DRAMRST_R#: C1602.2 C1603.2 C1702.2 C1703.2 CON1600.108(RESET_N) CON1601.108(RESET_N) CON1700.108(RESET_N) CON1701.108(RESET_N) SR2407.1
DXN: C5004.2 Q5001.2(EMITTER) U5000.3(DXN)
DXP: C5004.1 Q5001.1(BASE) Q5001.3(COLLECTOR) U5000.2(DXP)
EC_AGND: C3021.2 SR3014.2 U3002.75(AVSS)
EC_PIN_104: R3022.1 R3038.1 U3002.104(VSS5)
EC_PIN_107: R3012.1 R3028.1 U3002.107(PWRSW/GPE4)
EC_PIN_113: R3011.1 R3040.1 U3002.113(CRX0/GPC0)
EC_PIN_119: R3023.2 R3098.1 U3002.119(DSR0#/GPG6)
EC_PIN_122: R3021.1 R3039.1 U3002.122(DTR1#/SBUSY/GPG1/ID7)
EC_PIN_125: R3019.1 R3024.2 U3002.125(SSCE1#/GPG0)
EC_RST#: C3011.1 C5002.1 D5004.3(ANODE) R5004.2 U3002.14(WRST#)
EDP_AUX_DN_C: C4530.2 L4505.1 RN4505.3(X)
EDP_AUX_DN_R: CON4500.15 L4505.2 R4523.2 RN4505.4(Y)
EDP_AUX_DP_C: C4529.2 L4505.4 RN4505.1(X)
EDP_AUX_DP_R: CON4500.14 L4505.3 R4524.2 RN4505.2(Y)
EDP_AUXN: C4530.1 R7322.1 U7000.BF11(IFPD_AUX_SDA_N)
EDP_AUXP: C4529.1 R7321.1 U7000.BE11(IFPD_AUX_SCL)
EDP_RCOMP: R0300.2 U0300.D37(EDP_RCOMP)
EDP_TX0_DN_C: C4533.2 L4504.4 RN4504.1(X)
EDP_TX0_DN_R: CON4500.11 L4504.3 RN4504.2(Y)
EDP_TX0_DP_C: C4531.2 L4504.1 RN4504.3(X)
EDP_TX0_DP_R: CON4500.12 L4504.2 RN4504.4(Y)
EDP_TX1_DN_C: C4534.2 L4503.4 RN4503.1(X)
EDP_TX1_DN_R: CON4500.8 L4503.3 RN4503.2(Y)
EDP_TX1_DP_C: C4535.2 L4503.1 RN4503.3(X)
EDP_TX1_DP_R: CON4500.9 L4503.2 RN4503.4(Y)
EDP_TX2_DN_C: C4519.2 L4502.4 RN4502.1(X)
EDP_TX2_DN_R: CON4500.5 L4502.3 RN4502.2(Y)
EDP_TX2_DP_C: C4520.2 L4502.1 RN4502.3(X)
EDP_TX2_DP_R: CON4500.6 L4502.2 RN4502.4(Y)
EDP_TX3_DN_C: C4522.2 L4501.4 RN4501.1(X)
EDP_TX3_DN_R: CON4500.2 L4501.3 RN4501.2(Y)
EDP_TX3_DP_C: C4521.2 L4501.1 RN4501.3(X)
EDP_TX3_DP_R: CON4500.3 L4501.2 RN4501.4(Y)
EDP_TXN_0: C4533.1 U7000.BM17(IFPD_L0_N)
EDP_TXN_1: C4534.1 U7000.BK17(IFPD_L1_N)
EDP_TXN_2: C4519.1 U7000.BL15(IFPD_L2_N)
EDP_TXN_3: C4522.1 U7000.BM14(IFPD_L3_N)
EDP_TXP_0: C4531.1 U7000.BM18(IFPD_L0)
EDP_TXP_1: C4535.1 U7000.BL17(IFPD_L1)
EDP_TXP_2: C4520.1 U7000.BK15(IFPD_L2)
EDP_TXP_3: C4521.1 U7000.BM15(IFPD_L3)
EN: C1512.2 R1514.2 U1501.7(EN)
ENABLE1: R8111.1 SR8102.1 U8100.20(EN1)
ENABLE2: SR8103.2 U8100.6(EN2)
EQ0: R4601.1 U4601.39(EQ0/AD0)
EQ1: R4606.1 U4601.40(EQ1/AD1)
EQ2: R4602.1 U4601.41(EQ2/AD2)
EQ3: R4627.1 U4601.42(EQ3/AD3)
EQ_SEL_A0: R1324.2 R1325.1 U1301.17(EQ_SEL/A0)
ESPI_ALERT0#: R3013.1 SR2208.1
EXP_RXN0: C0631.1 U7000.BH26(PEX_TX0_N)
EXP_RXN1: C0629.1 U7000.BE26(PEX_TX1_N)
EXP_RXN2: C0627.1 U7000.BG27(PEX_TX2_N)
EXP_RXN3: C0625.1 U7000.BH29(PEX_TX3_N)
EXP_RXN4: C0623.1 U7000.BE29(PEX_TX4_N)
EXP_RXN5: C0621.1 U7000.BG30(PEX_TX5_N)
EXP_RXN6: C0619.1 U7000.BH32(PEX_TX6_N)
EXP_RXN7: C0617.1 U7000.BE32(PEX_TX7_N)
EXP_RXN8: C0615.1 U7000.BG33(PEX_TX8_N)
EXP_RXN9: C0613.1 U7000.BH35(PEX_TX9_N)
EXP_RXN10: C0611.1 U7000.BE35(PEX_TX10_N)
EXP_RXN11: C0605.1 U7000.BG36(PEX_TX11_N)
EXP_RXN12: C0609.1 U7000.BH38(PEX_TX12_N)
EXP_RXN13: C0608.1 U7000.BE38(PEX_TX13_N)
EXP_RXN14: C0602.1 U7000.BG39(PEX_TX14_N)
EXP_RXN15: C0600.1 U7000.BG41(PEX_TX15_N)
EXP_RXP0: C0630.1 U7000.BG26(PEX_TX0)
EXP_RXP1: C0628.1 U7000.BF26(PEX_TX1)
EXP_RXP2: C0626.1 U7000.BF27(PEX_TX2)
EXP_RXP3: C0624.1 U7000.BG29(PEX_TX3)
EXP_RXP4: C0622.1 U7000.BF29(PEX_TX4)
EXP_RXP5: C0620.1 U7000.BF30(PEX_TX5)
EXP_RXP6: C0618.1 U7000.BG32(PEX_TX6)
EXP_RXP7: C0616.1 U7000.BF32(PEX_TX7)
EXP_RXP8: C0614.1 U7000.BF33(PEX_TX8)
EXP_RXP9: C0612.1 U7000.BG35(PEX_TX9)
EXP_RXP10: C0606.1 U7000.BF35(PEX_TX10)
EXP_RXP11: C0610.1 U7000.BF36(PEX_TX11)
EXP_RXP12: C0604.1 U7000.BG38(PEX_TX12)
EXP_RXP13: C0603.1 U7000.BF38(PEX_TX13)
EXP_RXP14: C0601.1 U7000.BF39(PEX_TX14)
EXP_RXP15: C0607.1 U7000.BH41(PEX_TX15)
EXP_TXN0: C7014.2 U0300.B10(PEG_TXN[15])
EXP_TXN0_C: C7014.1 U7000.BK27(PEX_RX0_N)
EXP_TXN1: C7005.2 U0300.B11(PEG_TXN[14])
EXP_TXN1_C: C7005.1 U7000.BL29(PEX_RX1_N)
EXP_TXN2: C7010.2 U0300.B12(PEG_TXN[13])
EXP_TXN2_C: C7010.1 U7000.BM30(PEX_RX2_N)
EXP_TXN3: C7021.2 U0300.B13(PEG_TXN[12])
EXP_TXN3_C: C7021.1 U7000.BK30(PEX_RX3_N)
EXP_TXN4: C7023.2 U0300.B14(PEG_TXN[11])
EXP_TXN4_C: C7023.1 U7000.BL32(PEX_RX4_N)
EXP_TXN5: C7025.2 U0300.B15(PEG_TXN[10])
EXP_TXN5_C: C7025.1 U7000.BM33(PEX_RX5_N)
EXP_TXN6: C7030.2 U0300.B16(PEG_TXN[9])
EXP_TXN6_C: C7030.1 U7000.BK33(PEX_RX6_N)
EXP_TXN7: C7032.2 U0300.B17(PEG_TXN[8])
EXP_TXN7_C: C7032.1 U7000.BL35(PEX_RX7_N)
EXP_TXN8: C7034.2 U0300.C18(PEG_TXN[7])
EXP_TXN8_C: C7034.1 U7000.BM36(PEX_RX8_N)
EXP_TXN9: C7036.2 U0300.A19(PEG_TXN[6])
EXP_TXN9_C: C7036.1 U7000.BK36(PEX_RX9_N)
EXP_TXN10: C7038.2 U0300.C20(PEG_TXN[5])
EXP_TXN10_C: C7038.1 U7000.BL38(PEX_RX10_N)
EXP_TXN11: C7040.2 U0300.A21(PEG_TXN[4])
EXP_TXN11_C: C7040.1 U7000.BM39(PEX_RX11_N)
EXP_TXN12: C7042.2 U0300.C22(PEG_TXN[3])
EXP_TXN12_C: C7042.1 U7000.BK39(PEX_RX12_N)
EXP_TXN13: C7044.2 U0300.A23(PEG_TXN[2])
EXP_TXN13_C: C7044.1 U7000.BL41(PEX_RX13_N)
EXP_TXN14: C7050.2 U0300.C24(PEG_TXN[1])
EXP_TXN14_C: C7050.1 U7000.BM42(PEX_RX14_N)
EXP_TXN15: C7052.2 U0300.A25(PEG_TXN[0])
EXP_TXN15_C: C7052.1 U7000.BK42(PEX_RX15_N)
EXP_TXP0: C7004.2 U0300.C10(PEG_TXP[15])
EXP_TXP0_C: C7004.1 U7000.BL27(PEX_RX0)
EXP_TXP1: C7015.2 U0300.A11(PEG_TXP[14])
EXP_TXP1_C: C7015.1 U7000.BK29(PEX_RX1)
EXP_TXP2: C7009.2 U0300.C12(PEG_TXP[13])
EXP_TXP2_C: C7009.1 U7000.BM29(PEX_RX2)
EXP_TXP3: C7020.2 U0300.A13(PEG_TXP[12])
EXP_TXP3_C: C7020.1 U7000.BL30(PEX_RX3)
EXP_TXP4: C7022.2 U0300.C14(PEG_TXP[11])
EXP_TXP4_C: C7022.1 U7000.BK32(PEX_RX4)
EXP_TXP5: C7024.2 U0300.A15(PEG_TXP[10])
EXP_TXP5_C: C7024.1 U7000.BM32(PEX_RX5)
EXP_TXP6: C7029.2 U0300.C16(PEG_TXP[9])
EXP_TXP6_C: C7029.1 U7000.BL33(PEX_RX6)
EXP_TXP7: C7031.2 U0300.A17(PEG_TXP[8])
EXP_TXP7_C: C7031.1 U7000.BK35(PEX_RX7)
EXP_TXP8: C7033.2 U0300.B18(PEG_TXP[7])
EXP_TXP8_C: C7033.1 U7000.BM35(PEX_RX8)
EXP_TXP9: C7035.2 U0300.B19(PEG_TXP[6])
EXP_TXP9_C: C7035.1 U7000.BL36(PEX_RX9)
EXP_TXP10: C7037.2 U0300.B20(PEG_TXP[5])
EXP_TXP10_C: C7037.1 U7000.BK38(PEX_RX10)
EXP_TXP11: C7039.2 U0300.B21(PEG_TXP[4])
EXP_TXP11_C: C7039.1 U7000.BM38(PEX_RX11)
EXP_TXP12: C7041.2 U0300.B22(PEG_TXP[3])
EXP_TXP12_C: C7041.1 U7000.BL39(PEX_RX12)
EXP_TXP13: C7043.2 U0300.B23(PEG_TXP[2])
EXP_TXP13_C: C7043.1 U7000.BK41(PEX_RX13)
EXP_TXP14: C7049.2 U0300.B24(PEG_TXP[1])
EXP_TXP14_C: C7049.1 U7000.BM41(PEX_RX14)
EXP_TXP15: C7051.2 U0300.B25(PEG_TXP[0])
EXP_TXP15_C: C7051.1 U7000.BL42(PEX_RX15)
EXT_SCI#: R2210.2 SR3017.1 U2000.M44(GPP_G3/FAN_TACH_3)
EXT_SCI#_D: SR3017.2 U3002.23(ECSCI#/GPD3)
EXT_SMI#: R2365.2 SR3015.1 U2000.AN43(GPP_C23/UART2_CTS#)
EXT_SMI#_EC: SR3015.2 U3002.15(ECSMI#/GPD4)
F_CS#_EC: R3041.2 U3002.101(FSCE#/GPG3)
F_SCK_EC: R3043.2 U3002.105(FSCK/GPG7)
F_SDI_EC: R3044.2 U3002.102(FMOSI/GPG4)
FAN0_PWM: R5000.2 R5006.1 U3002.30(PWM4/GPA4)
FAN0_TACH: D5001.3(ANODE) R5003.2 R5005.1 U3002.47(TACH0A/GPD6)
FAN1_PWM: R5007.2 R5010.1 U3002.31(PWM5/GPA5)
FAN1_TACH: D5003.3(ANODE) R5008.2 R5009.1 U3002.48(TACH1A/TMA1/GPD7)
FAN2_PWM: R5020.1 U3002.32(PWM6/SSCK/GPA6)
FAN2_TACH: CON5002.2 R5021.2 U3002.79(DAC3/TACH1B/GPJ3)
FAN_REVERSE: R5015.1 R5016.1 U3002.29(PWM3/GPA3)
FB_A: R8049.2 R8080.2 R80100.2 U8000.17(FB_A)
FB_B: R8015.2 R8023.2 R8037.2 U8000.5(FB_B)
FB_C: R8047.1 R8079.1 R8099.1 U8000.30(FB_C)
FB_PLL_AVDD: C7100.1 C7105.1 C7106.1 C7107.1 SR7102.1 U7000.AN42(FBA_PLL_AVDD) U7000.L17(FBC_PLL_AVDD) U7000.L38(FBB_PLL_AVDD) U7000.V11(FBD_PLL_AVDD)
FB_PLL_VDD: C7101.1 C7102.1 L7100.1 SR7101.1 SR7102.2
FB_REFPLL_AVDD_GPU: C7103.1 C7104.1 SR7101.2 U7000.AF42(FB_REFPLL_AVDD0) U7000.L29(FB_REFPLL_AVDD1)
FBA_CLK0: U7000.AG45(FBA_CLK0) U7600.K11(CK_T)
FBA_CLK0*: U7000.AG46(FBA_CLK0_N) U7600.K10(CK_C)
FBA_CLK1: U7000.AK46(FBA_CLK1) U7601.K11(CK_T)
FBA_CLK1*: U7000.AK45(FBA_CLK1_N) U7601.K10(CK_C)
FBA_CMD<0>: U7000.Y51(FBA_CMD0) U7600.H4(RAS_N/CAS_N)
FBA_CMD<1>: R7113.1 U7000.Y52(FBA_CMD1) U7600.K2(RESET_N)
FBA_CMD<2>: U7000.Y49(FBA_CMD2) U7600.M4(CAS_N/RAS_N)
FBA_CMD<3>: U7000.AA52(FBA_CMD3) U7600.L5(A11_A6/A9_A1)
FBA_CMD<4>: U7000.AA51(FBA_CMD4) U7600.L4(A8_A7/A10_A0)
FBA_CMD<5>: U7000.AA50(FBA_CMD5) U7600.K5(A12_A13)
FBA_CMD<6>: U7000.AC50(FBA_CMD6) U7600.K4(ABI_N)
FBA_CMD<7>: U7000.AC51(FBA_CMD7) U7600.J5(A9_A1/A11_A6)
FBA_CMD<8>: U7000.AC52(FBA_CMD8) U7600.J4(A10_A0/A8_A7)
FBA_CMD<9>: U7000.AC49(FBA_CMD9) U7600.J11(BA0_A2/BA2_A4)
FBA_CMD<10>: U7000.AD52(FBA_CMD10) U7600.J10(BA3_A3/BA1_A5)
FBA_CMD<11>: U7000.AD51(FBA_CMD11) U7600.L10(BA1_A5/BA3_A3)
FBA_CMD<12>: U7000.AD50(FBA_CMD12) U7600.L11(BA2_A4/BA0_A2)
FBA_CMD<13>: R7100.1 U7000.AF50(FBA_CMD13) U7600.M11(WE_N/CKE_N)
FBA_CMD<14>: U7000.AF51(FBA_CMD14) U7600.K12(A14_A15)
FBA_CMD<15>: U7000.AF52(FBA_CMD15) U7600.H11(CKE_N/WE_N)
FBA_CMD<16>: U7000.AN50(FBA_CMD16) U7601.M4(CAS_N/RAS_N)
FBA_CMD<17>: R7112.1 U7000.AN51(FBA_CMD17) U7601.K2(RESET_N)
FBA_CMD<18>: U7000.AN52(FBA_CMD18) U7601.H4(RAS_N/CAS_N)
FBA_CMD<19>: U7000.AM49(FBA_CMD19) U7601.J5(A9_A1/A11_A6)
FBA_CMD<20>: U7000.AM52(FBA_CMD20) U7601.J4(A10_A0/A8_A7)
FBA_CMD<21>: U7000.AM51(FBA_CMD21) U7601.K5(A12_A13)
FBA_CMD<22>: U7000.AM50(FBA_CMD22) U7601.K4(ABI_N)
FBA_CMD<23>: U7000.AK50(FBA_CMD23) U7601.L5(A11_A6/A9_A1)
FBA_CMD<24>: U7000.AK51(FBA_CMD24) U7601.L4(A8_A7/A10_A0)
FBA_CMD<25>: U7000.AK52(FBA_CMD25) U7601.L11(BA2_A4/BA0_A2)
FBA_CMD<26>: U7000.AJ49(FBA_CMD26) U7601.L10(BA1_A5/BA3_A3)
FBA_CMD<27>: U7000.AJ52(FBA_CMD27) U7601.J10(BA3_A3/BA1_A5)
FBA_CMD<28>: U7000.AJ51(FBA_CMD28) U7601.J11(BA0_A2/BA2_A4)
FBA_CMD<29>: R7101.1 U7000.AJ50(FBA_CMD29) U7601.H11(CKE_N/WE_N)
FBA_CMD<30>: U7000.AG50(FBA_CMD30) U7601.K12(A14_A15)
FBA_CMD<31>: U7000.AG51(FBA_CMD31) U7601.M11(WE_N/CKE_N)
FBA_D<0>: U7000.U51(FBA_D0) U7600.V4(DQ24/DQ0)
FBA_D<1>: U7000.U48(FBA_D1) U7600.V3(DQ25/DQ1)
FBA_D<2>: U7000.U50(FBA_D2) U7600.U4(DQ26/DQ2)
FBA_D<3>: U7000.U49(FBA_D3) U7600.U3(DQ27/DQ3)
FBA_D<4>: U7000.R51(FBA_D4) U7600.P4(DQ28/DQ4)
FBA_D<5>: U7000.R50(FBA_D5) U7600.P3(DQ29/DQ5)
FBA_D<6>: U7000.R47(FBA_D6) U7600.N4(DQ30/DQ6)
FBA_D<7>: U7000.U46(FBA_D7) U7600.N3(DQ31/DQ7)
FBA_D<8>: U7000.V46(FBA_D8) U7600.V11(DQ16/DQ8)
FBA_D<9>: U7000.Y45(FBA_D9) U7600.V12(DQ17/DQ9)
FBA_D<10>: U7000.Y47(FBA_D10) U7600.U11(DQ18/DQ10)
FBA_D<11>: U7000.Y46(FBA_D11) U7600.U12(DQ19/DQ11)
FBA_D<12>: U7000.V50(FBA_D12) U7600.P11(DQ20/DQ12)
FBA_D<13>: U7000.V47(FBA_D13) U7600.P12(DQ21/DQ13)
FBA_D<14>: U7000.U52(FBA_D14) U7600.N11(DQ22/DQ14)
FBA_D<15>: U7000.V51(FBA_D15) U7600.N12(DQ23/DQ15)
FBA_D<16>: U7000.AJ44(FBA_D16) U7600.B11(DQ8/DQ16)
FBA_D<17>: U7000.AG48(FBA_D17) U7600.B12(DQ9/DQ17)
FBA_D<18>: U7000.AJ45(FBA_D18) U7600.C11(DQ10/DQ18)
FBA_D<19>: U7000.AG49(FBA_D19) U7600.C12(DQ11/DQ19)
FBA_D<20>: U7000.AF46(FBA_D20) U7600.F11(DQ12/DQ20)
FBA_D<21>: U7000.AF47(FBA_D21) U7600.F12(DQ13/DQ21)
FBA_D<22>: U7000.AF48(FBA_D22) U7600.G11(DQ14/DQ22)
FBA_D<23>: U7000.AD47(FBA_D23) U7600.G12(DQ15/DQ23)
FBA_D<24>: U7000.AD49(FBA_D24) U7600.B4(DQ0/DQ24)
FBA_D<25>: U7000.AD48(FBA_D25) U7600.B3(DQ1/DQ25)
FBA_D<26>: U7000.AC46(FBA_D26) U7600.C4(DQ2/DQ26)
FBA_D<27>: U7000.AC47(FBA_D27) U7600.C3(DQ3/DQ27)
FBA_D<28>: U7000.AA47(FBA_D28) U7600.F4(DQ4/DQ28)
FBA_D<29>: U7000.AA46(FBA_D29) U7600.F3(DQ5/DQ29)
FBA_D<30>: U7000.AA45(FBA_D30) U7600.G4(DQ6/DQ30)
FBA_D<31>: U7000.Y44(FBA_D31) U7600.G3(DQ7/DQ31)
FBA_D<32>: U7000.AW51(FBA_D32) U7601.B4(DQ0/DQ24)
FBA_D<33>: U7000.BA52(FBA_D33) U7601.B3(DQ1/DQ25)
FBA_D<34>: U7000.AW50(FBA_D34) U7601.C4(DQ2/DQ26)
FBA_D<35>: U7000.BA51(FBA_D35) U7601.C3(DQ3/DQ27)
FBA_D<36>: U7000.BA50(FBA_D36) U7601.F4(DQ4/DQ28)
FBA_D<37>: U7000.BB50(FBA_D37) U7601.F3(DQ5/DQ29)
FBA_D<38>: U7000.BA49(FBA_D38) U7601.G4(DQ6/DQ30)
FBA_D<39>: U7000.AW49(FBA_D39) U7601.G3(DQ7/DQ31)
FBA_D<40>: U7000.AV48(FBA_D40) U7601.B11(DQ8/DQ16)
FBA_D<41>: U7000.AT49(FBA_D41) U7601.B12(DQ9/DQ17)
FBA_D<42>: U7000.AT47(FBA_D42) U7601.C11(DQ10/DQ18)
FBA_D<43>: U7000.AT48(FBA_D43) U7601.C12(DQ11/DQ19)
FBA_D<44>: U7000.AT46(FBA_D44) U7601.F11(DQ12/DQ20)
FBA_D<45>: U7000.AV51(FBA_D45) U7601.F12(DQ13/DQ21)
FBA_D<46>: U7000.AV52(FBA_D46) U7601.G11(DQ14/DQ22)
FBA_D<47>: U7000.AV49(FBA_D47) U7601.G12(DQ15/DQ23)
FBA_D<48>: U7000.AJ48(FBA_D48) U7601.V11(DQ16/DQ8)
FBA_D<49>: U7000.AJ46(FBA_D49) U7601.V12(DQ17/DQ9)
FBA_D<50>: U7000.AJ47(FBA_D50) U7601.U11(DQ18/DQ10)
FBA_D<51>: U7000.AK49(FBA_D51) U7601.U12(DQ19/DQ11)
FBA_D<52>: U7000.AM47(FBA_D52) U7601.P11(DQ20/DQ12)
FBA_D<53>: U7000.AM46(FBA_D53) U7601.P12(DQ21/DQ13)
FBA_D<54>: U7000.AN48(FBA_D54) U7601.N11(DQ22/DQ14)
FBA_D<55>: U7000.AN49(FBA_D55) U7601.N12(DQ23/DQ15)
FBA_D<56>: U7000.AM44(FBA_D56) U7601.V4(DQ24/DQ0)
FBA_D<57>: U7000.AM45(FBA_D57) U7601.V3(DQ25/DQ1)
FBA_D<58>: U7000.AN45(FBA_D58) U7601.U4(DQ26/DQ2)
FBA_D<59>: U7000.AN46(FBA_D59) U7601.U3(DQ27/DQ3)
FBA_D<60>: U7000.AR48(FBA_D60) U7601.P4(DQ28/DQ4)
FBA_D<61>: U7000.AN47(FBA_D61) U7601.P3(DQ29/DQ5)
FBA_D<62>: U7000.AR47(FBA_D62) U7601.N4(DQ30/DQ6)
FBA_D<63>: U7000.AR46(FBA_D63) U7601.N3(DQ31/DQ7)
FBA_DBI<0>: U7000.U47(FBA_DQM0) U7600.R3(DBI3_N/DBI0_N)
FBA_DBI<1>: U7000.Y48(FBA_DQM1) U7600.R12(DBI2_N/DBI1_N)
FBA_DBI<2>: U7000.AG47(FBA_DQM2) U7600.E12(DBI1_N/DBI2_N)
FBA_DBI<3>: U7000.AC48(FBA_DQM3) U7600.E3(DBI0_N/DBI3_N)
FBA_DBI<4>: U7000.BB51(FBA_DQM4) U7601.E3(DBI0_N/DBI3_N)
FBA_DBI<5>: U7000.AV50(FBA_DQM5) U7601.E12(DBI1_N/DBI2_N)
FBA_DBI<6>: U7000.AM48(FBA_DQM6) U7601.R12(DBI2_N/DBI1_N)
FBA_DBI<7>: U7000.AR49(FBA_DQM7) U7601.R3(DBI3_N/DBI0_N)
FBA_EDC<0>: U7000.R48(FBA_DQS_WP0) U7600.T3(EDC3/EDC0)
FBA_EDC<1>: U7000.V48(FBA_DQS_WP1) U7600.T12(EDC2/EDC1)
FBA_EDC<2>: U7000.AF44(FBA_DQS_WP2) U7600.D12(EDC1/EDC2)
FBA_EDC<3>: U7000.AA48(FBA_DQS_WP3) U7600.D3(EDC0/EDC3)
FBA_EDC<4>: U7000.BB52(FBA_DQS_WP4) U7601.D3(EDC0/EDC3)
FBA_EDC<5>: U7000.AT50(FBA_DQS_WP5) U7601.D12(EDC1/EDC2)
FBA_EDC<6>: U7000.AK48(FBA_DQS_WP6) U7601.T12(EDC2/EDC1)
FBA_EDC<7>: U7000.AR51(FBA_DQS_WP7) U7601.T3(EDC3/EDC0)
FBA_VREFC: C7603.1 C7604.1 R7609.2 R7610.1 R7611.2 U7600.K13(VREFC) U7601.K13(VREFC)
FBA_VREFC_Q: Q7600.3(DRAIN) R7609.1
FBA_WCK01: U7000.U45(FBA_WCK01) U7600.T4(WCK23_T/WCK01_T)
FBA_WCK01*: U7000.U44(FBA_WCK01_N) U7600.T5(WCK23_C/WCK01_C)
FBA_WCK23: U7000.AC45(FBA_WCK23) U7600.D4(WCK01_T/WCK23_T)
FBA_WCK23*: U7000.AC44(FBA_WCK23_N) U7600.D5(WCK01_C/WCK23_C)
FBA_WCK45: U7000.AV47(FBA_WCK45) U7601.D4(WCK01_T/WCK23_T)
FBA_WCK45*: U7000.AV46(FBA_WCK45_N) U7601.D5(WCK01_C/WCK23_C)
FBA_WCK67: U7000.AR45(FBA_WCK67) U7601.T4(WCK23_T/WCK01_T)
FBA_WCK67*: U7000.AR44(FBA_WCK67_N) U7601.T5(WCK23_C/WCK01_C)
FBA_ZQ_1_B: R7612.2 U7600.H13(ZQ)
FBA_ZQ_2_B: R7613.2 U7601.H13(ZQ)
FBB_CLK0: U7000.H42(FBB_CLK0) U7700.K11(CK_T)
FBB_CLK0*: U7000.G42(FBB_CLK0_N) U7700.K10(CK_C)
FBB_CLK1: U7000.F47(FBB_CLK1) U7701.K11(CK_T)
FBB_CLK1*: U7000.E47(FBB_CLK1_N) U7701.K10(CK_C)
FBB_CMD<0>: U7000.B35(FBB_CMD0) U7700.H4(RAS_N/CAS_N)
FBB_CMD<1>: R7115.1 U7000.A35(FBB_CMD1) U7700.K2(RESET_N)
FBB_CMD<2>: U7000.D35(FBB_CMD2) U7700.M4(CAS_N/RAS_N)
FBB_CMD<3>: U7000.A36(FBB_CMD3) U7700.L5(A11_A6/A9_A1)
FBB_CMD<4>: U7000.B36(FBB_CMD4) U7700.L4(A8_A7/A10_A0)
FBB_CMD<5>: U7000.C36(FBB_CMD5) U7700.K5(A12_A13)
FBB_CMD<6>: U7000.C38(FBB_CMD6) U7700.K4(ABI_N)
FBB_CMD<7>: U7000.B38(FBB_CMD7) U7700.J5(A9_A1/A11_A6)
FBB_CMD<8>: U7000.A38(FBB_CMD8) U7700.J4(A10_A0/A8_A7)
FBB_CMD<9>: U7000.D38(FBB_CMD9) U7700.J11(BA0_A2/BA2_A4)
FBB_CMD<10>: U7000.A39(FBB_CMD10) U7700.J10(BA3_A3/BA1_A5)
FBB_CMD<11>: U7000.B39(FBB_CMD11) U7700.L10(BA1_A5/BA3_A3)
FBB_CMD<12>: U7000.C39(FBB_CMD12) U7700.L11(BA2_A4/BA0_A2)
FBB_CMD<13>: R7102.1 U7000.C41(FBB_CMD13) U7700.M11(WE_N/CKE_N)
FBB_CMD<14>: U7000.B41(FBB_CMD14) U7700.K12(A14_A15)
FBB_CMD<15>: U7000.A41(FBB_CMD15) U7700.H11(CKE_N/WE_N)
FBB_CMD<16>: U7000.B49(FBB_CMD16) U7701.M4(CAS_N/RAS_N)
FBB_CMD<17>: R7114.1 U7000.A49(FBB_CMD17) U7701.K2(RESET_N)
FBB_CMD<18>: U7000.A48(FBB_CMD18) U7701.H4(RAS_N/CAS_N)
FBB_CMD<19>: U7000.D47(FBB_CMD19) U7701.J5(A9_A1/A11_A6)
FBB_CMD<20>: U7000.A47(FBB_CMD20) U7701.J4(A10_A0/A8_A7)
FBB_CMD<21>: U7000.B47(FBB_CMD21) U7701.K5(A12_A13)
FBB_CMD<22>: U7000.C47(FBB_CMD22) U7701.K4(ABI_N)
FBB_CMD<23>: U7000.C45(FBB_CMD23) U7701.L5(A11_A6/A9_A1)
FBB_CMD<24>: U7000.B45(FBB_CMD24) U7701.L4(A8_A7/A10_A0)
FBB_CMD<25>: U7000.A45(FBB_CMD25) U7701.L11(BA2_A4/BA0_A2)
FBB_CMD<26>: U7000.D44(FBB_CMD26) U7701.L10(BA1_A5/BA3_A3)
FBB_CMD<27>: U7000.A44(FBB_CMD27) U7701.J10(BA3_A3/BA1_A5)
FBB_CMD<28>: U7000.B44(FBB_CMD28) U7701.J11(BA0_A2/BA2_A4)
FBB_CMD<29>: R7103.1 U7000.C44(FBB_CMD29) U7701.H11(CKE_N/WE_N)
FBB_CMD<30>: U7000.C42(FBB_CMD30) U7701.K12(A14_A15)
FBB_CMD<31>: U7000.B42(FBB_CMD31) U7701.M11(WE_N/CKE_N)
FBB_D<0>: U7000.H32(FBB_D0) U7700.V4(DQ24/DQ0)
FBB_D<1>: U7000.D32(FBB_D1) U7700.V3(DQ25/DQ1)
FBB_D<2>: U7000.A33(FBB_D2) U7700.U4(DQ26/DQ2)
FBB_D<3>: U7000.B32(FBB_D3) U7700.U3(DQ27/DQ3)
FBB_D<4>: U7000.E32(FBB_D4) U7700.P4(DQ28/DQ4)
FBB_D<5>: U7000.G32(FBB_D5) U7700.P3(DQ29/DQ5)
FBB_D<6>: U7000.J30(FBB_D6) U7700.N4(DQ30/DQ6)
FBB_D<7>: U7000.F32(FBB_D7) U7700.N3(DQ31/DQ7)
FBB_D<8>: U7000.H36(FBB_D8) U7700.V11(DQ16/DQ8)
FBB_D<9>: U7000.G36(FBB_D9) U7700.V12(DQ17/DQ9)
FBB_D<10>: U7000.J36(FBB_D10) U7700.U11(DQ18/DQ10)
FBB_D<11>: U7000.F36(FBB_D11) U7700.U12(DQ19/DQ11)
FBB_D<12>: U7000.F33(FBB_D12) U7700.P11(DQ20/DQ12)
FBB_D<13>: U7000.D33(FBB_D13) U7700.P12(DQ21/DQ13)
FBB_D<14>: U7000.J32(FBB_D14) U7700.N11(DQ22/DQ14)
FBB_D<15>: U7000.G33(FBB_D15) U7700.N12(DQ23/DQ15)
FBB_D<16>: U7000.E45(FBB_D16) U7700.B11(DQ8/DQ16)
FBB_D<17>: U7000.D45(FBB_D17) U7700.B12(DQ9/DQ17)
FBB_D<18>: U7000.F45(FBB_D18) U7700.C11(DQ10/DQ18)
FBB_D<19>: U7000.G45(FBB_D19) U7700.C12(DQ11/DQ19)
FBB_D<20>: U7000.D42(FBB_D20) U7700.F11(DQ12/DQ20)
FBB_D<21>: U7000.E42(FBB_D21) U7700.F12(DQ13/DQ21)
FBB_D<22>: U7000.F42(FBB_D22) U7700.G11(DQ14/DQ22)
FBB_D<23>: U7000.H41(FBB_D23) U7700.G12(DQ15/DQ23)
FBB_D<24>: U7000.E41(FBB_D24) U7700.B4(DQ0/DQ24)
FBB_D<25>: U7000.F39(FBB_D25) U7700.B3(DQ1/DQ25)
FBB_D<26>: U7000.E39(FBB_D26) U7700.C4(DQ2/DQ26)
FBB_D<27>: U7000.D39(FBB_D27) U7700.C3(DQ3/DQ27)
FBB_D<28>: U7000.F38(FBB_D28) U7700.F4(DQ4/DQ28)
FBB_D<29>: U7000.E38(FBB_D29) U7700.F3(DQ5/DQ29)
FBB_D<30>: U7000.D36(FBB_D30) U7700.G4(DQ6/DQ30)
FBB_D<31>: U7000.E36(FBB_D31) U7700.G3(DQ7/DQ31)
FBB_D<32>: U7000.M50(FBB_D32) U7701.B4(DQ0/DQ24)
FBB_D<33>: U7000.P48(FBB_D33) U7701.B3(DQ1/DQ25)
FBB_D<34>: U7000.M51(FBB_D34) U7701.C4(DQ2/DQ26)
FBB_D<35>: U7000.M49(FBB_D35) U7701.C3(DQ3/DQ27)
FBB_D<36>: U7000.P47(FBB_D36) U7701.F4(DQ4/DQ28)
FBB_D<37>: U7000.P52(FBB_D37) U7701.F3(DQ5/DQ29)
FBB_D<38>: U7000.R46(FBB_D38) U7701.G4(DQ6/DQ30)
FBB_D<39>: U7000.P46(FBB_D39) U7701.G3(DQ7/DQ31)
FBB_D<40>: U7000.L50(FBB_D40) U7701.B11(DQ8/DQ16)
FBB_D<41>: U7000.L51(FBB_D41) U7701.B12(DQ9/DQ17)
FBB_D<42>: U7000.L52(FBB_D42) U7701.C11(DQ10/DQ18)
FBB_D<43>: U7000.L49(FBB_D43) U7701.C12(DQ11/DQ19)
FBB_D<44>: U7000.M46(FBB_D44) U7701.F11(DQ12/DQ20)
FBB_D<45>: U7000.L47(FBB_D45) U7701.F12(DQ13/DQ21)
FBB_D<46>: U7000.M48(FBB_D46) U7701.G11(DQ14/DQ22)
FBB_D<47>: U7000.M47(FBB_D47) U7701.G12(DQ15/DQ23)
FBB_D<48>: U7000.D48(FBB_D48) U7701.V11(DQ16/DQ8)
FBB_D<49>: U7000.C50(FBB_D49) U7701.V12(DQ17/DQ9)
FBB_D<50>: U7000.C48(FBB_D50) U7701.U11(DQ18/DQ10)
FBB_D<51>: U7000.C49(FBB_D51) U7701.U12(DQ19/DQ11)
FBB_D<52>: U7000.E49(FBB_D52) U7701.P11(DQ20/DQ12)
FBB_D<53>: U7000.E50(FBB_D53) U7701.P12(DQ21/DQ13)
FBB_D<54>: U7000.F49(FBB_D54) U7701.N11(DQ22/DQ14)
FBB_D<55>: U7000.F48(FBB_D55) U7701.N12(DQ23/DQ15)
FBB_D<56>: U7000.F50(FBB_D56) U7701.V4(DQ24/DQ0)
FBB_D<57>: U7000.D52(FBB_D57) U7701.V3(DQ25/DQ1)
FBB_D<58>: U7000.J50(FBB_D58) U7701.U4(DQ26/DQ2)
FBB_D<59>: U7000.H48(FBB_D59) U7701.U3(DQ27/DQ3)
FBB_D<60>: U7000.H51(FBB_D60) U7701.P4(DQ28/DQ4)
FBB_D<61>: U7000.J51(FBB_D61) U7701.P3(DQ29/DQ5)
FBB_D<62>: U7000.H49(FBB_D62) U7701.N4(DQ30/DQ6)
FBB_D<63>: U7000.H52(FBB_D63) U7701.N3(DQ31/DQ7)
FBB_DBI<0>: U7000.C32(FBB_DQM0) U7700.R3(DBI3_N/DBI0_N)
FBB_DBI<1>: U7000.E33(FBB_DQM1) U7700.R12(DBI2_N/DBI1_N)
FBB_DBI<2>: U7000.E44(FBB_DQM2) U7700.E12(DBI1_N/DBI2_N)
FBB_DBI<3>: U7000.G39(FBB_DQM3) U7700.E3(DBI0_N/DBI3_N)
FBB_DBI<4>: U7000.P49(FBB_DQM4) U7701.E3(DBI0_N/DBI3_N)
FBB_DBI<5>: U7000.L48(FBB_DQM5) U7701.E12(DBI1_N/DBI2_N)
FBB_DBI<6>: U7000.D50(FBB_DQM6) U7701.R12(DBI2_N/DBI1_N)
FBB_DBI<7>: U7000.H50(FBB_DQM7) U7701.R3(DBI3_N/DBI0_N)
FBB_EDC<0>: U7000.B33(FBB_DQS_WP0) U7700.T3(EDC3/EDC0)
FBB_EDC<1>: U7000.E35(FBB_DQS_WP1) U7700.T12(EDC2/EDC1)
FBB_EDC<2>: U7000.G44(FBB_DQS_WP2) U7700.D12(EDC1/EDC2)
FBB_EDC<3>: U7000.H38(FBB_DQS_WP3) U7700.D3(EDC0/EDC3)
FBB_EDC<4>: U7000.P50(FBB_DQS_WP4) U7701.D3(EDC0/EDC3)
FBB_EDC<5>: U7000.J48(FBB_DQS_WP5) U7701.D12(EDC1/EDC2)
FBB_EDC<6>: U7000.D51(FBB_DQS_WP6) U7701.T12(EDC2/EDC1)
FBB_EDC<7>: U7000.F51(FBB_DQS_WP7) U7701.T3(EDC3/EDC0)
FBB_VREFC: C7703.1 C7704.1 R7709.2 R7710.1 R7711.2 U7700.K13(VREFC) U7701.K13(VREFC)
FBB_VREFC_Q: Q7700.3(DRAIN) R7709.1
FBB_WCK01: U7000.J33(FBB_WCK01) U7700.T4(WCK23_T/WCK01_T)
FBB_WCK01*: U7000.H33(FBB_WCK01_N) U7700.T5(WCK23_C/WCK01_C)
FBB_WCK23: U7000.J39(FBB_WCK23) U7700.D4(WCK01_T/WCK23_T)
FBB_WCK23*: U7000.H39(FBB_WCK23_N) U7700.D5(WCK01_C/WCK23_C)
FBB_WCK45: U7000.L46(FBB_WCK45) U7701.D4(WCK01_T/WCK23_T)
FBB_WCK45*: U7000.L45(FBB_WCK45_N) U7701.D5(WCK01_C/WCK23_C)
FBB_WCK67: U7000.H47(FBB_WCK67) U7701.T4(WCK23_T/WCK01_T)
FBB_WCK67*: U7000.H46(FBB_WCK67_N) U7701.T5(WCK23_C/WCK01_C)
FBB_ZQ_1_B: R7712.2 U7700.H13(ZQ)
FBB_ZQ_2_B: R7713.2 U7701.H13(ZQ)
FBC_CLK0: U7000.G15(FBC_CLK0) U7800.K11(CK_T)
FBC_CLK0*: U7000.F15(FBC_CLK0_N) U7800.K10(CK_C)
FBC_CLK1: U7000.H21(FBC_CLK1) U7801.K11(CK_T)
FBC_CLK1*: U7000.J21(FBC_CLK1_N) U7801.K10(CK_C)
FBC_CMD<0>: U7000.C11(FBC_CMD0) U7800.H4(RAS_N/CAS_N)
FBC_CMD<1>: R7117.1 U7000.B11(FBC_CMD1) U7800.K2(RESET_N)
FBC_CMD<2>: U7000.A11(FBC_CMD2) U7800.M4(CAS_N/RAS_N)
FBC_CMD<3>: U7000.D11(FBC_CMD3) U7800.L5(A11_A6/A9_A1)
FBC_CMD<4>: U7000.A12(FBC_CMD4) U7800.L4(A8_A7/A10_A0)
FBC_CMD<5>: U7000.B12(FBC_CMD5) U7800.K5(A12_A13)
FBC_CMD<6>: U7000.C12(FBC_CMD6) U7800.K4(ABI_N)
FBC_CMD<7>: U7000.C14(FBC_CMD7) U7800.J5(A9_A1/A11_A6)
FBC_CMD<8>: U7000.B14(FBC_CMD8) U7800.J4(A10_A0/A8_A7)
FBC_CMD<9>: U7000.A14(FBC_CMD9) U7800.J11(BA0_A2/BA2_A4)
FBC_CMD<10>: U7000.D14(FBC_CMD10) U7800.J10(BA3_A3/BA1_A5)
FBC_CMD<11>: U7000.A15(FBC_CMD11) U7800.L10(BA1_A5/BA3_A3)
FBC_CMD<12>: U7000.B15(FBC_CMD12) U7800.L11(BA2_A4/BA0_A2)
FBC_CMD<13>: R7104.1 U7000.C15(FBC_CMD13) U7800.M11(WE_N/CKE_N)
FBC_CMD<14>: U7000.C17(FBC_CMD14) U7800.K12(A14_A15)
FBC_CMD<15>: U7000.B17(FBC_CMD15) U7800.H11(CKE_N/WE_N)
FBC_CMD<16>: U7000.B24(FBC_CMD16) U7801.M4(CAS_N/RAS_N)
FBC_CMD<17>: R7116.1 U7000.A24(FBC_CMD17) U7801.K2(RESET_N)
FBC_CMD<18>: U7000.D23(FBC_CMD18) U7801.H4(RAS_N/CAS_N)
FBC_CMD<19>: U7000.A23(FBC_CMD19) U7801.J5(A9_A1/A11_A6)
FBC_CMD<20>: U7000.B23(FBC_CMD20) U7801.J4(A10_A0/A8_A7)
FBC_CMD<21>: U7000.C23(FBC_CMD21) U7801.K5(A12_A13)
FBC_CMD<22>: U7000.C21(FBC_CMD22) U7801.K4(ABI_N)
FBC_CMD<23>: U7000.B21(FBC_CMD23) U7801.L5(A11_A6/A9_A1)
FBC_CMD<24>: U7000.A21(FBC_CMD24) U7801.L4(A8_A7/A10_A0)
FBC_CMD<25>: U7000.D20(FBC_CMD25) U7801.L11(BA2_A4/BA0_A2)
FBC_CMD<26>: U7000.A20(FBC_CMD26) U7801.L10(BA1_A5/BA3_A3)
FBC_CMD<27>: U7000.B20(FBC_CMD27) U7801.J10(BA3_A3/BA1_A5)
FBC_CMD<28>: U7000.C20(FBC_CMD28) U7801.J11(BA0_A2/BA2_A4)
FBC_CMD<29>: R7105.1 U7000.C18(FBC_CMD29) U7801.H11(CKE_N/WE_N)
FBC_CMD<30>: U7000.B18(FBC_CMD30) U7801.K12(A14_A15)
FBC_CMD<31>: U7000.A18(FBC_CMD31) U7801.M11(WE_N/CKE_N)
FBC_D<0>: U7000.C6(FBC_D0) U7800.V4(DQ24/DQ0)
FBC_D<1>: U7000.D6(FBC_D1) U7800.V3(DQ25/DQ1)
FBC_D<2>: U7000.A6(FBC_D2) U7800.U4(DQ26/DQ2)
FBC_D<3>: U7000.B6(FBC_D3) U7800.U3(DQ27/DQ3)
FBC_D<4>: U7000.B4(FBC_D4) U7800.P4(DQ28/DQ4)
FBC_D<5>: U7000.A4(FBC_D5) U7800.P3(DQ29/DQ5)
FBC_D<6>: U7000.B3(FBC_D6) U7800.N4(DQ30/DQ6)
FBC_D<7>: U7000.C4(FBC_D7) U7800.N3(DQ31/DQ7)
FBC_D<8>: U7000.D9(FBC_D8) U7800.V11(DQ16/DQ8)
FBC_D<9>: U7000.C9(FBC_D9) U7800.V12(DQ17/DQ9)
FBC_D<10>: U7000.E9(FBC_D10) U7800.U11(DQ18/DQ10)
FBC_D<11>: U7000.B9(FBC_D11) U7800.U12(DQ19/DQ11)
FBC_D<12>: U7000.B8(FBC_D12) U7800.P11(DQ20/DQ12)
FBC_D<13>: U7000.A8(FBC_D13) U7800.P12(DQ21/DQ13)
FBC_D<14>: U7000.F6(FBC_D14) U7800.N11(DQ22/DQ14)
FBC_D<15>: U7000.E6(FBC_D15) U7800.N12(DQ23/DQ15)
FBC_D<16>: U7000.F18(FBC_D16) U7800.B11(DQ8/DQ16)
FBC_D<17>: U7000.G18(FBC_D17) U7800.B12(DQ9/DQ17)
FBC_D<18>: U7000.E18(FBC_D18) U7800.C11(DQ10/DQ18)
FBC_D<19>: U7000.H18(FBC_D19) U7800.C12(DQ11/DQ19)
FBC_D<20>: U7000.D15(FBC_D20) U7800.F11(DQ12/DQ20)
FBC_D<21>: U7000.E15(FBC_D21) U7800.F12(DQ13/DQ21)
FBC_D<22>: U7000.G17(FBC_D22) U7800.G11(DQ14/DQ22)
FBC_D<23>: U7000.H17(FBC_D23) U7800.G12(DQ15/DQ23)
FBC_D<24>: U7000.J15(FBC_D24) U7800.B4(DQ0/DQ24)
FBC_D<25>: U7000.H15(FBC_D25) U7800.B3(DQ1/DQ25)
FBC_D<26>: U7000.E14(FBC_D26) U7800.C4(DQ2/DQ26)
FBC_D<27>: U7000.F14(FBC_D27) U7800.C3(DQ3/DQ27)
FBC_D<28>: U7000.H11(FBC_D28) U7800.F4(DQ4/DQ28)
FBC_D<29>: U7000.G11(FBC_D29) U7800.F3(DQ5/DQ29)
FBC_D<30>: U7000.F11(FBC_D30) U7800.G4(DQ6/DQ30)
FBC_D<31>: U7000.E11(FBC_D31) U7800.G3(DQ7/DQ31)
FBC_D<32>: U7000.J29(FBC_D32) U7801.B4(DQ0/DQ24)
FBC_D<33>: U7000.F30(FBC_D33) U7801.B3(DQ1/DQ25)
FBC_D<34>: U7000.H29(FBC_D34) U7801.C4(DQ2/DQ26)
FBC_D<35>: U7000.G30(FBC_D35) U7801.C3(DQ3/DQ27)
FBC_D<36>: U7000.B30(FBC_D36) U7801.F4(DQ4/DQ28)
FBC_D<37>: U7000.A30(FBC_D37) U7801.F3(DQ5/DQ29)
FBC_D<38>: U7000.H30(FBC_D38) U7801.G4(DQ6/DQ30)
FBC_D<39>: U7000.C30(FBC_D39) U7801.G3(DQ7/DQ31)
FBC_D<40>: U7000.D27(FBC_D40) U7801.B11(DQ8/DQ16)
FBC_D<41>: U7000.J26(FBC_D41) U7801.B12(DQ9/DQ17)
FBC_D<42>: U7000.F27(FBC_D42) U7801.C11(DQ10/DQ18)
FBC_D<43>: U7000.G27(FBC_D43) U7801.C12(DQ11/DQ19)
FBC_D<44>: U7000.C27(FBC_D44) U7801.F11(DQ12/DQ20)
FBC_D<45>: U7000.B27(FBC_D45) U7801.F12(DQ13/DQ21)
FBC_D<46>: U7000.A27(FBC_D46) U7801.G11(DQ14/DQ22)
FBC_D<47>: U7000.G29(FBC_D47) U7801.G12(DQ15/DQ23)
FBC_D<48>: U7000.H20(FBC_D48) U7801.V11(DQ16/DQ8)
FBC_D<49>: U7000.D18(FBC_D49) U7801.V12(DQ17/DQ9)
FBC_D<50>: U7000.G20(FBC_D50) U7801.U11(DQ18/DQ10)
FBC_D<51>: U7000.E20(FBC_D51) U7801.U12(DQ19/DQ11)
FBC_D<52>: U7000.F23(FBC_D52) U7801.P11(DQ20/DQ12)
FBC_D<53>: U7000.E21(FBC_D53) U7801.P12(DQ21/DQ13)
FBC_D<54>: U7000.D21(FBC_D54) U7801.N11(DQ22/DQ14)
FBC_D<55>: U7000.E23(FBC_D55) U7801.N12(DQ23/DQ15)
FBC_D<56>: U7000.G24(FBC_D56) U7801.V4(DQ24/DQ0)
FBC_D<57>: U7000.H26(FBC_D57) U7801.V3(DQ25/DQ1)
FBC_D<58>: U7000.F24(FBC_D58) U7801.U4(DQ26/DQ2)
FBC_D<59>: U7000.G26(FBC_D59) U7801.U3(DQ27/DQ3)
FBC_D<60>: U7000.F26(FBC_D60) U7801.P4(DQ28/DQ4)
FBC_D<61>: U7000.D26(FBC_D61) U7801.P3(DQ29/DQ5)
FBC_D<62>: U7000.B26(FBC_D62) U7801.N4(DQ30/DQ6)
FBC_D<63>: U7000.C26(FBC_D63) U7801.N3(DQ31/DQ7)
FBC_DBI<0>: U7000.A5(FBC_DQM0) U7800.R3(DBI3_N/DBI0_N)
FBC_DBI<1>: U7000.C8(FBC_DQM1) U7800.R12(DBI2_N/DBI1_N)
FBC_DBI<2>: U7000.J18(FBC_DQM2) U7800.E12(DBI1_N/DBI2_N)
FBC_DBI<3>: U7000.F12(FBC_DQM3) U7800.E3(DBI0_N/DBI3_N)
FBC_DBI<4>: U7000.D29(FBC_DQM4) U7801.E3(DBI0_N/DBI3_N)
FBC_DBI<5>: U7000.E27(FBC_DQM5) U7801.E12(DBI1_N/DBI2_N)
FBC_DBI<6>: U7000.F20(FBC_DQM6) U7801.R12(DBI2_N/DBI1_N)
FBC_DBI<7>: U7000.E26(FBC_DQM7) U7801.R3(DBI3_N/DBI0_N)
FBC_EDC<0>: U7000.D5(FBC_DQS_WP0) U7800.T3(EDC3/EDC0)
FBC_EDC<1>: U7000.D8(FBC_DQS_WP1) U7800.T12(EDC2/EDC1)
FBC_EDC<2>: U7000.E17(FBC_DQS_WP2) U7800.D12(EDC1/EDC2)
FBC_EDC<3>: U7000.E12(FBC_DQS_WP3) U7800.D3(EDC0/EDC3)
FBC_EDC<4>: U7000.E30(FBC_DQS_WP4) U7801.D3(EDC0/EDC3)
FBC_EDC<5>: U7000.B29(FBC_DQS_WP5) U7801.D12(EDC1/EDC2)
FBC_EDC<6>: U7000.G21(FBC_DQS_WP6) U7801.T12(EDC2/EDC1)
FBC_EDC<7>: U7000.E24(FBC_DQS_WP7) U7801.T3(EDC3/EDC0)
FBC_VREFC: C7803.1 C7804.1 R7809.2 R7810.1 R7811.2 U7800.K13(VREFC) U7801.K13(VREFC)
FBC_VREFC_Q: Q7800.3(DRAIN) R7809.1
FBC_WCK01: U7000.F8(FBC_WCK01) U7800.T4(WCK23_T/WCK01_T)
FBC_WCK01*: U7000.G8(FBC_WCK01_N) U7800.T5(WCK23_C/WCK01_C)
FBC_WCK23: U7000.H12(FBC_WCK23) U7800.D4(WCK01_T/WCK23_T)
FBC_WCK23*: U7000.G12(FBC_WCK23_N) U7800.D5(WCK01_C/WCK23_C)
FBC_WCK45: U7000.J27(FBC_WCK45) U7801.D4(WCK01_T/WCK23_T)
FBC_WCK45*: U7000.H27(FBC_WCK45_N) U7801.D5(WCK01_C/WCK23_C)
FBC_WCK67: U7000.G23(FBC_WCK67) U7801.T4(WCK23_T/WCK01_T)
FBC_WCK67*: U7000.H23(FBC_WCK67_N) U7801.T5(WCK23_C/WCK01_C)
FBC_ZQ_1_B: R7812.2 U7800.H13(ZQ)
FBC_ZQ_2_B: R7813.2 U7801.H13(ZQ)
FBD_CLK0: U7000.Y8(FBD_CLK0) U7900.K11(CK_T)
FBD_CLK0*: U7000.Y7(FBD_CLK0_N) U7900.K10(CK_C)
FBD_CLK1: U7000.R8(FBD_CLK1) U7901.K11(CK_T)
FBD_CLK1*: U7000.R7(FBD_CLK1_N) U7901.K10(CK_C)
FBD_CMD<0>: U7000.AD2(FBD_CMD0) U7900.H4(RAS_N/CAS_N)
FBD_CMD<1>: R7119.1 U7000.AD1(FBD_CMD1) U7900.K2(RESET_N)
FBD_CMD<2>: U7000.AD4(FBD_CMD2) U7900.M4(CAS_N/RAS_N)
FBD_CMD<3>: U7000.AC1(FBD_CMD3) U7900.L5(A11_A6/A9_A1)
FBD_CMD<4>: U7000.AC2(FBD_CMD4) U7900.L4(A8_A7/A10_A0)
FBD_CMD<5>: U7000.AC3(FBD_CMD5) U7900.K5(A12_A13)
FBD_CMD<6>: U7000.AA3(FBD_CMD6) U7900.K4(ABI_N)
FBD_CMD<7>: U7000.AA2(FBD_CMD7) U7900.J5(A9_A1/A11_A6)
FBD_CMD<8>: U7000.AA1(FBD_CMD8) U7900.J4(A10_A0/A8_A7)
FBD_CMD<9>: U7000.AA4(FBD_CMD9) U7900.J11(BA0_A2/BA2_A4)
FBD_CMD<10>: U7000.Y1(FBD_CMD10) U7900.J10(BA3_A3/BA1_A5)
FBD_CMD<11>: U7000.Y2(FBD_CMD11) U7900.L10(BA1_A5/BA3_A3)
FBD_CMD<12>: U7000.Y3(FBD_CMD12) U7900.L11(BA2_A4/BA0_A2)
FBD_CMD<13>: R7106.1 U7000.V3(FBD_CMD13) U7900.M11(WE_N/CKE_N)
FBD_CMD<14>: U7000.V2(FBD_CMD14) U7900.K12(A14_A15)
FBD_CMD<15>: U7000.V1(FBD_CMD15) U7900.H11(CKE_N/WE_N)
FBD_CMD<16>: U7000.L3(FBD_CMD16) U7901.M4(CAS_N/RAS_N)
FBD_CMD<17>: R7118.1 U7000.L2(FBD_CMD17) U7901.K2(RESET_N)
FBD_CMD<18>: U7000.L1(FBD_CMD18) U7901.H4(RAS_N/CAS_N)
FBD_CMD<19>: U7000.M4(FBD_CMD19) U7901.J5(A9_A1/A11_A6)
FBD_CMD<20>: U7000.M1(FBD_CMD20) U7901.J4(A10_A0/A8_A7)
FBD_CMD<21>: U7000.M2(FBD_CMD21) U7901.K5(A12_A13)
FBD_CMD<22>: U7000.M3(FBD_CMD22) U7901.K4(ABI_N)
FBD_CMD<23>: U7000.P3(FBD_CMD23) U7901.L5(A11_A6/A9_A1)
FBD_CMD<24>: U7000.P2(FBD_CMD24) U7901.L4(A8_A7/A10_A0)
FBD_CMD<25>: U7000.P1(FBD_CMD25) U7901.L11(BA2_A4/BA0_A2)
FBD_CMD<26>: U7000.R4(FBD_CMD26) U7901.L10(BA1_A5/BA3_A3)
FBD_CMD<27>: U7000.R1(FBD_CMD27) U7901.J10(BA3_A3/BA1_A5)
FBD_CMD<28>: U7000.R2(FBD_CMD28) U7901.J11(BA0_A2/BA2_A4)
FBD_CMD<29>: R7107.1 U7000.R3(FBD_CMD29) U7901.H11(CKE_N/WE_N)
FBD_CMD<30>: U7000.U3(FBD_CMD30) U7901.K12(A14_A15)
FBD_CMD<31>: U7000.U2(FBD_CMD31) U7901.M11(WE_N/CKE_N)
FBD_D<0>: U7000.AK8(FBD_D0) U7900.V4(DQ24/DQ0)
FBD_D<1>: U7000.AK4(FBD_D1) U7900.V3(DQ25/DQ1)
FBD_D<2>: U7000.AK2(FBD_D2) U7900.U4(DQ26/DQ2)
FBD_D<3>: U7000.AK3(FBD_D3) U7900.U3(DQ27/DQ3)
FBD_D<4>: U7000.AK5(FBD_D4) U7900.P4(DQ28/DQ4)
FBD_D<5>: U7000.AK6(FBD_D5) U7900.P3(DQ29/DQ5)
FBD_D<6>: U7000.AK9(FBD_D6) U7900.N4(DQ30/DQ6)
FBD_D<7>: U7000.AK7(FBD_D7) U7900.N3(DQ31/DQ7)
FBD_D<8>: U7000.AG4(FBD_D8) U7900.V11(DQ16/DQ8)
FBD_D<9>: U7000.AF9(FBD_D9) U7900.V12(DQ17/DQ9)
FBD_D<10>: U7000.AG6(FBD_D10) U7900.U11(DQ18/DQ10)
FBD_D<11>: U7000.AG7(FBD_D11) U7900.U12(DQ19/DQ11)
FBD_D<12>: U7000.AJ4(FBD_D12) U7900.P11(DQ20/DQ12)
FBD_D<13>: U7000.AJ5(FBD_D13) U7900.P12(DQ21/DQ13)
FBD_D<14>: U7000.AJ6(FBD_D14) U7900.N11(DQ22/DQ14)
FBD_D<15>: U7000.AG5(FBD_D15) U7900.N12(DQ23/DQ15)
FBD_D<16>: U7000.Y6(FBD_D16) U7900.B11(DQ8/DQ16)
FBD_D<17>: U7000.Y5(FBD_D17) U7900.B12(DQ9/DQ17)
FBD_D<18>: U7000.V5(FBD_D18) U7900.C11(DQ10/DQ18)
FBD_D<19>: U7000.Y4(FBD_D19) U7900.C12(DQ11/DQ19)
FBD_D<20>: U7000.AA6(FBD_D20) U7900.F11(DQ12/DQ20)
FBD_D<21>: U7000.AA5(FBD_D21) U7900.F12(DQ13/DQ21)
FBD_D<22>: U7000.AC5(FBD_D22) U7900.G11(DQ14/DQ22)
FBD_D<23>: U7000.AC4(FBD_D23) U7900.G12(DQ15/DQ23)
FBD_D<24>: U7000.AD7(FBD_D24) U7900.B4(DQ0/DQ24)
FBD_D<25>: U7000.AC6(FBD_D25) U7900.B3(DQ1/DQ25)
FBD_D<26>: U7000.AF6(FBD_D26) U7900.C4(DQ2/DQ26)
FBD_D<27>: U7000.AD6(FBD_D27) U7900.C3(DQ3/DQ27)
FBD_D<28>: U7000.AF7(FBD_D28) U7900.F4(DQ4/DQ28)
FBD_D<29>: U7000.AF8(FBD_D29) U7900.F3(DQ5/DQ29)
FBD_D<30>: U7000.AF2(FBD_D30) U7900.G4(DQ6/DQ30)
FBD_D<31>: U7000.AF3(FBD_D31) U7900.G3(DQ7/DQ31)
FBD_D<32>: U7000.F4(FBD_D32) U7901.B4(DQ0/DQ24)
FBD_D<33>: U7000.E1(FBD_D33) U7901.B3(DQ1/DQ25)
FBD_D<34>: U7000.F3(FBD_D34) U7901.C4(DQ2/DQ26)
FBD_D<35>: U7000.F5(FBD_D35) U7901.C3(DQ3/DQ27)
FBD_D<36>: U7000.D2(FBD_D36) U7901.F4(DQ4/DQ28)
FBD_D<37>: U7000.D1(FBD_D37) U7901.F3(DQ5/DQ29)
FBD_D<38>: U7000.C3(FBD_D38) U7901.G4(DQ6/DQ30)
FBD_D<39>: U7000.C2(FBD_D39) U7901.G3(DQ7/DQ31)
FBD_D<40>: U7000.J5(FBD_D40) U7901.B11(DQ8/DQ16)
FBD_D<41>: U7000.J4(FBD_D41) U7901.B12(DQ9/DQ17)
FBD_D<42>: U7000.L8(FBD_D42) U7901.C11(DQ10/DQ18)
FBD_D<43>: U7000.J2(FBD_D43) U7901.C12(DQ11/DQ19)
FBD_D<44>: U7000.F1(FBD_D44) U7901.F11(DQ12/DQ20)
FBD_D<45>: U7000.F2(FBD_D45) U7901.F12(DQ13/DQ21)
FBD_D<46>: U7000.H4(FBD_D46) U7901.G11(DQ14/DQ22)
FBD_D<47>: U7000.H5(FBD_D47) U7901.G12(DQ15/DQ23)
FBD_D<48>: U7000.V7(FBD_D48) U7901.V11(DQ16/DQ8)
FBD_D<49>: U7000.V8(FBD_D49) U7901.V12(DQ17/DQ9)
FBD_D<50>: U7000.V6(FBD_D50) U7901.U11(DQ18/DQ10)
FBD_D<51>: U7000.V9(FBD_D51) U7901.U12(DQ19/DQ11)
FBD_D<52>: U7000.U4(FBD_D52) U7901.P11(DQ20/DQ12)
FBD_D<53>: U7000.R5(FBD_D53) U7901.P12(DQ21/DQ13)
FBD_D<54>: U7000.R6(FBD_D54) U7901.N11(DQ22/DQ14)
FBD_D<55>: U7000.U8(FBD_D55) U7901.N12(DQ23/DQ15)
FBD_D<56>: U7000.P6(FBD_D56) U7901.V4(DQ24/DQ0)
FBD_D<57>: U7000.R9(FBD_D57) U7901.V3(DQ25/DQ1)
FBD_D<58>: U7000.P4(FBD_D58) U7901.U4(DQ26/DQ2)
FBD_D<59>: U7000.P5(FBD_D59) U7901.U3(DQ27/DQ3)
FBD_D<60>: U7000.L7(FBD_D60) U7901.P4(DQ28/DQ4)
FBD_D<61>: U7000.L6(FBD_D61) U7901.P3(DQ29/DQ5)
FBD_D<62>: U7000.L4(FBD_D62) U7901.N4(DQ30/DQ6)
FBD_D<63>: U7000.L5(FBD_D63) U7901.N3(DQ31/DQ7)
FBD_DBI<0>: U7000.AJ1(FBD_DQM0) U7900.R3(DBI3_N/DBI0_N)
FBD_DBI<1>: U7000.AG1(FBD_DQM1) U7900.R12(DBI2_N/DBI1_N)
FBD_DBI<2>: U7000.AA7(FBD_DQM2) U7900.E12(DBI1_N/DBI2_N)
FBD_DBI<3>: U7000.AD5(FBD_DQM3) U7900.E3(DBI0_N/DBI3_N)
FBD_DBI<4>: U7000.D3(FBD_DQM4) U7901.E3(DBI0_N/DBI3_N)
FBD_DBI<5>: U7000.H3(FBD_DQM5) U7901.E12(DBI1_N/DBI2_N)
FBD_DBI<6>: U7000.U5(FBD_DQM6) U7901.R12(DBI2_N/DBI1_N)
FBD_DBI<7>: U7000.M9(FBD_DQM7) U7901.R3(DBI3_N/DBI0_N)
FBD_EDC<0>: U7000.AJ3(FBD_DQS_WP0) U7900.T3(EDC3/EDC0)
FBD_EDC<1>: U7000.AG2(FBD_DQS_WP1) U7900.T12(EDC2/EDC1)
FBD_EDC<2>: U7000.AA9(FBD_DQS_WP2) U7900.D12(EDC1/EDC2)
FBD_EDC<3>: U7000.AF4(FBD_DQS_WP3) U7900.D3(EDC0/EDC3)
FBD_EDC<4>: U7000.E3(FBD_DQS_WP4) U7901.D3(EDC0/EDC3)
FBD_EDC<5>: U7000.H2(FBD_DQS_WP5) U7901.D12(EDC1/EDC2)
FBD_EDC<6>: U7000.U6(FBD_DQS_WP6) U7901.T12(EDC2/EDC1)
FBD_EDC<7>: U7000.M5(FBD_DQS_WP7) U7901.T3(EDC3/EDC0)
FBD_VREFC: C7903.1 C7904.1 R7909.2 R7910.1 R7911.2 U7900.K13(VREFC) U7901.K13(VREFC)
FBD_VREFC_Q: Q7900.3(DRAIN) R7909.1
FBD_WCK01: U7000.AJ8(FBD_WCK01) U7900.T4(WCK23_T/WCK01_T)
FBD_WCK01*: U7000.AJ7(FBD_WCK01_N) U7900.T5(WCK23_C/WCK01_C)
FBD_WCK23: U7000.AD8(FBD_WCK23) U7900.D4(WCK01_T/WCK23_T)
FBD_WCK23*: U7000.AD9(FBD_WCK23_N) U7900.D5(WCK01_C/WCK23_C)
FBD_WCK45: U7000.J6(FBD_WCK45) U7901.D4(WCK01_T/WCK23_T)
FBD_WCK45*: U7000.J7(FBD_WCK45_N) U7901.D5(WCK01_C/WCK23_C)
FBD_WCK67: U7000.P8(FBD_WCK67) U7901.T4(WCK23_T/WCK01_T)
FBD_WCK67*: U7000.P7(FBD_WCK67_N) U7901.T5(WCK23_C/WCK01_C)
FBD_ZQ_1_B: R7912.2 U7900.H13(ZQ)
FBD_ZQ_2_B: R7913.2 U7901.H13(ZQ)
FBVDDQ_GND_SENSE: R7513.2 SR7502.2 SR7504.2 SR8913.1 T8907.1
FBVDDQ_GND_SENSE_IC: C8907.1 SR8906.2 SR8912.2 SR8913.2 U8900.10(RGND)
FBVDDQ_SENSE: R7512.1 SR7501.2 SR7503.1 SR8914.1 T8908.1
FBVDDQ_SENSE_FBD: R7511.1 SR7503.2
FBVDDQ_SENSE_GPU: R7504.1 U7000.E52(FBVDDQ_SENSE)
FBVDDQ_SENSE_GPU_R: R7504.2 SR7501.1
FBVDDQ_SENSE_GPU_RTN_R: R7503.2 SR7504.1
FBVDDQ_SENSE_IC: C8907.2 R8909.1 SR8914.2 U8900.11(VSNS)
FBVDDQ_SENSE_RTN_FBD: R7502.1 SR7502.1
FCCM_A: U8000.24(FCCM_A) U8001.2(FCCM) U8002.2(FCCM) U8003.2(FCCM)
FCCM_B: U8000.11(FCCM_B) U8004.2(FCCM) U8006.2(FCCM)
FCCM_C: U8000.34(FCCM_C) U8005.7(FCCM)
FG0: R4623.1 U4601.37(FG0)
FG1: R4625.1 U4601.38(FG1/I2C_RESET#)
FORCE_OFF#: D5004.2(CATHODE2) JRST5001.1 Q5002.6(D) Q9200.6(D) R5014.1 T9206.1
FORCE_OFF_PWR: C9200.1 Q8106.2(G) Q8106.5(G) Q9200.2(G) Q9200.3(D) R9204.2 R9205.1
FP_RST_DBR_N_CPUXDP: C4402.1 SR4407.1 XDP4400.48
FRAMELOCK#: Q7406.3(DRAIN) SR7406.2
FRAMELOCK#_EDP: Q7406.2(SOURCE) R4517.1 R4595.1
G1: R3707.1 SR3702.2 U3700.11(G1)
G2: R3708.1 SR3703.2 U3700.12(G2)
GATE_SQ14: Q3101.2(G) Q3101.5(G) R3112.1 R3114.1
GC6_FB_EN: D7402.1(ANODE1) R7448.2 U7402.3(D)
GC6_FB_EN_R: R7442.2 U7402.5(G) U7402.6(D) U7412.2(B)
GC6_FB_GPU: R2357.2 U2000.AV43(GPP_C10/UART0_RTS#) U2302.6(D)
GEN1_I2C_SCL: R5803.2 U5800.12(SCX)
GEN1_I2C_SDA: R5804.2 U5800.2(SDX)
GPC_PLLVDD: C7211.1 L7201.2 SR7201.1 SR7203.1
GPD8_SUSCLK: R2401.2 R2458.1 T2411.1 U2000.AN15(GPD8/SUSCLK)
GPG2_EC: R3001.2 SR3018.1 U3002.100(SSCE0#/GPG2)
GPH7: R3026.1 R3027.2 R3031.2 U3002.3(GPH7)
GPIO0: R1227.1 U1201.B2(GPIO0)
GPIO0_NVVDD_PWM_GPU: SR7403.1 U7000.BD6(GPIO0)
GPIO1_GC6FBEN: R7436.2 U2302.5(G) U7000.BB5(GPIO1) U7402.2(G)
GPIO2: T1208.1 U1201.D10(GPIO2)
GPIO2_GPU_EVENT#: R7437.2 U7000.BD1(GPIO2) U7404.6(D)
GPIO3: T1207.1 U1201.G11(GPIO3)
GPIO3_NVVDDS_PWM_GPU: SR7405.1 U7000.BE4(GPIO3)
GPIO4_1V8MAINEN: R7419.2 U7000.BE1(GPIO4) U7410.2(G)
GPIO5_FL_INT_GPU: R7438.2 SR7406.1 U7000.BG2(GPIO5)
GPIO6: R1229.1 U1201.G10(GPIO6)
GPIO6_NVVDD_PSI#: R7439.2 SR7409.1 SR7418.1 U7000.BD2(GPIO6)
GPIO7: R1228.1 U1201.D7(GPIO7)
GPIO7_BL_PWM: CON4500.26 R4587.1 R4596.2 U7406.3(D)
GPIO7_BL_PWM_GPU: R7451.1 U7000.BD7(GPIO7) U7406.2(G)
GPIO9_ALERT#: R7414.2 SR7410.1 U7000.BJ3(GPIO9)
GPIO10_FBVREF_SEL: Q7600.1(GATE) Q7700.1(GATE) Q7800.1(GATE) Q7900.1(GATE) R7429.2 U7000.BD3(GPIO10)
GPIO11_PPEN_PWRBRK: R7454.1 U7000.BH3(GPIO11) U7407.2(G)
GPIO12_AC_BATT#: Q7405.3(DRAIN) SR7411.2 SR8810.2
GPIO12_AC_DETECT: R7423.2 SR7411.1 U7000.BE6(GPIO12)
GPIO13_BLEN_FAN_TACH: R7456.1 U7000.BB1(GPIO13) U7408.2(G)
GPIO17_IFPD_HPD: R7458.2 U7000.BD5(GPIO24) U7403.6(D)
GPIO18_IFPE_HPD: R7466.2 U7000.BE3(GPIO18) U7403.3(D)
GPIO19_STEREO_OUT_SRV_HEAD: T7402.1 U7000.BD4(GPIO19)
GPIO20_GC5_MODE_GPU: R7478.1 U7000.BE5(GPIO20)
GPIO23_GPU_PEX_RST_HOLD: SR7415.2 U7003.2(B)
GPIO23_PEXRSTHOLD_RASTERSYNC1: R7457.2 SR7415.1 U7000.BG3(GPIO23)
GPIO24_IFPF_HPD: R7477.2 U7000.BH1(GPIO17) U7405.6(D)
GPIO27_IFPC_HPD: R7475.2 U7000.BA4(GPIO27) U7405.3(D)
GPIO29_VRDUTY: R74102.1 U7000.BA3(GPIO29)
GPP_A6_SERIRQ: R2203.2 SR2207.2 U2000.BA17(GPP_A6/SERIRQ/ESPI_CS1#)
GPP_A14_SUS_STAT#_ESPI_RST#: SR2209.2 U2000.BC18(GPP_A14/SUS_STAT#/ESPI_RESET#)
GPP_D13: R2314.2 R2315.1 U2000.AK45(GPP_D13/ISH_UART0_RXD/SML0BDATA)
GPP_D14: R2316.2 R2317.1 U2000.AK44(GPP_D14/ISH_UART0_TXD/SML0BCLK/)
GPP_D15: R2318.2 R2319.1 U2000.AL43(GPP_D15/ISH_UART0_RTS#)
GPP_D16: R2320.2 R2321.1 U2000.AJ43(GPP_D16/ISH_UART0_CTS#)
GPP_H23: R2463.2 U2000.BD36(GPP_H23)
GPP_H_16_SML4CLK: R2466.2 U2000.BD39(GPP_H16/SML4CLK)
GPP_H_17_SML4DATA: R2469.2 U2000.BE34(GPP_H17/SML4DATA)
GPU_1V8_MAIN_EN: D7405.3(CATHODE) R7489.1 SR9105.1
GPU_ALERT#: R2371.2 U2000.AT44(GPP_C14/UART1_RTS#/ISH_UART1_RT) U7413.3(D)
GPU_BAT_THRO: Q7405.1(GATE) R2409.2 U2000.BC23(GPP_B3/CPU_GP2)
GPU_EVENT#: R2358.2 U2000.AU44(GPP_C11/UART0_CTS#) U7404.5(G)
GPU_ID0: R6113.2 R6114.1 U2000.U39(GPP_G10/FAN_PWM_2)
GPU_ID1: R6115.2 R6116.1 U2000.N42(GPP_G11/FAN_PWM_3)
GPU_IPC_SCL: SR7407.2 U9702.6(SCL)
GPU_IPC_SDA: SR7408.2 U9702.7(SDA)
GPU_OVERT#: R2364.2 SR7404.1 U2000.AR45(GPP_C20/UART2_RXD)
GPU_OVERT#_R: SR7404.2 U7413.6(D) U7417.6(D)
GPU_THERM_ALERT#: SR7410.2 U7413.4(S)
GSEN_INT_1: R5805.2 U5800.5(INT1)
GSEN_INT_2: R5807.2 R5811.2 U5800.6(INT2)
GSENSOR_INT1_PCH: R2246.2 R5805.1 U2000.R35(GPP_G20)
GSENSOR_INT2: R5131.2 R5807.1
GSPI1_MOSI: R2424.2 U2000.AT29(GPP_B22/GSPI1_MOSI)
H_BPM_N0: SR4404.2 U0300.BR27(BPM#[0])
H_BPM_N0_R: SR4404.1 XDP4400.21
H_BPM_N1: SR4405.2 U0300.BT27(BPM#[1])
H_BPM_N1_R: SR4405.1 XDP4400.23
H_CFG0: R0702.1 R4416.2 U0300.BN25(CFG[0]) XDP4400.9
H_CFG1: R0701.1 U0300.BN27(CFG[1]) XDP4400.11
H_CFG2: R0723.1 U0300.BN26(CFG[2]) XDP4400.15
H_CFG3: R0725.1 R4422.2 U0300.BN28(CFG[3]) XDP4400.17
H_CFG4: R0724.1 R0754.2 U0300.BR20(CFG[4]) XDP4400.27
H_CFG5: R0703.1 R0745.2 U0300.BM20(CFG[5]) XDP4400.29
H_CFG6: R0705.1 R0744.2 U0300.BT20(CFG[6]) XDP4400.33
H_CFG7: R0709.1 U0300.BP20(CFG[7]) XDP4400.35
H_CFG8: U0300.BR23(CFG[8]) XDP4400.10
H_CFG9: R0700.2 U0300.BR22(CFG[9]) XDP4400.12
H_CFG10: U0300.BT23(CFG[10]) XDP4400.16
H_CFG11: U0300.BT22(CFG[11]) XDP4400.18
H_CFG12: U0300.BM19(CFG[12]) XDP4400.28
H_CFG13: U0300.BR19(CFG[13]) XDP4400.30
H_CFG14: U0300.BP19(CFG[14]) XDP4400.34
H_CFG15: U0300.BT19(CFG[15]) XDP4400.36
H_CFG16: U0300.BP23(CFG[16]) XDP4400.6
H_CFG17: U0300.BN23(CFG[17]) XDP4400.4
H_CFG18: U0300.BN22(CFG[18]) XDP4400.24
H_CFG19: U0300.BP22(CFG[19]) XDP4400.22
H_PECI_EC: R0733.1 U3002.117(SMCLK2/PECI/GPF6)
H_PRDY#: R2325.2 U0300.BP27(PROC_PRDY#) XDP4400.5
H_PREQ#: R0738.2 R4403.1 U0300.BL30(PROC_PREQ#) XDP4400.3
H_TCK: R0741.1 SR2305.2 U0300.BR28(PROC_TCK) XDP4400.57
H_TDI: R4427.2 SR2304.2 U0300.BL32(PROC_TDI) XDP4400.56
H_TDO: R0739.2 SR2303.2 U0300.BT28(PROC_TDO) XDP4400.52
H_THMTRIP#: R2450.2 R2454.2 U0300.J31(THERMTRIP#)
H_TMS: R4428.2 SR2302.2 U0300.BP28(PROC_TMS) XDP4400.58
H_TRIGIN: R2326.2 U0300.H23(PROC_TRIGIN)
H_TRIGOUT: R0743.1 U2000.AK1(PCH_TRIGIN)
H_TRIGOUT_R: R0743.2 U0300.J23(PROC_TRIGOUT)
H_TRST#: R0740.1 SR2301.2 U0300.BP30(PROC_TRST#) XDP4400.54
HDA_AZRST#_L500MIL: R2306.2 U2000.BD8(HDA_RST#)
HDA_BCLK: C2301.1 R2301.1 SR3603.2
HDA_BCLK_R: C3629.1 SR3603.1 U3600.6(BCLK)
HDA_BITCLK_24MHZ_L500MIL: R2301.2 U2000.BA9(HDA_BCLK)
HDA_RST#: C2300.1 C3626.1 Q3601.5(G) R2306.1 U3600.11(RESETB)
HDA_SDI0: C2310.1 R3613.1 U2000.BE7(HDA_SDI0)
HDA_SDO: C2303.1 R2308.1 U3600.5(SDATA-OUT)
HDA_SDO_L500MIL: D2301.2(CATHODE) R2308.2 R2378.2 U2000.BB7(HDA_SDO)
HDA_SPKR_LN: SR3606.1 U3600.43(SPK-OUT-L-)
HDA_SPKR_LP: SR3607.1 U3600.42(SPK-OUT-L+)
HDA_SPKR_RN: SR3605.1 U3600.44(SPK-OUT-R-)
HDA_SPKR_RP: SR3604.1 U3600.45(SPK-OUT-R+)
HDA_SYNC: C2302.1 R2300.1 U3600.10(SYNC)
HDA_SYNC_L500MIL: R2300.2 U2000.BD9(HDA_SYNC)
HDMI_CTRCLK_C: C4809.1 CON4800.15 R1308.1 R4807.2 U1301.32(SCL_SNK)
HDMI_CTRLDATA_C: C4810.1 CON4800.16 R1309.1 R4806.2 U1301.33(SDA_SNK)
HDMI_HOTPLUG_DET: CON4800.19 R4801.2 U1301.28(HPD_SNK)
HDMI_OUT_5V_L1: D4800.1(CATHODE1) R4806.1
HDMI_OUT_5V_L2: D4800.2(CATHODE2) R4807.1
HDMI_OUT_CLK_N: C4811.2 CON4800.12 L4803.3 RN4803.1(X)
HDMI_OUT_CLK_P: C4811.1 CON4800.10 L4803.4 RN4803.3(X)
HDMI_OUT_DATA0_N: CON4800.9 L4800.3 RN4800.1(X)
HDMI_OUT_DATA0_P: CON4800.7 L4800.4 RN4800.3(X)
HDMI_OUT_DATA1_N: CON4800.6 L4801.3 RN4801.1(X)
HDMI_OUT_DATA1_P: CON4800.4 L4801.4 RN4801.3(X)
HDMI_OUT_DATA2_N: CON4800.3 L4802.3 RN4802.1(X)
HDMI_OUT_DATA2_P: CON4800.1 L4802.4 RN4802.3(X)
HDMI_SEL#_TEST_A1: R1326.2 R1327.1 U1301.23(HDMI_SEL#/A1)
HDMI_TMDSD_CLK_N: L4803.2 RN4803.2(Y) U1301.21(OUT_CLKN)
HDMI_TMDSD_CLK_P: L4803.1 RN4803.4(Y) U1301.22(OUT_CLKP)
HDMI_TMDSD_DATA0_N: L4800.2 RN4800.2(Y) U1301.24(OUT_D0N)
HDMI_TMDSD_DATA0_P: L4800.1 RN4800.4(Y) U1301.25(OUT_D0P)
HDMI_TMDSD_DATA1_N: L4801.2 RN4801.2(Y) U1301.26(OUT_D1N)
HDMI_TMDSD_DATA1_P: L4801.1 RN4801.4(Y) U1301.27(OUT_D1P)
HDMI_TMDSD_DATA2_N: L4802.2 RN4802.2(Y) U1301.29(OUT_D2N)
HDMI_TMDSD_DATA2_P: L4802.1 RN4802.4(Y) U1301.30(OUT_D2P)
HDMID_DDI2_AUXN: R1306.1 R1311.1 R1312.2 U1301.39(SDA_SRC)
HDMID_DDI2_AUXP: R1307.1 R1310.1 R1313.2 U1301.38(SCL_SRC)
HDMID_DDI2_DATA0_N: C1306.2 U1301.7(IN_D0N)
HDMID_DDI2_DATA0_P: C1311.2 U1301.6(IN_D0P)
HDMID_DDI2_DATA1_N: C1307.2 U1301.5(IN_D1N)
HDMID_DDI2_DATA1_P: C1312.2 U1301.4(IN_D1P)
HDMID_DDI2_DATA2_N: C1305.2 U1301.2(IN_D2N)
HDMID_DDI2_DATA2_P: C1309.2 U1301.1(IN_D2P)
HDMID_DDI2_DATA3_N: C1310.2 U1301.10(IN_CLKN)
HDMID_DDI2_DATA3_P: C1308.2 U1301.9(IN_CLKP)
HDMID_IFPE_AUXN: Q7205.3(DRAIN) R1306.2 R1309.2 R7227.2
HDMID_IFPE_AUXN_GPU: Q7205.2(SOURCE) R7225.2 R7227.1 U7000.BL8(IFPE_AUX_SDA_N)
HDMID_IFPE_AUXP: Q7204.3(DRAIN) R1307.2 R1308.2 R7228.2
HDMID_IFPE_AUXP_GPU: Q7204.2(SOURCE) R7226.2 R7228.1 U7000.BK8(IFPE_AUX_SCL)
HDMID_IFPE_DATA0_N: C1305.1 U7000.BG17(IFPE_L0_N)
HDMID_IFPE_DATA0_P: C1309.1 U7000.BH17(IFPE_L0)
HDMID_IFPE_DATA1_N: C1307.1 U7000.BF15(IFPE_L1_N)
HDMID_IFPE_DATA1_P: C1312.1 U7000.BG15(IFPE_L1)
HDMID_IFPE_DATA2_N: C1306.1 U7000.BF14(IFPE_L2_N)
HDMID_IFPE_DATA2_P: C1311.1 U7000.BE14(IFPE_L2)
HDMID_IFPE_DATA3_N: C1310.1 U7000.BG14(IFPE_L3_N)
HDMID_IFPE_DATA3_P: C1308.1 U7000.BH14(IFPE_L3)
HG_C: Q8002.4(G) U8005.1(UGATE)
HOOK3_SPI_MOSI_VRM_PWRGD: C4403.1 R4411.2 R4414.1 R4417.1 XDP4400.47
HOOK6_ITP_PMODE_PLTRST_CPU#: R4410.2 R4418.1 R4423.1 SR4406.1 XDP4400.46
HPD_DDPD_DP_R: R1142.1 U1101.AA2(DPSNK0_HPD) U1401.11(HPD_SNK)
HPD_IFPC_DP2: C7401.1 CON4601.18 L7404.2 R4605.2
HPD_IFPD_DP: C7407.1 L7401.2 U1401.9(HPD_SRC)
HPD_IFPE_HDMI: C7405.1 L7402.2 R1303.1
HPD_IFPE_HDMI_R: R1303.2 U1301.3(HPD_SRC)
HPD_IFPF_EDP: C4526.2 C7403.1 CON4500.20 L7403.2 R4501.2 R4505.2 T4505.1
HPOUT1_JD#: C6717.1 CON6700.17 D6703.1(ANODE) Q6701.1(GATE) R3623.2
HPOUT1_JD_EC: Q6701.3(DRAIN) R3005.2 U3002.126(GA20/GPB5)
HPOUT1_L: C6704.1 CON6700.18 U3600.32(HPOUT-L(PORT-I-L))
HPOUT1_R: C6705.1 CON6700.19 U3600.33(HPOUT-R(PORT-I-R))
I2C_EN_PIN: R1319.2 R1320.1 U1301.8(I2C_EN/PIN)
I2C_IRQ2Z: R1230.1 R3077.2 U1201.B6(I2C_IRQ2Z)
I2C_IRQ2Z_EC: R3077.1 R3079.1 U3002.83(EGCS#/GPE2)
I2C_SCL2: Q1202.3(DRAIN) R1231.1 SR3004.1 U1201.B5(I2C_SCL2)
I2C_SDA2: Q1201.3(DRAIN) R1232.1 SR3003.1 U1201.A5(I2C_SDA2)
ID_DET: D8805.1(ANODE) R8805.1 R8807.2 SR8812.2
