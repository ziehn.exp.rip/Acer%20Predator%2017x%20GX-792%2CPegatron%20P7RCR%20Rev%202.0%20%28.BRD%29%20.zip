# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VO on IN1 (solid shape): 255.91,51.67 255.91,50.64 256.27,50.29 256.27,49.69 255.83,49.31 256.27,48.93 256.27,48.6 256.06,48.39 254.82,48.39 254.69,48.52 254.69,51.65 254.9,51.85 255.73,51.85
+3VO on IN1 (solid shape): outline of 115 points within 245.16,16.24 259.58,27.63
+3VO on IN1 (solid shape): outline of 190 points within 114.67,15.45 120.05,22.35
+3VO on IN2 (solid shape): 256.27,60.51 256.27,59.62 255.81,59.16 254.31,59.16 253.96,59.52 253.96,60.54 254.41,60.99 255.78,60.99
+3VO on IN2 (solid shape): 124.64,6.99 124.64,3.94 124.35,3.65 120.34,3.65 120.16,3.83 120.16,7.69 120.81,8.34 123.3,8.34
+3VO on IN2 (solid shape): outline of 101 points within 170.61,12.16 179.71,15.05
+3VO on IN2 (solid shape): outline of 133 points within 256.24,70.06 260.38,79.76
+3VO on IN2 (solid shape): outline of 421 points within 238.95,15.54 259.65,27.82
+3VO on IN3 (solid shape): outline of 480 points within 251.06,38.84 259.51,51.7
+3VO on IN4 (solid shape): outline of 113 points within 244.74,16.24 259.58,29.27
+3VS on TOP (solid shape): 295.26,102.98 295.26,101.56 295.15,101.45 293.27,101.45 293.15,101.58 293.15,102.75 293.63,103.23 295,103.23
+3VS on TOP (solid shape): 34.77,32.43 34.77,30.86 34.55,30.64 31.83,30.64 31.78,30.69 31.78,32.49 31.86,32.57 34.63,32.57
+3VS on TOP (solid shape): 4.81,20.61 4.81,17.99 6.03,16.77 6.03,16.29 5.9,16.16 4.78,16.16 3.99,16.95 3.99,20.61 4.04,20.66 4.76,20.66
+3VS on TOP (solid shape): 308.09,42.74 308.91,42.74 309.69,41.95 309.69,41.38 309.28,40.97 308.86,40.97 308.16,41.68 307.19,41.68 306.33,42.53 306.33,43.06 306.49,43.21 307.62,43.21
+3VS on TOP (solid shape): 29.84,24.94 29.84,24.59 29.88,24.56 31.41,24.56 31.6,24.37 31.6,22.33 31.35,22.08 29.57,22.08 28.17,23.48 28.17,24.77 28.45,25.05 29.72,25.05
+3VS on TOP (solid shape): 64.12,16.49 64.12,14.46 63.99,14.33 61.25,14.33 61.09,14.49 61.09,15.45 60.86,15.68 60.86,17.76 61.12,18.02 62.59,18.02
+3VS on TOP (solid shape): 81.51,21.57 81.51,18.78 79.36,16.62 79.36,11.67 79.23,11.54 77.45,11.54 76.69,12.3 76.69,21.7 76.94,21.95 81.13,21.95
+3VS on TOP (solid shape): 5.39,51.16 5.39,50.55 5.72,50.22 5.72,49.28 5.54,49.11 4.58,49.11 4.12,49.56 4.12,49.82 3.46,50.48 2.37,50.48 2.06,50.78 2.06,51.32 2.25,51.51 5.05,51.51
+3VS on TOP (solid shape): 309.86,112.38 309.86,111.13 309.48,110.75 309.48,108.72 308.81,108.05 307.57,108.05 307.08,107.55 306.08,107.55 305.7,107.17 304.4,107.17 304.11,107.46 304.11,108.34 304.24,108.46 304.3,108.53 304.3,108.53 304.37,108.6 305.29,108.6 305.4,108.7 305.4,108.93 305.49,109.02 305.49,109.03 306.05,109.58 306.05,110.73 306.13,110.8 306.71,110.8 307.3,111.39 307.3,112.25 307.55,112.5 309.73,112.5
+3VS on TOP (solid shape): 239.72,21.11 239.72,20.59 240.09,20.23 240.09,19.79 239.33,19.79 239.3,19.77 239.3,19.57 239.33,19.54 240.01,19.54 240.01,19.36 239.12,19.36 238.82,19.67 237.39,19.67 237.04,19.31 237.04,17.99 237.39,17.63 238.87,17.63 239.17,17.94 240.01,17.94 240.01,17.76 239.33,17.76 239.3,17.74 239.3,17.56 239.33,17.53 240.01,17.53 240.01,15.48 239.76,15.22 236.96,15.22 236.33,15.86 235.79,15.86 235.52,16.12 235.52,20.98 235.71,21.17 239.67,21.17
+3VS on BOTTOM (solid shape): 110.11,188 110.2,187.9 110.2,186.38 109.92,186.1 109.06,186.1 108.87,185.91 108.87,184.89 108.96,184.79 109.52,184.79 109.76,184.56 109.76,183.79 109.97,183.57 109.97,180.04 109.78,179.84 107.88,179.84 107.61,180.11 107.61,183.47 106.82,184.25 106.82,185.79 107.04,186.01 107.04,187 107.17,187.13 108.16,187.13 108.26,187.22 108.26,187.84 108.61,188.19 108.93,188.19 108.94,188.2 109.91,188.2
+3VS on IN1 (solid shape): 285.6,67.8 286.75,67.8 286.75,67.8 286.87,67.68 286.87,65.9 286.44,65.46 283.54,65.46 283.19,65.81 283.19,66.31 284.08,66.31 284.09,66.26 284.1,66.2 284.12,66.15 284.15,66.1 284.19,66.06 284.23,66.02 284.27,65.99 284.32,65.97 284.38,65.95 284.43,65.95 284.49,65.95 284.54,65.95 284.6,65.97 284.65,65.99 284.69,66.02 284.74,66.06 284.77,66.1 284.8,66.15 284.82,66.2 284.84,66.26 284.84,66.31 284.84,66.37 284.83,66.42 284.81,66.48 284.79,66.53 284.75,66.57 284.72,66.61 284.67,66.65 284.62,66.67 284.57,66.69 284.52,66.7 284.46,66.71 284.41,66.7 284.35,66.69 284.3,66.67 284.25,66.65 284.21,66.61 284.17,66.57 284.13,66.53 284.11,66.48 284.09,66.42 284.08,66.37 284.08,66.31 283.19,66.31 283.19,67.93 283.44,68.18 285.22,68.18
+3VS on IN2 (solid shape): 287.46,53.19 287.46,50.83 287.13,50.5 285.81,50.5 285.58,50.73 285.58,51.49 284.71,52.36 284.71,53.14 285.02,53.45 287.2,53.45
+3VS on IN2 (solid shape): outline of 111 points within 302.72,40.32 309.49,49.13
+3VS on IN2 (solid shape): outline of 209 points within 291.9,50.71 298.25,54.34
+3VS on IN2 (solid shape): outline of 306 points within 5.19,25 8.62,33.76
+3VS on IN2 (solid shape): outline of 928 points within 40.84,171.3 92.89,192.55
+3VS on IN2 (solid shape): outline of 1045 points within 293.62,99.65 308.59,109.91
+3VS on IN2 (solid shape): outline of 2066 points within 36.1,10.17 83.65,21.9
+3VS on IN2 (solid shape): outline of 2493 points within 283.55,66.53 303.76,92.06
+3VS on VCC1 (solid shape): outline of 1361 points within 24.75,11.54 286.75,172.96
+3VS on IN3 (solid shape): 308.72,109.71 308.72,109.2 306.18,106.66 303,106.66 300.59,104.25 299.57,104.25 299.56,104.29 299.19,104.58 298.82,104.29 298.81,104.25 298.68,104.25 298.68,104.29 298.3,104.58 297.93,104.29 297.92,104.25 295.64,104.25 295.26,103.87 295.26,101.84 294.87,101.45 293.86,101.45 293.48,101.84 293.48,105.14 293.99,105.65 300.08,105.65 302.09,107.65 302.11,107.65 302.3,107.73 302.42,107.9 302.43,107.93 302.51,107.93 302.52,107.9 302.88,107.65 303.23,107.9 303.25,107.93 303.32,107.93 303.33,107.9 303.69,107.65 304.05,107.9 304.06,107.93 305.54,107.93 307.57,109.96 308.46,109.96
+3VS on IN3 (solid shape): outline of 3371 points within 40.72,171.25 113.08,192.5
+3VS_DPOUT on TOP (solid shape): 313.39,120.02 313.39,117.15 312.75,116.51 311.94,116.51 311.26,116.09 311.33,115.29 311.33,114.31 310.95,113.93 309.23,113.93 309.19,113.96 309.19,115.12 309.62,115.55 309.62,116.96 309.91,117.25 309.91,117.99 310.19,118.27 311.31,118.27 312.81,119.77 312.81,120.12 313.29,120.12
+3VS_DPSW on TOP (solid shape): 267.14,43.21 267.44,42.91 268.2,42.91 268.31,42.81 268.31,39.91 267.24,38.84 266.3,38.84 266.02,39.12 266.02,39.3 266.2,39.48 266.91,39.48 267.11,39.68 267.11,40.19 267.7,40.77 267.7,41.66 266.88,42.48 266.88,43.85 267.14,43.85
+3VS_EDP on TOP (solid shape): 114.26,190.17 114.26,189.06 114.38,188.94 114.38,187.82 114.31,187.75 114.12,187.75 114.12,188.47 114.12,188.95 114.1,188.97 113.89,188.97 113.87,188.95 113.87,187.75 113.62,187.75 113.62,188.47 113.62,188.47 113.62,188.94 113.59,188.97 113.39,188.97 113.37,188.94 113.37,187.75 113.13,187.75 113.13,189.17 112.6,189.69 112.6,190.15 112.83,190.37 114.06,190.37
+3VS_EDP on BOTTOM (solid shape): outline of 81 points within 111.22,187.04 115.55,191.49
+3VS_HDMI on IN1 (solid shape): outline of 349 points within 291.7,77.13 297.03,87.23
+3VS_HDMI on IN2 (solid shape): outline of 223 points within 291.19,77.2 296.78,88.1
+3VS_IO on TOP (solid shape): 8.9,50.86 8.9,49.26 8.71,49.07 6.62,49.07 6.52,49.17 6.52,49.83 7.09,50.4 7.09,51.42 7.27,51.59 8.16,51.59
+3VS_IO on TOP (solid shape): 19.79,88.12 19.79,87.56 19.95,87.41 19.95,85.43 19.75,85.23 17.97,85.23 17.76,85.44 17.76,85.71 18.14,86.09 19.11,86.09 19.17,86.15 19.18,86.15 19.18,87.33 19.09,87.42 18.08,87.42 17.91,87.59 17.91,87.97 18.19,88.25 19.67,88.25
+3VS_S0 on TOP (solid shape): 302.12,45.42 302.37,45.32 302.63,45.42 304.08,45.42 304.34,45.32 304.6,45.42 307.52,45.42 307.6,45.34 307.6,44.18 307.44,44.03 306.38,44.03 306.33,43.99 305.06,43.99 305.05,43.99 304.9,44.02 304.75,43.98 304.74,43.97 301.62,43.97 301.38,44.06 301.13,43.97 300.82,43.97 299.96,44.83 299.93,44.83 299.92,44.85 299.16,44.85 299.08,44.76 299.04,44.76 298.94,44.86 298.94,44.97 299.07,45.09 299.24,45.09 299.31,45.16 299.31,45.31 299.42,45.42
+3VS_S0 on BOTTOM (solid shape): 302.17,44.47 302.17,44.06 301.94,43.83 301.18,43.83 301.06,43.95 300,43.95 299.92,44.03 299.92,45.05 300.09,45.23 301.42,45.23
+3VS_S0 on BOTTOM (solid shape): 279.99,45.03 279.99,43.87 279.92,43.81 278.96,43.81 278.78,43.99 278.78,44.99 278.89,45.11 279.91,45.11
+3VS_S0 on IN2 (solid shape): outline of 2708 points within 278.59,38.83 305.75,50.41
+3VS_S0_TBT on BOTTOM (solid shape): 286.26,43.57 286.26,43.31 286.27,43.31 285.71,42.74 279.32,42.74 279,43.06 279,43.62 279.03,43.64 283.68,43.64 283.8,43.77 286.06,43.77
+3VS_S0_TBT on IN1 (solid shape): outline of 631 points within 285.78,38.72 294.9,43.87
+3VS_SSD2 on TOP (solid shape): outline of 376 points within 24.26,20.61 31.72,39.86
+3VS_SSD2 on BOTTOM (solid shape): 27.95,38.79 27.95,38.11 27.9,38.06 25.86,38.06 25.76,37.95 25.76,37.07 25.56,36.86 24.82,36.86 24.75,36.94 24.75,38.54 25.71,38.54 25.71,38.36 25.74,38.34 27.57,38.34 27.62,38.39 27.62,38.51 27.57,38.56 25.74,38.56 25.71,38.54 24.75,38.54 24.75,38.72 24.87,38.84 27.9,38.84
+3VS_SSD2 on BOTTOM (solid shape): 25.74,23.5 25.74,22.36 25.76,22.33 25.76,21.98 25.89,21.85 27.41,21.85 27.41,21.57 25.91,21.57 25.89,21.55 25.89,21.37 25.91,21.34 27.41,21.34 27.41,21.06 25.91,21.06 25.89,21.04 25.89,20.86 25.91,20.84 27.41,20.84 27.41,20.56 25.62,20.56 25.38,20.68 25.13,20.75 25.01,20.75 24.91,20.75 24.88,20.75 24.62,21.01 24.62,23.6 24.72,23.71 25.53,23.71
+3VS_SSD2 on IN1 (solid shape): outline of 87 points within 24.24,20.58 27.21,39.15
+3VS_SSD3 on TOP (solid shape): 38.92,9.3 42.65,9.3 42.93,9.58 46.89,9.58 47.35,9.13 47.35,8.74 47.1,8.49 34.65,8.49 34.52,8.62 34.52,9.15 34.55,9.39 34.53,9.64 34.65,9.76 38.46,9.76
+3VS_SSD3 on TOP (solid shape): outline of 110 points within 52.05,14.08 60.28,17.63
+3VS_SSD3 on BOTTOM (solid shape): 38.77,9.84 39.55,9.84 39.81,10.09 47.22,10.09 47.48,9.84 47.48,8.87 47.22,8.62 35.72,8.62 35.64,8.54 35.64,6.94 35.36,6.94 35.36,8.57 35.34,8.59 35.16,8.59 35.13,8.57 35.13,6.94 35.11,6.92 34.86,6.92 34.86,8.57 34.83,8.59 34.65,8.59 34.63,8.57 34.63,7.09 34.6,7.07 34.37,7.07 34.37,8.8 34.53,9.18 34.54,9.6 34.54,10 34.83,10.29 38.31,10.29
+3VS_SSD3 on BOTTOM (solid shape): 52.77,9.72 52.75,9.69 52.73,9.61 52.71,9.54 52.7,9.46 52.7,9.39 52.7,9.31 52.72,9.24 52.74,9.16 52.76,9.09 52.79,9.02 52.81,8.99 52.81,8.74 52.61,8.54 52.61,6.74 52.71,6.64 52.71,5.9 52.58,5.77 49.38,5.77 49.26,5.9 49.26,8.59 50.17,8.59 50.17,6.79 50.25,6.71 51.8,6.71 51.87,6.79 51.87,8.54 52.13,8.54 52.13,6.81 52.18,6.76 52.3,6.76 52.36,6.81 52.36,8.54 52.3,8.59 52.18,8.59 52.13,8.54 51.87,8.54 51.87,8.59 51.82,8.64 50.22,8.64 50.17,8.59 49.26,8.59 49.26,9.55 49.92,10.22 52.27,10.22
+3VS_SSD3 on IN4 (solid shape): outline of 1670 points within 32.43,8.43 55.04,22.23
+3VS_SSD_PCIE on TOP (solid shape): outline of 199 points within 34.78,21.88 43.36,38.83
+3VS_SSD_PCIE on BOTTOM (solid shape): outline of 530 points within 34.4,17.76 47.61,38.84
+3VS_TYPEC on BOTTOM (solid shape): outline of 281 points within 285.73,51.7 295.01,55.07
+3VS_VGA on TOP (solid shape): 297.14,109.63 297.14,109.37 296.53,109.37 295.59,108.43 295.59,107.81 295.84,107.56 296.65,107.56 296.97,107.24 296.97,105.99 296.87,105.89 295.22,105.89 294.56,106.55 294.56,106.95 294.84,107.22 294.84,109.55 294.92,109.64 297.13,109.64
+3VS_VGA on TOP (solid shape): 305.87,111.06 305.87,109.89 305.47,109.49 304.23,109.49 303.99,109.25 300.54,109.25 300.44,109.35 299.75,109.35 299.73,109.38 299.73,109.58 299.78,109.63 300.31,109.63 300.46,109.79 301.66,109.79 302.15,110.28 304.08,110.28 305.01,111.21 305.72,111.21
+3VS_VGA on IN3 (solid shape): outline of 1224 points within 292.33,106.15 305.8,121.77
+3VSUS on TOP (solid shape): 10.24,59.47 10.24,55.51 10.17,55.43 9.15,55.43 9.12,55.46 9.12,56.42 8.54,57 8.54,57.92 8.03,58.43 6.28,58.43 6.15,58.55 6.15,59.77 6.31,59.93 9.79,59.93
+3VSUS on TOP (solid shape): 1.81,55.79 1.81,55.05 2.01,54.85 2.01,54.81 2.08,54.63 2.22,54.51 2.24,54.49 2.26,54.49 2.39,54.46 2.52,54.49 2.55,54.49 2.57,54.51 2.66,54.58 2.73,54.67 2.75,54.69 2.75,54.71 2.78,54.83 2.76,54.95 2.75,54.98 2.98,55.2 4.1,55.2 4.22,55.07 4.22,54.21 3.82,53.8 1.94,53.8 1.2,54.54 1.2,55.73 1.3,55.84 1.76,55.84
+3VSUS on TOP (solid shape): 298.15,103.01 298.13,102.98 298.11,102.74 298.24,102.53 298.25,102.52 298.25,102.42 298.24,102.41 298.11,102.21 298.13,101.98 298.12,101.9 298.06,101.85 297.77,101.53 297.9,101.11 298.25,100.75 298.25,100.31 298.1,100.16 296.3,100.16 296.13,100.32 296.13,103.04 296.32,103.23 297.92,103.23
+3VSUS on TOP (solid shape): 250.53,76.18 251.97,76.18 252.23,75.93 252.23,74.3 251.82,73.9 249.6,73.9 249.15,74.34 249.11,74.34 249.1,74.34 248.95,74.38 248.79,74.34 248.78,74.34 248.51,74.34 248.5,74.34 248.3,74.37 248.11,74.3 248,74.17 247.96,74.01 247.97,73.88 248.02,73.78 248.02,73.23 248,73.21 247.49,73.21 247.39,73.31 247.39,73.69 247.37,73.72 246.39,73.72 246.39,73.72 243.32,73.72 243.08,73.95 243.08,74.25 244.03,75.2 244.03,76.18 244.18,76.33 246.64,76.33 247.03,76.73 249.99,76.73
+3VSUS on TOP (solid shape): outline of 1137 points within 240.9,30.08 257.03,46.08
+3VSUS on BOTTOM (solid shape): 20,60.21 20,59.19 19.79,58.99 19.23,58.99 18.85,59.37 18.85,60.05 19.16,60.36 19.84,60.36
+3VSUS on BOTTOM (solid shape): 7.55,59.47 7.55,57.98 7.38,57.81 6.29,57.81 6,58.1 6,59.46 6.19,59.65 7.37,59.65
+3VSUS on BOTTOM (solid shape): 3.89,54.67 3.89,53.96 3.26,53.32 2.67,53.32 2.22,53.78 2.22,54.19 2.46,54.43 2.66,54.43 2.67,54.41 3.13,54.87 3.69,54.87
+3VSUS on BOTTOM (solid shape): 244.06,47.51 244.06,47 243.94,46.87 243.67,46.87 243.59,46.79 243.59,46.01 243.25,45.66 243.07,45.66 242.7,45.3 241.26,45.3 241.15,45.4 241.15,47.38 241.36,47.59 243.99,47.59
+3VSUS on BOTTOM (solid shape): 250.49,32.87 250.49,30.45 250.35,30.3 248.4,30.3 248.24,30.46 245.95,30.46 245.45,29.95 245.45,28.61 245.14,28.3 240.92,28.3 240.8,28.42 240.8,32.33 240.99,32.52 242.83,32.52 243.31,33 250.36,33
+3VSUS on IN1 (solid shape): 9.3,59.19 9.3,57.33 9.12,57.16 8.74,57.16 8.72,57.18 8.08,57.18 6.14,59.12 6.14,59.79 6.41,60.06 8.43,60.06
+3VSUS on IN1 (solid shape): outline of 489 points within 240.93,30.66 254.92,41.69
+3VSUS on IN2 (solid shape): 253.27,75.65 253.27,74.02 252.58,73.34 250.12,73.34 249.54,73.92 249.54,75.7 249.87,76.03 252.89,76.03
+3VSUS on IN2 (solid shape): 256.72,88.17 256.72,86.27 256.47,86.01 254.34,86.01 253.98,86.37 253.98,87.81 254.54,88.37 256.52,88.37
+3VSUS on IN2 (solid shape): 9.3,59.19 9.3,57.33 9.12,57.16 8.74,57.16 8.52,57.39 7.93,57.39 6.05,59.27 6.05,59.68 6.33,59.96 8.53,59.96
+3VSUS on IN2 (solid shape): 259.91,37.74 259.91,36.6 259.72,36.41 259.72,36.26 259.71,36.24 259.71,35.75 259.71,35.7 259.72,35.66 259.72,35.22 258.84,34.34 257.39,34.34 257.36,34.35 257.31,34.35 257.26,34.35 257.23,34.34 257.01,34.34 256.34,33.66 255.19,33.66 255.02,33.84 255.02,34.22 256.29,35.5 257.82,35.5 257.82,35.43 257.82,35.37 257.84,35.31 257.86,35.25 257.89,35.19 257.93,35.14 257.98,35.09 258.03,35.05 258.08,35.02 258.14,34.99 258.2,34.97 258.26,34.96 258.32,34.96 258.39,34.96 258.45,34.97 258.51,34.99 258.57,35.02 258.62,35.05 258.67,35.09 258.72,35.14 258.75,35.19 258.79,35.25 258.81,35.31 258.82,35.37 258.83,35.43 258.83,35.5 258.82,35.56 258.81,35.62 258.79,35.68 258.75,35.74 258.72,35.79 258.67,35.84 258.62,35.88 258.57,35.91 258.51,35.94 258.45,35.96 258.39,35.97 258.32,35.97 258.26,35.97 258.2,35.96 258.14,35.94 258.08,35.91 258.03,35.88 257.98,35.84 257.93,35.79 257.89,35.74 257.86,35.68 257.84,35.62 257.82,35.56 257.82,35.5 256.29,35.5 258.41,37.62 258.63,37.62 258.64,37.62 258.69,37.62 259.15,38.09 259.56,38.09
+3VSUS on IN2 (solid shape): outline of 300 points within 241.28,46.57 249.82,54.54
+3VSUS on IN3 (solid shape): 20.28,60.51 20.28,59.27 19.84,58.83 19.23,58.83 18.5,59.57 18.5,60.36 18.95,60.81 19.97,60.81
+3VSUS on IN3 (solid shape): 179.36,28.2 179.36,27.13 179.15,26.93 177.39,26.93 177.23,27.08 177.23,28.32 177.39,28.47 179.09,28.47
+3VSUS on IN3 (solid shape): 242.16,39.19 242.16,38.68 242.83,38.01 242.83,37.06 242.39,36.62 241.73,36.62 241.03,37.32 241.03,39.02 241.28,39.28 242.07,39.28
+3VSUS on IN3 (solid shape): 269.22,97.7 269.22,96.7 268.46,95.94 266.78,95.94 266.36,96.37 266.36,97.41 266.81,97.65 267.25,97.89 267.31,97.92 267.36,97.95 267.67,98.12 267.98,98.31 268.61,98.31
+3VSUS on IN3 (solid shape): 258.12,89.59 258.12,88.12 256.85,86.85 254.95,86.85 254.57,87.23 254.57,89.97 254.8,90.21 255.17,90.26 255.28,90.25 255.39,90.28 255.4,90.28 257.44,90.28
+3VSUS on IN3 (solid shape): 170.57,28.23 170.57,27.95 170.54,27.93 170.31,27.58 170.54,27.24 170.57,27.22 170.57,26.75 170.55,26.74 168.55,26.74 168.48,26.68 168.26,26.68 167.98,26.96 167.98,27.74 168.71,28.48 170.31,28.48
+3VSUS on IN3 (solid shape): 229.5,36.09 229.5,34.99 228.86,34.34 226.08,34.34 225.23,35.2 225.23,35.35 226.9,35.35 226.91,35.29 226.92,35.24 226.94,35.19 226.97,35.14 227,35.09 227.04,35.06 227.09,35.02 227.14,35 227.19,34.98 227.24,34.97 227.3,34.97 227.35,34.97 227.41,34.99 227.46,35.01 227.51,35.04 227.55,35.07 227.59,35.12 227.62,35.16 227.64,35.21 227.66,35.27 227.67,35.32 227.67,35.38 227.66,35.43 227.64,35.49 227.62,35.54 227.59,35.58 227.55,35.62 227.51,35.66 227.46,35.69 227.41,35.71 227.35,35.73 227.3,35.73 227.24,35.73 227.19,35.72 227.14,35.7 227.09,35.68 227.04,35.64 227,35.6 226.97,35.56 226.94,35.51 226.92,35.46 226.91,35.41 226.9,35.35 225.23,35.35 225.23,36.04 225.87,36.68 228.91,36.68
+3VSUS on IN3 (solid shape): outline of 146 points within 121.11,28 128.69,30.77
+3VSUS on IN3 (solid shape): outline of 2568 points within 239.2,45.32 252.71,68.69
+3VSUS on IN4 (solid shape): 20,60.21 20,59.19 19.79,58.99 19.23,58.99 18.4,59.82 18.4,60.28 18.7,60.59 19.62,60.59
+3VSUS on IN4 (solid shape): 8.13,60.18 8.13,59.44 7.52,58.83 6.48,58.83 6.08,59.24 6.08,60.33 6.43,60.69 7.63,60.69
+3VSUS on IN4 (solid shape): 297.83,103.27 297.83,99.61 297.36,99.14 295.56,99.14 295.13,99.58 295.13,102.88 295.65,103.4 295.68,103.41 295.98,103.31 296.24,103.42 296.27,103.43 296.31,103.42 296.67,103.32 296.94,103.58 296.95,103.61 297.49,103.61
+3VSUS on IN4 (solid shape): outline of 1004 points within 266.57,96.31 287.13,103.74
+3VSUS on IN4 (solid shape): outline of 1890 points within 214.51,37.46 244.37,43.49
+3VSUS_IO on TOP (solid shape): 12.5,83.67 13.67,83.67 13.8,83.55 13.8,82.96 13.62,82.79 13.62,82.77 11.27,82.77 11.06,82.99 11.06,83.65 11.28,83.88 12.3,83.88
+3VSUS_IO on TOP (solid shape): 8.26,57.74 8.26,54.34 8.13,54.21 6.41,54.21 6.08,54.54 6.08,55.07 6.15,55.15 7.3,55.15 7.47,55.33 7.47,57.13 7.35,57.26 6,57.26 5.67,56.93 5.67,55.96 5.09,55.38 2.93,55.38 2.75,55.56 2.75,56.09 2.95,56.29 4.38,56.29 4.73,56.65 4.73,57.92 4.96,58.15 7.85,58.15
+3VSUS_IO on BOTTOM (solid shape): 4.07,56.83 4.07,55.58 3.77,55.28 2.77,55.28 2.42,55.63 2.42,56.8 2.65,57.03 3.87,57.03
+3VSUS_IO on IN3 (solid shape): 12.45,83.8 12.45,82.96 12.07,82.58 10.33,82.58 10.16,82.75 10.16,83.79 10.34,83.96 12.29,83.96
+3VSUS_LAN on BOTTOM (solid shape): 283.95,99.09 283.95,98.15 283.69,97.89 283.06,97.89 282.71,97.53 282.71,96.83 282.56,96.68 281.03,96.68 280.85,96.86 280.85,98.27 281.03,98.45 281.26,98.45 281.31,98.44 281.37,98.44 281.7,98.58 281.81,98.93 281.81,99.2 281.87,99.27 283.78,99.27
+3VSUS_SX on BOTTOM (solid shape): 301.41,42.84 301.41,41.71 301.35,41.66 300.47,41.66 300.09,42.04 297.34,42.04 297.14,42.25 297.14,42.47 297.23,42.56 298.44,42.56 298.61,42.73 298.61,42.73 299.02,43.14 301.11,43.14
+3VSUS_SX on BOTTOM (solid shape): outline of 136 points within 283.73,48.15 293.78,51.33
+5V_FAN0 on TOP (solid shape): 48.09,120.28 48.09,117.3 47.86,117.08 47.86,116.06 47.72,115.92 44.27,115.92 44.23,115.96 44.23,116.75 44.31,116.84 45.77,116.84 46.04,117.1 46.04,119.27 46.21,119.59 46.04,119.91 46.04,120.33 46.21,120.5 47.86,120.5
+5V_FAN0 on BOTTOM (solid shape): 53.22,125.14 53.22,124.29 54.29,123.22 54.29,120.93 54.21,120.85 53.57,120.85 53.52,120.9 53.52,121.34 53.52,121.34 53.52,122.54 51.49,124.57 50.65,124.57 50.53,124.7 50.53,125.58 50.65,125.71 52.65,125.71
+5V_USB on TOP (solid shape): 309.86,74.8 310.17,74.49 310.17,72.39 310.72,71.84 310.72,70.75 310.52,70.54 309.76,70.54 309.28,71.03 305.21,71.03 304.91,71.33 304.91,73.31 305.16,73.57 305.47,73.57 305.85,73.95 305.85,74.35 306.09,74.59 308.51,74.59 308.72,74.8 309.47,74.8
+5V_USB on BOTTOM (solid shape): outline of 202 points within 309.35,72.26 313.7,79
+5VA on TOP (solid shape): 268.69,61.09 268.69,58.66 268.31,58.27 266.91,58.27 266.78,58.4 266.78,58.66 266.93,58.81 266.93,61.26 267.09,61.42 268.36,61.42
+5VAO on TOP (solid shape): 266.48,61.37 266.48,59.04 266.35,58.91 264.88,58.91 264.78,59.01 264.78,59.77 264.97,59.96 264.97,60.86 265.59,61.48 266.38,61.48
+5VO on TOP (solid shape): 278.36,79.61 285.98,79.61 286.49,79.1 289.44,79.1 289.86,78.68 289.86,76.69 287.33,74.15 264.09,74.15 262.97,75.27 262.97,76.99 262.52,77.44 261.41,77.44 261.32,77.35 261.07,77.35 260.76,77.65 260.76,78.62 260.66,78.72 259.67,78.72 259.49,78.9 259.49,79.71 259.54,79.76 259.54,80.55 259.7,80.55 259.72,80.53 259.72,79.23 259.9,79.05 260.43,79.05 260.61,79.23 260.61,79.59 260.36,79.84 260.36,80.5 260.38,80.53 261.04,80.53 261.09,80.47 261.09,80.27 261.47,79.89 261.47,79.56 261.68,79.36 262.44,79.36 262.64,79.36 266.2,82.91 275.06,82.91
+5VO on BOTTOM (solid shape): 226.04,28.68 226.04,26.14 225.91,26.02 224.01,26.02 223.88,26.14 223.88,28.68 224.01,28.81 225.91,28.81
+5VO on BOTTOM (solid shape): 277.48,83.29 277.48,79.74 277.91,79.31 286.21,79.31 286.42,79.1 289.41,79.1 289.67,78.85 289.67,76.26 289.41,76 289.41,74.15 287.81,72.55 287.79,72.55 287.66,72.53 287.54,72.46 287.47,72.43 287.4,72.46 286.92,72.47 286.81,72.01 286.8,71.91 286.71,71.86 284.33,71.86 283.32,70.85 272.01,70.85 271.38,71.48 271.38,83.29 272.01,83.93 276.84,83.93
+5VO on IN3 (solid shape): 226.04,27.92 225.83,27.71 225.18,27.71 225,27.88 225,28.73 225.08,28.81 226.04,28.81
+5VO on IN3 (solid shape): 290.18,78.59 290.18,75.9 289.76,75.49 289.76,73.39 289.51,73.13 283.7,73.13 283.57,73.26 283.57,74.3 285.17,75.9 285.17,78.28 285.63,78.75 287.95,78.75 288.02,78.82 289.95,78.82
+5VO on IN3 (solid shape): outline of 108 points within 276.01,56.81 279.71,59.87
+5VO_1_1 on TOP (solid shape): 260.25,72.93 260.25,70.9 260.17,70.82 259.27,70.82 259.04,71.05 259.04,72.79 259.26,73.01 260.18,73.01
+5VO_1_2 on TOP (solid shape): 262.52,76.38 262.52,75.14 262.41,75.04 261.45,75.04 261.19,74.78 261.19,73.82 261.04,73.67 260.28,73.67 260.1,73.84 260.1,75.98 260.47,76.35 260.93,76.35 261.09,76.51 262.39,76.51
+5VS on TOP (solid shape): 72.79,10.68 72.79,8.81 72.22,8.24 70.62,8.24 70.26,8.6 70.26,11.01 70.42,11.16 72.31,11.16
+5VS on TOP (solid shape): 45.85,117.85 45.85,117.19 45.68,117.02 44.05,117.02 43.84,116.81 43.84,116.42 43.55,116.13 42.89,116.13 42.4,116.62 42.4,117.73 42.63,117.95 45.74,117.95
+5VS on TOP (solid shape): 74.91,6.2 74.91,4.43 74.78,4.3 71.48,4.3 71.35,4.43 71.35,4.93 71.48,5.06 72.88,5.06 73.13,5.32 73.13,6.2 73.26,6.33 74.78,6.33
+5VS on TOP (solid shape): 147.22,166.48 147.22,165.59 146.98,165.35 146.27,165.35 146.17,165.46 146.17,165.88 146.07,165.98 144.83,165.98 144.73,166.08 144.73,166.58 144.84,166.69 147.01,166.69
+5VS on TOP (solid shape): 161.65,166.48 161.65,165.59 161.41,165.35 160.7,165.35 160.59,165.46 160.59,165.88 160.5,165.98 159.26,165.98 159.16,166.08 159.16,166.58 159.27,166.69 161.44,166.69
+5VS on TOP (solid shape): 174.6,166.48 174.6,165.59 174.36,165.35 173.65,165.35 173.55,165.46 173.55,165.88 173.45,165.98 172.22,165.98 172.11,166.08 172.11,166.58 172.22,166.69 174.39,166.69
+5VS on TOP (solid shape): 186.67,165.72 186.67,164.83 186.43,164.59 185.72,164.59 185.61,164.69 185.61,165.12 185.52,165.21 184.28,165.21 184.18,165.32 184.18,165.82 184.28,165.93 186.45,165.93
+5VS on TOP (solid shape): 262.68,84.49 262.68,81.32 262.59,81.24 261.45,81.24 261.22,81.46 261.22,81.62 260.97,81.87 260.41,81.87 260.36,81.92 260.36,82.46 260.58,82.68 260.58,83.7 260.71,83.83 261.19,83.83 261.47,84.11 261.47,84.51 261.63,84.67 262.5,84.67
+5VS on TOP (solid shape): 24.88,13.34 25.12,13.1 25.53,13.1 25.69,12.95 25.69,12.73 25.58,12.63 25.48,12.58 25.39,12.54 25.38,12.53 25.13,12.53 24.95,12.35 24.95,11.39 24.9,11.34 24.44,11.34 24.36,11.41 24.36,13.19 24.52,13.34 24.75,13.34
+5VS on TOP (solid shape): 14.62,35.42 14.62,35.01 14.68,34.69 14.97,34.53 15.68,33.81 21.88,33.81 22.22,34.15 23.27,34.15 23.61,33.81 23.61,31.93 23.29,31.61 17.15,31.61 15.61,33.15 15.08,33.15 13.81,34.42 13.29,34.42 13.06,34.65 13.06,35.51 13.2,35.64 14.4,35.64
+5VS on BOTTOM (solid shape): 308.34,85.2 308.34,83.93 308.21,83.8 307.57,83.8 307.24,83.47 307.24,82.3 307.04,82.1 305.8,82.1 305.67,82.23 305.67,84.59 305.83,84.75 306.23,84.75 306.66,84.77 306.8,85.18 306.8,85.24 306.89,85.33 308.21,85.33
+5VS on IN1 (solid shape): 307.24,83.55 307.24,82.3 306.97,82.03 305.92,82.03 305.67,82.28 305.67,83.6 305.8,83.73 307.07,83.73
+5VS on IN1 (solid shape): 268.33,87.56 268.33,85.33 267.35,84.35 262.72,84.35 262.67,84.3 262.67,81.39 262.46,81.19 261.14,81.19 260.92,81.41 260.92,84.31 261.09,84.49 261.09,84.94 262.74,86.6 266.3,86.6 267.42,87.71 268.18,87.71
+5VS on IN1 (solid shape): outline of 1144 points within 145.87,163.51 186.47,166.69
+5VS on VCC2 (solid shape): outline of 1003 points within 21.55,5.19 270.11,94.6
+5VS on IN4 (solid shape): 44.81,117.96 44.81,114.28 44.68,114.15 42.65,114.15 42.53,114.28 42.53,115.27 42.65,115.53 42.56,115.8 42.53,115.87 42.56,115.94 42.65,116.21 42.53,116.47 42.53,117.8 42.78,118.06 44.72,118.06
+5VS on IN4 (solid shape): outline of 361 points within 18.91,31.82 24.42,49.13
+5VS_FAN2 on TOP (solid shape): 71.1,4.93 71.1,4.32 71.38,4.05 73.01,4.05 73.13,3.92 73.13,3.16 73.01,3.03 70.6,3.03 69.48,4.15 68.45,4.15 68.31,4.3 68.31,5.06 68.43,5.19 70.85,5.19
+5VS_FAN2 on BOTTOM (solid shape): outline of 203 points within 67.54,3.41 78.34,8.87
+5VS_HDD on TOP (solid shape): 23.48,13.32 23.48,10.6 21.88,9 17.08,9 16.87,9.2 16.87,10.29 16.95,10.37 20.37,10.37 20.62,10.62 20.62,10.95 20.44,11.13 20.44,13.38 20.51,13.44 23.35,13.44
+5VS_HDD on BOTTOM (solid shape): 19.36,14.56 19.36,12.62 18.4,11.66 18.4,10.54 18.65,10.29 20.28,10.29 20.28,10.3 20.68,10.3 20.9,10.52 20.9,10.86 21.07,11.02 22.32,11.02 22.6,10.74 22.6,8.85 22.18,8.43 16.73,8.43 16.38,8.78 16.38,10.61 17.13,11.36 17.13,13.2 17.25,13.33 18.03,13.33 18.12,13.42 18.12,14.55 18.14,14.56 18.32,14.56 18.37,14.51 18.37,13.47 18.42,13.42 18.62,13.42 18.65,13.44 18.65,14.54 18.68,14.56 18.83,14.56 18.88,14.51 18.88,13.55 18.85,13.52 18.85,13.44 18.93,13.37 19.08,13.37 19.13,13.42 19.13,14.56 19.16,14.59 19.34,14.59
+5VS_HDD_2 on TOP (solid shape): 18.14,12.94 18.14,11.28 18.04,11.18 16.87,11.18 16.72,11.03 16.11,11.03 15.98,11.16 15.98,12.94 16.11,13.06 18.01,13.06
+5VS_HDD_2 on BOTTOM (solid shape): 15.86,14.56 15.86,13.46 15.91,13.41 16.08,13.41 16.12,13.45 16.12,14.54 16.16,14.59 16.34,14.59 16.37,14.55 16.37,13.67 16.37,13.66 16.37,13.45 16.5,13.32 16.87,13.32 17,13.19 17,11.41 16.62,11.03 16.01,11.03 15.63,11.41 15.63,14.55 15.67,14.6 15.83,14.6
+5VS_HDMI on TOP (solid shape): 310.57,88.93 310.57,87 310.17,86.6 309.73,86.6 309.63,86.7 309.63,87.13 309.4,87.36 308.84,87.36 308.69,87.51 308.69,88.78 309.02,89.11 310.39,89.11
+5VS_HDMI on BOTTOM (solid shape): outline of 101 points within 307.45,85.91 314.94,97.14
+5VS_HDMI on IN4 (solid shape): 314.94,97.01 314.94,94.65 311.91,91.62 311.91,89.83 310.74,88.66 310.74,86.89 310.38,86.53 309.56,86.53 309.51,86.87 309.21,87.03 309.21,89.84 309.93,90.56 309.93,92.07 313.74,95.88 313.83,95.95 313.9,96.04 314.31,96.45 314.31,97.06 314.38,97.14 314.81,97.14
+5VSUS on TOP (solid shape): 37.04,78.65 37.04,77.99 35.57,76.51 34.07,76.51 32.85,77.73 32.85,79.59 33.18,79.92 35.77,79.92
+5VSUS on TOP (solid shape): 284.89,60.56 284.89,58.25 284.08,57.44 281.49,57.44 280.9,58.02 280.9,58.53 280.7,58.73 280.7,60.69 280.78,60.76 284.69,60.76
+5VSUS on TOP (solid shape): 305.9,69.88 305.9,66.15 305.82,66.07 305.72,66.07 305.29,65.64 305.01,65.64 304.22,64.85 303.38,64.85 303.38,65.44 303.64,65.44 303.66,65.46 303.66,66.63 304.15,67.11 304.15,69.93 304.22,70.01 305.77,70.01
+5VSUS on TOP (solid shape): outline of 86 points within 1.22,5.72 76.16,20.17
+5VSUS on TOP (solid shape): outline of 440 points within 271.02,66.05 289.41,73.48
+5VSUS on BOTTOM (solid shape): 289.41,71.09 289.41,70.21 288.91,69.7 282.94,69.7 282.94,70.47 283.7,70.47 284.54,71.31 289.19,71.31
+5VSUS on BOTTOM (solid shape): outline of 387 points within 1.38,5.64 76.82,20.17
+5VSUS on BOTTOM (solid shape): outline of 580 points within 20.09,76.31 37.06,96.76
+5VSUS on IN3 (solid shape): outline of 8473 points within 72.24,3.68 243.31,25
+5VSUS on IN3 (solid shape): outline of 12133 points within 269.89,17.75 308.23,73.29
+5VSUS_CHARGING on TOP (solid shape): 310.92,45.63 310.92,44.77 310.51,44.36 308.15,44.36 307.99,44.53 307.99,45.7 308.95,46.67 309.88,46.67
+5VSUS_CHARGING on TOP (solid shape): outline of 112 points within 303.37,59.49 310.5,63.67
+5VSUS_CHARGING on IN2 (solid shape): outline of 788 points within 306.91,45.09 313.52,62.97
+5VSUS_CHARGING on IN3 (solid shape): outline of 788 points within 306.91,45.09 313.52,62.97
+5VSUS_CHARGING on IN4 (solid shape): outline of 751 points within 306.91,45.09 313.52,62.97
+5VSUS_PVDD on TOP (solid shape): 68.15,14.93 68.15,14.41 68.18,14.38 68.79,14.38 68.84,14.43 68.84,14.92 68.88,14.97 69.3,14.97 69.32,14.94 69.32,14.46 69.42,14.36 69.42,13.33 68.83,13.33 68.71,13.22 68.71,11.36 69.42,10.65 69.42,9.75 68.89,9.22 67.83,9.22 66.35,10.7 66.35,11.12 66.63,11.4 66.63,12.55 66.76,12.68 66.76,14.49 66.94,14.66 67.42,14.66 67.62,14.46 67.67,14.46 67.7,14.49 67.7,14.94 67.73,14.97 68.11,14.97
+5VSUS_TYPEC on TOP (solid shape): outline of 90 points within 280.68,60.54 293.15,64.73
+10VO on TOP (solid shape): 259.21,75.34 259.21,73.51 259.04,73.34 258.73,73.34 258.07,74 256.88,74 256.22,73.34 255.76,73.34 255.48,73.62 255.48,74.4 255.78,74.71 256.25,74.71 256.8,75.26 256.8,75.7 257.13,76.03 258.53,76.03
+12VO on TOP (solid shape): 254.69,76.42 254.69,73.54 254.49,73.34 252.89,73.34 252.51,73.71 252.51,75.22 252.76,75.22 252.76,75.16 252.78,75.11 252.8,75.05 252.82,75.01 252.86,74.96 252.9,74.92 252.94,74.89 252.99,74.86 253.05,74.85 253.1,74.84 253.16,74.83 253.21,74.84 253.27,74.85 253.32,74.88 253.37,74.91 253.41,74.94 253.45,74.98 253.48,75.03 253.5,75.08 253.52,75.13 253.52,75.19 253.52,75.24 253.52,75.3 253.5,75.35 253.48,75.4 253.45,75.45 253.41,75.49 253.37,75.53 253.32,75.56 253.27,75.58 253.21,75.59 253.16,75.6 253.1,75.6 253.05,75.59 252.99,75.57 252.94,75.54 252.9,75.51 252.86,75.47 252.82,75.43 252.8,75.38 252.78,75.33 252.76,75.27 252.76,75.22 252.51,75.22 252.51,75.63 253.45,76.57 254.54,76.57
+AVDDL on TOP (solid shape): 278.08,92.79 278.08,91.78 278.69,91.17 278.75,91.17 279,90.91 280.02,90.91 280.14,90.79 280.14,90.02 280.02,89.9 278.52,89.9 276.97,91.45 276.97,92.77 277.09,92.89 277.98,92.89
+AVDDL on BOTTOM (solid shape): 278.11,93.76 278.11,92.31 277.98,92.18 277.09,92.18 276.97,92.31 276.97,93.78 277.07,93.89 277.98,93.89
+AVDDL on IN4 (solid shape): outline of 133 points within 276.08,92.16 279.25,97.95
+AVDDVCO on BOTTOM (solid shape): 280.52,97.39 280.52,93.1 280.42,93 278.47,93 278.36,93.1 278.36,97.52 278.49,97.64 280.27,97.64
+DVDDIO_AUDIO_W10MIL on TOP (solid shape): 247.2,73.07 247.2,72.49 246.73,72.02 246.54,72.02 246.39,71.87 246.12,71.87 245.93,72.06 245.23,72.06 245.04,72.24 245.04,72.72 245.04,72.85 245.1,72.92 246.07,72.92 246.27,73.11 247.16,73.11
+DVDDL on TOP (solid shape): 280.75,97.11 280.75,96.25 281.29,95.71 281.29,95.35 281.25,94.78 281.79,94.58 285.55,94.58 285.68,94.44 285.68,93.45 282.38,90.15 280.65,90.15 280.4,90.4 280.4,95.95 280.4,95.96 280.4,97.05 280.55,97.2 280.66,97.2
+V1P0A_VCCAMPHYPLL_W25MIL on TOP (solid shape): 214.15,47.86 214.15,46.82 213.98,46.64 212.71,46.64 212.63,46.72 212.63,47.94 212.86,48.17 213.85,48.17
+V1P0A_VCCAMPHYPLL_W25MIL on BOTTOM (solid shape): 217.93,49.3 217.96,49.27 218.01,49.24 218.01,49.09 217.96,49.04 217.74,49.04 217.59,48.89 217.01,48.89 216.49,48.37 216.49,47.71 216.62,47.58 217.41,47.58 217.42,47.58 217.91,47.58 218.1,47.77 218.1,48.21 218.25,48.37 218.25,48.59 218.25,48.6 218.25,48.7 218.31,48.76 218.41,48.76 218.41,48.72 218.45,48.61 218.51,48.51 218.52,48.5 218.52,48.37 218.43,48.18 218.48,47.97 218.49,47.95 218.49,47.81 218.48,47.8 218.48,47.41 218.24,47.17 216.19,47.17 215.96,47.4 213.39,47.4 213.09,47.1 210.55,47.1 210.37,47.28 210.37,48.14 210.15,48.36 210.15,48.87 210.28,48.99 211.11,48.99 211.11,49 211.35,49.24 212.72,49.24 212.86,49.18 212.89,49.16 213.92,49.16 214.08,49 215.5,49 215.84,49.34 217.11,49.34 217.22,49.23 217.37,49.18 217.41,49.18 217.5,49.2 217.58,49.25 217.64,49.31 217.66,49.33 217.67,49.36 217.86,49.36
+V1P0A_VCCF24_W15MIL on TOP (solid shape): 221.27,74.96 221.27,70.79 221.71,70.35 221.71,70.04 221.59,69.92 220.27,69.92 220.27,70.38 220.34,70.45 220.34,75.14 220.44,75.24 220.99,75.24
+VBUS1 on TOP (solid shape): 312.4,28.81 312.4,27.67 312.15,27.41 310.75,27.41 310.5,27.67 310.5,27.92 310.24,28.18 307.45,28.18 306.69,28.94 306.19,28.94 306.19,28.95 305.54,28.95 305.42,29.06 305.42,31.22 305.67,31.48 309.73,31.48
+VBUS1 on TOP (solid shape): 292.14,60.27 292.14,60.04 292.07,59.97 292.04,59.97 291.95,59.97 291.86,59.95 291.85,59.94 291.56,59.94 291.49,59.95 291.4,59.94 291.31,59.88 291.25,59.78 291.24,59.77 291.04,59.57 291.02,59.57 290.99,59.53 290.22,59.53 290.1,59.65 290.1,60.08 290.43,60.4 292.01,60.4
+VBUS1 on TOP (solid shape): 297.67,62.21 298.38,62.21 298.38,62.21 300.58,62.21 300.92,61.87 300.92,61.12 300.84,61.03 296.5,61.03 296.39,60.93 296.28,60.84 296.23,60.7 296.09,60.56 296.09,60.54 296.03,60.47 296.01,60.48 295.82,60.42 295.72,60.27 295.71,60.23 295.71,60.2 295.68,60.13 295.6,60.1 295.42,60.1 295.26,60.26 295.24,60.31 295.22,60.35 295.2,60.38 295.13,60.44 294.99,60.48 294.9,60.48 294.9,61.28 294.92,61.33 294.93,61.37 294.93,61.45 295.29,61.82 295.76,61.82 295.76,62.21 295.89,62.34 297.54,62.34
+VBUS1 on BOTTOM (solid shape): 312.45,29.14 312.45,27.01 311.69,26.25 308.54,26.25 308.34,26.44 308.34,28.93 308.78,29.37 312.22,29.37
+VBUS1 on BOTTOM (solid shape): 319.69,34.35 319.69,34.16 319.51,33.98 319.29,33.98 318.84,33.53 317.93,33.53 317.89,33.58 317.89,34.4 317.99,34.5 319.54,34.5
+VBUS1 on BOTTOM (solid shape): 318.89,32.06 319.57,32.06 319.6,32.04 319.6,31.64 319.54,31.58 318.15,31.58 318.07,31.51 317.97,31.51 317.91,31.57 317.91,32.44 317.93,32.46 318.49,32.46
+VBUS1 on VCC1 (solid shape): outline of 244 points within 288.91,27.16 320.78,63.61
+VBUS1 on VCC2 (solid shape): outline of 244 points within 288.91,27.16 320.78,63.61
+VBUS1 on IN3 (solid shape): outline of 872 points within 305.34,27.38 319.53,35.39
+VCC_SYS_HV on TOP (solid shape): 291.65,59.26 291.65,59.03 291.82,58.86 292.06,58.86 292.16,58.76 292.16,58.6 292.08,58.53 291.7,58.53 291.62,58.45 291.62,58.15 291.59,58.11 291.47,58.11 291.44,58.12 291.4,58.12 291.37,58.12 291.34,58.15 291.34,58.4 290.89,58.86 290.89,59.21 291.01,59.34 291.57,59.34
+VCCDSW on TOP (solid shape): 249.27,43.14 250.62,43.14 250.9,42.86 250.9,42.66 250.39,42.15 248.48,42.15 248.41,42.22 248.41,42.65 247.9,43.16 246.79,43.16 246.58,43.36 246.58,43.99 246.64,44.05 248.36,44.05
+VCCGT on TOP (solid shape): outline of 2607 points within 53.93,111.26 94.39,163.94
+VCCGT on BOTTOM (solid shape): outline of 3067 points within 62.39,111.01 94.51,137.83
+VCCGT on IN1 (solid shape): outline of 7063 points within 55.23,111.28 94.25,153.96
+VCCGT on IN2 (solid shape): outline of 4168 points within 72.88,111.28 94.25,137.4
+VCCGT on VCC1 (solid shape): 87.61,136.33 87.61,134.47 87.62,134.43 87.65,134.38 90.7,131.34 90.74,131.31 90.79,131.3 93.27,131.3 94.6,129.98 94.6,124.24 94,123.64 93.97,123.6 93.96,123.55 93.96,111.36 81.44,111.36 80.75,112.05 80.75,122.03 80.74,122.08 80.72,122.12 77.58,125.26 77.58,128 77.57,128.05 77.54,128.09 77.16,128.47 77.12,128.5 77.07,128.51 75.85,128.51 75.13,129.23 75.09,129.26 75.04,129.27 74.33,129.27 72.71,130.88 72.67,130.91 72.62,130.92 66.45,130.92 66.27,131.1 66.27,134.09 66.27,134.14 66.24,134.18 65.89,134.53 65.89,137.9 86.03,137.9
+VCCGT on VCC2 (solid shape): 87.61,136.33 87.61,134.47 87.62,134.43 87.65,134.38 90.7,131.34 90.74,131.31 90.79,131.3 93.27,131.3 94.6,129.98 94.6,124.24 94,123.64 93.97,123.6 93.96,123.55 93.96,111.36 81.44,111.36 80.75,112.05 80.75,122.03 80.74,122.08 80.72,122.12 77.58,125.26 77.58,128 77.57,128.05 77.54,128.09 77.16,128.47 77.12,128.5 77.07,128.51 75.85,128.51 75.13,129.23 75.09,129.26 75.04,129.27 74.33,129.27 72.71,130.88 72.67,130.91 72.62,130.92 66.45,130.92 66.27,131.1 66.27,134.09 66.27,134.14 66.24,134.18 65.89,134.53 65.89,137.9 86.03,137.9
+VCCGT on IN3 (solid shape): outline of 10374 points within 55.3,111.28 94.26,152.2
+VCCGT on IN4 (solid shape): outline of 4417 points within 66.59,111.28 95.27,137.9
+VCCIO on TOP (solid shape): 110.47,119.05 110.47,118.47 111.04,117.9 111.04,117.44 110.93,117.33 110.87,117.33 110.85,117.33 110.79,117.32 110.73,117.33 110.71,117.33 110.52,117.33 110.42,117.23 110.42,115.55 110.55,115.42 110.95,115.42 111.08,115.3 111.08,113.39 110.95,113.27 110.52,113.27 110.4,113.39 110.4,114.35 110.08,115.12 109.7,114.38 109.7,113.44 109.63,113.37 109.15,113.37 109.07,113.44 109.07,114.83 109.05,114.86 109.02,114.91 109.01,114.97 109.01,115.05 109.04,115.12 109.07,115.16 109.07,115.17 109.13,115.23 109.14,115.23 109.57,115.55 109.18,115.93 109.11,115.96 109.07,116.03 109.07,117.76 109.31,117.99 109.56,118.19 109.55,118.52 109.55,118.76 109.59,118.87 109.59,118.99 109.72,119.12 110.39,119.12
+VCCIO on BOTTOM (solid shape): 112.74,157.86 114.3,157.86 114.45,157.72 115.8,157.72 115.93,157.59 115.93,156.06 114.16,154.29 107.3,154.29 106.91,154.67 106.91,158.1 107.04,158.22 112.38,158.22
+VCCIO on BOTTOM (solid shape): outline of 118 points within 107.71,112.93 111.27,122.97
+VCCIO on IN1 (solid shape): outline of 6364 points within 95.89,102.46 123.49,156.78
+VCCIO on IN2 (solid shape): outline of 2428 points within 108.31,109 124.29,124.77
+VCCIO on VCC2 (solid shape): 119.14,153.43 119.19,153.41 119.23,153.4 120.38,153.4 120.38,135.42 119.91,134.95 119.88,134.9 119.87,134.86 119.87,134.47 119.88,134.43 119.91,134.38 120.38,133.91 120.38,130.59 119.65,129.87 119.62,129.82 119.61,129.78 119.61,126.6 119.62,126.55 119.65,126.51 119.91,126.26 119.95,126.23 120,126.22 120.71,126.22 124.19,122.74 124.19,106.33 119.69,101.84 115.68,101.84 115.63,101.83 115.59,101.8 110.29,96.5 94.14,96.5 93.58,97.06 93.58,106.74 94.18,107.33 94.21,107.38 94.21,107.42 94.21,111.11 107.8,111.11 107.85,111.12 107.89,111.14 109.04,112.29 109.06,112.33 109.07,112.38 109.07,114.66 109.06,114.71 109.04,114.75 107.8,115.99 107.8,141.03 110.05,143.27 110.08,143.32 110.09,143.36 110.09,155.25 111.67,156.83 115.75,156.83
+VCCIO on IN3 (solid shape): outline of 3140 points within 71.29,104.76 97.14,113.35
+VCCIO on IN4 (solid shape): outline of 1889 points within 108.73,110.22 123.37,123.43
+VCCPFUSE_W20MIL on TOP (solid shape): 242.97,72.92 244.01,72.92 244.02,72.9 244.02,72.4 243.9,72.27 242.73,72.27 242.5,72.04 242.36,71.9 241.55,71.9 241.43,72.02 241.43,72.59 241.54,72.69 241.86,72.73 242.04,73.01 242.22,73.18 242.71,73.18
+VCCPGPPCD_W15MIL on BOTTOM (solid shape): 238.21,48.75 238.21,48.31 238.33,48.18 238.33,48.1 238.41,48.03 238.41,48.02 238.46,47.95 238.53,47.89 238.54,47.89 239.18,47.26 239.18,47.16 238.9,46.89 238.8,46.89 238.04,47.64 237.52,47.64 237.05,48.11 237.05,48.19 237.12,48.26 237.22,48.26 237.31,48.18 237.52,48.18 237.87,48.52 237.87,48.77 237.9,48.8 238.03,48.78 238.15,48.8
+VCCPLL_OC on TOP (solid shape): outline of 750 points within 74.23,106.48 80.7,111.33
+VCCPLL_OC on IN3 (solid shape): outline of 5545 points within 78.47,92.36 112.58,111.13
+VCCSA on TOP (solid shape): outline of 1682 points within 96.48,123.98 119.54,155.06
+VCCSA on BOTTOM (solid shape): outline of 707 points within 102.65,123.3 111.53,152.22
+VCCSA on IN1 (solid shape): 109.53,151.8 109.53,150.25 109.33,150.04 104.88,150.04 104.65,150.27 104.65,151.9 104.96,152.2 109.12,152.2
+VCCSA on IN1 (solid shape): outline of 874 points within 107.46,124.19 116.45,141.27
+VCCSA on IN2 (solid shape): outline of 1622 points within 102.55,124.24 117.43,152.66
+VCCSA on VCC1 (solid shape): 111.65,153.43 111.69,153.41 111.74,153.4 120.38,153.4 120.38,135.42 119.91,134.95 119.88,134.9 119.87,134.86 119.87,134.47 119.88,134.43 119.91,134.38 120.38,133.91 120.38,130.59 119.65,129.87 119.62,129.82 119.61,129.78 119.61,126.65 117.28,124.31 113.9,124.31 113.85,124.31 113.81,124.28 112.45,122.92 110.27,122.92 109.04,124.15 109,124.18 108.95,124.19 107.8,124.19 107.8,141.08 107.79,141.13 107.77,141.17 97.32,151.62 99.47,153.78 104.25,153.78 104.3,153.79 104.34,153.82 105.7,155.18 109.91,155.18
+VCCSA on IN3 (solid shape): outline of 1333 points within 102.11,123.12 117.07,152.01
AGND on TOP (solid shape): 6.48,45.52 8.03,45.52 8.22,45.33 8.22,45.08 7.95,44.81 7.22,44.81 5.95,43.54 4.55,43.54 4.3,43.8 4.3,45.57 4.43,45.7 6.31,45.7
AGND on TOP (solid shape): 3.23,41.1 3.23,38.79 3.03,38.59 3.03,37.32 2.77,37.07 2.52,37.07 2.39,37.19 2.39,39.38 2.55,39.53 2.55,40.7 2.39,40.85 2.39,41.33 2.47,41.41 2.93,41.41
AGND on TOP (solid shape): 15.6,45.32 15.6,42.65 15.09,42.15 14.71,42.15 14.61,42.25 14.61,42.65 14.74,42.78 15.11,42.99 15.06,43.41 15.04,43.48 15.15,43.8 15.06,44.05 15.06,44.45 15.04,45.09 14.46,44.81 13.27,44.81 13.21,44.86 13.21,45.51 13.25,45.55 14.38,45.55 14.54,45.7 15.22,45.7
AGND on TOP (solid shape): 61.32,14.08 63.86,14.08 63.99,13.95 63.99,12.94 64.75,12.17 64.75,11.67 64.62,11.54 62.08,11.54 61.96,11.67 59.37,11.67 58.86,11.16 56.5,11.16 56.37,11.28 56.37,11.54 56.47,11.64 57.29,11.64 57.44,11.79 57.51,11.8 57.67,11.86 57.79,11.98 57.85,12.02 57.92,12.02 58.46,12.28 58.08,12.75 58.06,12.75 57.85,12.96 57.15,12.96 56.85,12.66 55.63,12.66 55.48,12.81 55.48,13.57 55.61,13.7 55.86,13.7 55.87,13.71 55.9,13.7 56.14,13.74 56.31,13.92 56.32,13.95 60.31,13.95 60.56,14.21 61.19,14.21
AGND on BOTTOM (solid shape): 63.48,12.43 64.28,12.43 64.68,12.04 64.68,11.87 64.37,11.56 63,11.56 62.97,11.59 62.97,12.19 62.84,12.33 62.84,12.52 63.02,12.71 63.2,12.71
AGND on BOTTOM (solid shape): 60.41,14.71 61.14,14.71 61.18,14.68 61.19,14.45 61.32,14.27 61.32,13.8 61.19,13.67 60.92,13.67 60.81,13.77 60.81,13.99 60.5,14.31 60.46,14.31 60.18,14.59 58.39,14.59 58.39,14.22 58.02,13.85 58.02,12.81 58.02,12.76 58,12.74 57.85,12.67 57.75,12.54 57.56,12.54 57.08,12.24 57.44,11.79 57.46,11.77 57.46,11.69 57.44,11.67 57,11.67 56.75,11.92 56.75,12.43 57.51,13.19 57.51,14.2 58.28,14.97 60.15,14.97
AGND on GND1 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on GND2 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on GND3 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on VCC1 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on VCC2 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on GND4 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on GND5 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
AGND on IN4 (solid shape): outline of 96 points within 56.75,11.54 65.89,14.97
AGND on GND6 (solid shape): 62.36,14.59 64.12,14.59 64.12,12.96 64.77,12.3 65.79,12.3 65.89,12.2 65.89,11.64 65.79,11.54 62.06,11.54 61.94,11.67 56.98,11.67 56.75,11.9 56.75,12.45 57.51,13.21 57.51,14.2 58.28,14.97 61.98,14.97
AGND on GND6 (solid shape): 15.6,45.34 15.6,42.63 15.12,42.15 12.83,42.15 12.45,41.76 11.31,41.76 10.65,41.11 10.65,39.75 11.05,39.35 12.32,39.35 12.43,39.25 12.43,34.42 12.96,33.89 13.59,33.89 14.86,32.62 15.37,32.62 15.98,32.01 15.98,30.06 15.22,29.3 15.22,28.07 15.35,27.94 15.35,25.74 15.12,25.51 13.17,25.51 11.41,27.26 11.41,31.84 11.01,32.24 8.21,32.24 7.73,32.73 7.73,34.67 8.11,35.06 8.11,36.66 7.2,37.57 5.34,37.57 4.68,36.92 4.68,32.26 5.46,31.48 5.84,31.48 6.2,31.12 6.2,30.69 6.1,30.59 4.28,30.59 2.39,32.47 2.39,45.09 3.01,45.7 15.24,45.7
GND on TOP (solid shape): 321.95,88.4 310.78,88.4 310.78,90.4 321.95,90.4
GND on TOP (solid shape): 286.84,64.68 286.84,64.19 284.85,64.19 284.78,64.27 284.78,64.62 284.91,64.75 286.76,64.75
GND on TOP (solid shape): 10.45,54.77 10.45,54.31 10.22,54.08 9.2,54.08 9.05,54.24 9.05,55.02 9.15,55.13 10.09,55.13
GND on TOP (solid shape): 11.08,50.1 11.08,49.05 10.52,48.5 9.79,48.5 9.48,48.8 9.48,50.25 9.73,50.5 10.67,50.5
GND on TOP (solid shape): 24.31,23.32 24.31,21.11 24.14,20.94 23.27,20.94 23.09,21.11 23.09,23.35 23.22,23.48 24.16,23.48
GND on TOP (solid shape): 70.51,14.45 70.51,13.39 70.37,13.25 69.79,13.25 69.69,13.35 69.69,14.45 69.81,14.57 70.4,14.57
GND on TOP (solid shape): 70.72,6.71 70.72,5.57 70.59,5.44 67.67,5.44 67.54,5.57 67.54,6.71 67.67,6.84 70.59,6.84
GND on TOP (solid shape): 74.53,176.38 74.53,171.56 74.28,171.3 71.61,171.3 71.35,171.56 71.35,176.64 71.61,176.89 74.02,176.89
GND on TOP (solid shape): 84.05,146.86 84.05,143.49 83.55,142.98 76.56,142.98 76.18,143.36 76.18,146.92 76.63,147.37 83.55,147.37
GND on TOP (solid shape): 92.07,115.3 92.07,112.76 91.94,112.63 91.18,112.63 91.15,112.66 91.15,115.37 91.2,115.42 91.94,115.42
GND on TOP (solid shape): 110.88,55.53 110.88,54.48 110.79,54.38 110.1,54.38 109.95,54.54 109.95,55.51 110.1,55.66 110.75,55.66
GND on TOP (solid shape): 118.45,47 118.45,40.24 117.99,39.78 116.62,39.78 116.44,39.96 116.44,47.45 116.74,47.76 117.68,47.76
GND on TOP (solid shape): 120.66,129.68 120.66,126.82 119.88,126.04 119.28,126.04 119.19,126.14 119.19,129.64 119.46,129.92 120.42,129.92
GND on TOP (solid shape): 123.85,85.31 123.85,83.17 123.78,83.1 122.67,83.1 122.44,83.33 122.44,84.43 123.36,85.34 123.82,85.34
GND on TOP (solid shape): 143.12,92.39 143.12,91.19 142.84,90.91 141.7,90.91 141.6,91.02 141.6,91.84 142.25,92.49 143.02,92.49
GND on TOP (solid shape): 149.28,94.7 149.28,93.76 149.18,93.66 148.24,93.66 148.01,93.89 148.01,94.67 148.16,94.83 149.16,94.83
GND on TOP (solid shape): 155.6,106.37 155.6,105.66 155.54,105.59 153.84,105.59 153.73,105.69 153.73,106.56 153.86,106.68 155.28,106.68
GND on TOP (solid shape): 166.88,142.68 166.88,141.25 166.65,141.02 164.12,141.02 163.99,141.15 163.99,142.6 164.5,143.1 166.46,143.1
GND on TOP (solid shape): 172.97,140.56 172.97,139.89 172.87,139.8 171.58,139.8 171.38,139.99 171.38,140.49 171.53,140.64 172.89,140.64
GND on TOP (solid shape): 173.27,132.8 173.27,132.06 173.23,132.02 171.8,132.02 171.67,132.15 171.67,132.37 172.15,132.86 173.22,132.86
GND on TOP (solid shape): 201.15,109.91 201.15,108.21 200.92,107.98 200.34,107.98 200.21,108.11 200.21,110.12 200.39,110.29 200.77,110.29
