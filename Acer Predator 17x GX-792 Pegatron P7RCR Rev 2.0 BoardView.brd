# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
Y5_R: length 3.5
  BOTTOM w0.121: C2500.1 244.37,70.53 R2525.1 ; C2500.1 244.61,69.93 244.71,69.83 v1(244.71,69.4) ; C2500.1 245.27,70.29 245.31,70.33 Y2500.1
ZVM_TP: length 1.3
  TOP w0.102: T1000.1 89.5,111.99 v3(89.04,111.52)
  BOTTOM w0.102: v3(89.04,111.52) 88.71,111.2 U0300.AT13
N17740100: length 4.5
  TOP w0.102: R8102.1 258.55,61.88 v2(258.55,61.6) 258.55,60.69 258.77,60.47 U8100.1
  BOTTOM w0.102: v1(258.55,60.92) v2(258.55,61.6)
N17742210: length 4.1
  TOP w0.229: R8103.1 258.76,56.01 258.76,57.92 258.68,58 258.68,58.62 258.93,58.87 U8100.5
N21533547: length 5.6
  TOP w0.203: R8300.2 31.07,45.83 30.94,45.83 v1(30.51,45.4) 30.16,45.75 30.16,45.96 C8310.1 29.17,46.95 28.56,46.95 28.12,47.39 U8300.9
N23400012: length 99.6
  TOP w0.102: R9215.2 R9216.2 213.42,21.14 211.94,19.67 209.28,19.67 208.26,18.65 205.47,18.65 v2(204.58,19.54) ; R9207.2 166.1,40.86 R9200.2 SR9209.2 SR9208.2 163.47,41.08 SR9207.2 ; R9207.2 166.43,40.55 166.58,40.39 166.58,39.12 167.49,38.21 168.54,38.21 169.2,37.55 SR9204.2 169.77,38.27 169.48,38.56 169.48,39.62 169.24,39.86 168.87,39.86 168.38,39.37 U9200.2 167.49,39.37 167.39,39.48 167.39,39.86 167.56,40.02 U9200.1 168.08,40.92 167.6,41.41 167.6,42.36 168.7,43.47 177.07,43.47 177.27,43.27 D9200.1 177.88,42.25 178.77,43.14 R9206.2 178.77,44.08 178.9,44.2 179.89,44.2 181.04,43.06 186.24,43.06 186.53,43.35 192.2,43.35 192.89,44.05 v2(193.91,44.05) ; R9207.2 R9208.2
  BOTTOM w0.102: v2(204.58,19.54) 204.58,21.19 203.94,21.83 199.8,21.83 197.67,19.69 194.32,19.69 193.91,20.1 v1(193.91,41.33) v2(193.91,44.05)
N25316574: length 9.3
  TOP w0.102: R9214.2 177.65,39.25 177.72,39.31 SR9206.1 ; R9214.2 178.31,38.89 178.59,38.62 182.23,38.62 182.32,38.71 U9201.4 182.65,39.11 183.24,38.51 v1(183.8,38.51) ; R9214.2 176.99,38.89 176.64,39.25 Q9200.5
N59712038: length 3.9
  TOP w0.102: SR8813.2 272.38,35.91 v1(273.13,35.16) 274.28,35.16 274.97,34.47 U8800.7
N59900925: length 5.8
  TOP w0.102: D9201.1 178.92,36.43 R9205.2 179.34,35.3 182.14,35.3 v1(182.51,34.93)
N60195343: length 5.9
  BOTTOM w0.102: SR8902.2 SR8900.1 252.5,77.95 252.84,77.6 253.37,77.6 254.34,78.57 SR8903.1 255.11,79.19 v1(255.3,79.38)
N60195463: length 8.8
  TOP w0.254: R8912.1 C8915.1 252.36,88.03 v1(252.66,88.03) 253.73,86.96 253.73,85.69 254.13,85.29 254.13,83.2 R8907.2
N60195527: length 3.4
  TOP w0.203: 249.43,84.84 249.17,84.58 U8900.12
  TOP w0.254: R8911.2 C8912.1 249.94,85.19 v1(249.86,85.11) 249.7,85.11 249.43,84.84
N60250597: length 5.4
  TOP w0.102: v1(259.16,76.51) 259.62,76.51 259.87,76.77 259.87,77.86 R9105.2 ; R9105.2 C9118.1 ; R9105.2 259.44,78.63 259.25,78.82 U9102.3
N60250604: length 3.6
  TOP w0.102: v2(260.15,79.46) 260.05,79.57 U9102.5
  BOTTOM w0.102: v1(260.89,79.18) 260.43,79.18 v2(260.15,79.46) 259.8,79.81 259.8,79.94 C9120.1 R9106.2
N60250715: length 0.7
  BOTTOM w0.102: v1(258.63,82.43) 258.63,82.56 v2(259.04,82.96)
N60253878: length 3.5
  TOP w0.102: v1(199.14,35.72) 198.43,35.72 R9100.2
  TOP w0.203: R9100.2 C9100.1 196.64,36.62 U9100.3
N60253885: length 4.5
  TOP w0.102: R9112.2 197.77,38.51 198.94,38.51 v1(199.14,38.72)
  TOP w0.203: U9100.5 196.7,37.42 C9103.1 R9112.2
N60253996: length 3.2
  TOP w0.203: v1(191.45,35.21) 192,35.77 192,35.82 C9109.1 193.02,36.15 193.49,36.62 U9100.12
N60254000: length 2.9
  TOP w0.203: U9100.10 193.48,37.42 193.18,37.72 C9108.1 191.93,38.13 v1(191.93,38.67)
N60314877: length 9.8
  TOP w0.102: U9101.3 242.52,18.25 243.16,17.61 244.29,17.61 244.57,17.89 244.57,18.18 v1(245.01,18.63) 245.14,18.75 245.14,19.54 244.89,19.79 244.56,19.79 244.41,19.95 243.74,19.95 R9104.2 C9111.1 242.77,19.05 U9101.5
N60314934: length 1.3
  TOP w0.102: U9101.12 239.18,18.25 238.94,18.02 C9117.1
N60315047: length 1.3
  TOP w0.102: U9101.10 239.13,19.05 238.89,19.29 C9116.1
N65022721: length 19.1
  TOP w0.121: SR8802.2 260.56,31.88 263.81,28.63 v1(265.89,28.63) 266.93,28.63 267.8,27.77 271.28,27.77 272.88,29.37 272.88,30.28 273.67,31.07 273.67,31.66 274.05,32.04 U8800.12
N65022802: length 79.5
  TOP w0.102: U8800.6 275.37,34.63 275.22,34.78 274.94,34.78 273.98,35.74 273,35.74 272.37,36.38 272.37,36.87 272.09,37.15 271.29,37.15 269.86,35.72 C8814.2 268.66,34.88 D8805.2 267.27,36.04 266.38,36.94 265.27,36.94 264.38,37.83 262.46,37.83 261.04,36.41 259.89,36.41 259.21,35.73 v2(259.21,33.95) ; v2(213.8,22.61) 213.95,22.77 213.95,23.86 213.98,23.88 D8804.2 v1(216.79,22.36)
  IN4 w0.102: v2(213.8,22.61) 213.87,22.69 229.22,22.69 230.12,23.59 241.04,23.59 248.88,31.44 254.11,31.44 257.04,34.37 258.79,34.37 v2(259.21,33.95)
N65023456:
  vias: v1(10.55,75.55)
N65023505: length 18
  TOP w0.121: SR8801.2 261.42,31.73 264.01,29.14 267.13,29.14 268.01,28.27 271.04,28.27 272.37,29.6 v1(272.37,29.88) 272.37,30.49 273.21,31.33 273.21,31.83 273.82,32.44 U8800.11
N68998160: length 4.3
  TOP w0.102: 273.85,39.29 273.88,39.29 274.49,39.9 274.57,39.9 v1(275.22,40.55)
  TOP w0.254: R8816.1 R8817.2 274.25,38.89 273.85,39.29 Q8805.1
N68998162: length 7.2
  TOP w0.102: SR8807.1 269.55,37.35 v1(269.93,36.96) 270.06,36.96 C8827.1 R8815.2 272.22,39.83 271.81,40.24 Q8805.3
N125017610: length 3.3
  BOTTOM w0.089: U0300.A33 115.46,126.6 117.89,126.6 T0301.1
N125034509: length 1.5
  TOP w0.254: R1000.2 79.74,117.76 v3(79.47,117.76) 79.19,117.76 v1(78.92,117.49)
N125034565:
  vias: v1(79.81,122.18) v3(79.52,121.57) v3(80.08,121.57)
N126050588: length 11.6
  BOTTOM w0.089: U2000.AC44 228.35,48.48 228.35,48.44 228.41,48.3 228.44,48.25 228.44,48.02 228.15,47.72 228.15,47.51
  BOTTOM w0.102: R2121.1 R2120.2 ; R2121.1 226.52,41.1 226.22,40.8 226.22,39.35 v1(226.47,39.1) ; R2121.1 226.68,41.46 226.73,41.51 226.73,44 227.26,44.53 227.26,45.65 228.15,46.54 228.15,47.51
N126051220: length 17.3
  TOP w0.102: R2148.1 215.32,43.75 218.18,46.61 v1(218.18,47.13) 218.18,47.19 218.99,48 219.43,48 221.8,50.37 221.8,51.37 223.17,52.74 223.17,52.97 223.41,53.21 225.1,53.21 v2(225.8,52.51)
  BOTTOM w0.102: v2(225.8,52.51) 226.12,52.82 226.18,52.82 U2000.W35
N126053407: length 16.3
  BOTTOM w0.102: U2000.N44 223.15,48.41 223.15,47.94 221.62,46.41 220.55,46.41 219.92,45.78 216.89,45.78 215.53,44.41 215.12,44.41 R2258.1 214.06,43.35 214.06,42.01 214.48,41.59 R2249.2 214.92,40.42 v1(214.92,39.05)
N126053413: length 8.7
  BOTTOM w0.089: 225.04,47.92 225.13,48 225.13,48.27 225.1,48.29 225.1,49.22 U2000.U42
  BOTTOM w0.102: 225.04,47.92 225.02,47.9 225.02,46.86 223.72,45.56 223.22,45.56 222.62,44.97 221.8,44.97 221.52,44.69 v1(221.42,44.69) 221.21,44.69 220.94,44.41 220.94,44 R2208.2
N126053417: length 13.2
  TOP w0.102: R2209.2 219.39,43.34 219.39,44.5 220.85,45.96 v1(222.03,45.96) 223.1,45.96 224.49,47.34 224.49,49.36 225.19,50.06 225.19,50.73 225.09,50.84 v2(224.72,50.84)
  BOTTOM w0.102: U2000.U41 225.25,50.31 v2(224.72,50.84)
N126053497: length 18.5
  TOP w0.102: R2243.2 214.48,44.28 214.92,44.71 v1(215.45,44.71) 215.45,47.84 218.01,50.4 220.17,50.4 221.08,51.3 221.45,51.3 222.97,52.82 222.97,53.12 223.26,53.41 225.49,53.41 v2(225.8,53.73)
  BOTTOM w0.102: v2(225.8,53.73) 225.25,53.17 U2000.U35
N126053501: length 17.9
  BOTTOM w0.102: R2244.2 210.36,41.54 209.96,41.54 209.51,41.99 209.51,43.16 209.63,43.29 210.42,43.29 210.85,43.72 R2255.1 210.85,43.87 v1(213.65,46.67) 213.77,46.79 219.33,46.79 220.2,47.66 220.7,47.66 220.85,47.81 221.4,47.81 221.61,48.02 221.61,48.18 221.99,48.56 U2000.L44
N126053667: length 16.1
  TOP w0.102: v1(212.73,40.85) 213.06,41.18 v2(213.06,41.58)
  BOTTOM w0.102: R2204.2 213.06,41.5 v2(213.06,41.58) 212.88,41.76 212.88,42.3 213.21,42.63 213.21,43.36 R2201.1 212.81,44.13 214.86,46.18 219.66,46.18 220.4,46.92 221.47,46.92 222.61,48.06 U2000.M45
N126061486: length 10.8
  TOP w0.102: v2(236.37,50.18) 235.74,49.55 235.74,46.01 v1(235.9,45.85) 235.9,45.55 236.54,44.9 236.54,43.33 R2347.2 236.56,42.5 236.56,42.14 236.84,41.86 236.84,41.51 236.76,41.43 R2333.2
  BOTTOM w0.102: v2(236.37,50.18) 236.57,50.37 U2000.BA40
N126061517: length 13.6
  TOP w0.102: v2(235.76,50.18) 235.54,49.95 235.54,46.24 235.39,46.08 235.39,45.63 236.34,44.67 236.34,43.34 C2308.1 235.74,42.75 235.74,42.15 236,41.9 236,41.19 R2331.2 235.36,40.56 235.36,38.92 v1(235.79,38.49)
  BOTTOM w0.102: U2000.AW42 235.76,49.97 v2(235.76,50.18)
N126061523: length 9.8
  BOTTOM w0.102: v1(239.43,41.08) 240.1,41.75 240.1,43.66 239.99,43.77 C2309.1 R2332.2 238.21,44.2 238.21,45 236.76,46.45 236.76,46.83 236.09,47.5 U2000.AW45
N126061775: length 9.9
  TOP w0.102: v2(232.76,51.1) v1(231.88,51.1) 231.78,51.1 230.78,50.1 230.78,48.39 231.22,47.95 231.22,45.85 230.77,45.4 230.77,44.33 R2302.2
  BOTTOM w0.102: v2(232.76,51.1) 232.7,51.05 232.53,51.05 U2000.AL39
N126061781: length 9.3
  TOP w0.102: R2303.2 231.92,44.27 231.6,44.58 v1(231.6,44.74) 231.6,45.3 231.83,45.52 231.83,47.86 232.59,48.62 232.59,48.84 233.37,49.62 233.37,50.91 v2(233.79,51.33)
  BOTTOM w0.102: v2(233.79,51.33) 233.69,51.33 U2000.AN38
N126061784: length 9.4
  TOP w0.102: R2304.2 231.03,44.22 230.97,44.28 230.97,45.31 231.43,45.77 v1(231.43,48.5) 231.43,48.66 230.98,49.11 230.98,50.01 231.62,50.65 232.19,50.65 232.35,50.49 v2(232.76,50.49)
  BOTTOM w0.102: v2(232.76,50.49) 233.05,50.2 U2000.AN41
N126071044: length 7.6
  TOP w0.102: R2472.2 241.23,50.3 240.82,50.71 v1(240.37,50.71) 240.14,50.93 239.38,50.93 238.82,51.5 238.18,51.5 237.87,51.8 236.97,51.8 236.47,52.31 v2(235.66,52.31)
  BOTTOM w0.102: U2000.AW35 235.93,52.65 235.93,52.58 v2(235.66,52.31)
N126071761: length 18.5
  TOP w0.102: v2(247.45,53.68) 247.45,53.75 R2429.2 ; v2(233.52,54.35) 233.28,54.11 233.28,54.03 v1(233.03,53.78)
  IN4 w0.102: v2(233.52,54.35) 234.19,55.02 237.57,55.02 240.14,52.46 246.67,52.46 247.45,53.25 v2(247.45,53.68)
  BOTTOM w0.102: U2000.AR31 233.76,54.66 233.76,54.6 v2(233.52,54.35)
N126071895: length 13.2
  BOTTOM w0.102: U2000.BE11 241.01,64.73 241.1,64.82 241.2,64.82 241.61,64.82 242.42,65.64 244.1,65.64 244.31,65.84 244.92,65.84 246.7,67.62 247.39,67.62 247.43,67.67 v1(247.43,67.67) 247.54,67.77 248.29,67.77 248.72,67.34 249.15,67.34 C2401.1 249.82,66.68 R2448.2
N126072312: length 23.5
  TOP w0.102: v2(233.73,56.73) 234.36,56.1 236.49,56.1 236.85,55.74 238.41,55.74 239.14,55.01 240.68,55.01 241.12,54.58 244.57,54.58 244.96,54.97 244.96,55.68 245.22,55.94 246.11,55.94 246.74,56.57 248.54,56.57 R2426.1 249.29,55.83 250.05,55.83 SR2410.1 R2406.2 250.14,57.25 249.54,57.25 249.33,57.46 249.33,58.4 249.43,58.5 v1(249.89,58.5)
  BOTTOM w0.102: U2000.AR27 233.73,56.83 v2(233.73,56.73)
N126072357: length 3
  TOP w0.102: v2(240.16,57.41) 240.57,57.41 T2408.1
  BOTTOM w0.102: v2(240.16,57.41) 238.93,57.41 238.89,57.45 238.68,57.55 238.34,57.55 U2000.BC26
N126072385: length 15.7
  TOP w0.102: T2404.1 251.25,62.87 v2(251.2,62.92)
  BOTTOM w0.102: U2000.BC15 238.29,62.86 241.83,62.86 242.77,63.81 243.81,63.81 244.19,64.18 249.24,64.18 249.51,63.91 250.37,63.91 250.62,63.67 250.62,63.51 v2(251.2,62.92)
N126072389: length 1.3
  TOP w0.102: T2402.1 235.24,62.41 v2(235.41,62.58)
  BOTTOM w0.102: v2(235.41,62.58) 235.41,62.87 U2000.AV15
N126072391: length 5.7
  BOTTOM w0.102: T2401.1 242.51,64.73 242,64.21 241.46,64.21 241.35,64.11 239.59,64.11 239.44,63.95 238.87,63.95 238.68,63.86 237.94,63.86 237.83,63.97 237.8,63.99 U2000.BB13
N126075660:
  vias: v1(242.04,48.11)
N126076879: length 15.4
  TOP w0.102: SR2606.1 240.69,48.51 241.03,48.17 v1(241.33,48.17)
  TOP w0.381: v2(228.2,49.78) 227.74,49.31 C2604.1
  TOP w0.432: v2(238.01,50.27) 238.66,49.62 C2603.1 238.89,49.13 239.08,49.13 239.71,48.51 SR2606.1 ; C2602.1 232.62,49.87 v2(232.76,49.87)
  IN4 w0.508: v2(232.76,49.87) 232.42,49.54 229.09,49.54 228.85,49.78 v2(228.2,49.78)
  BOTTOM w0.203: U2000.AD41 228.66,50.02 228.42,49.78 v2(228.2,49.78) ; v2(238.01,50.27) 238.36,49.92 U2000.BC42 ; v2(232.76,49.87) 232.56,50.07 U2000.AL41 232.2,50.16 232.2,50.36 232.19,50.37 232.19,50.38 231.93,50.65 231.55,50.65 231.15,50.26 U2000.AJ41
  BOTTOM w0.254: U2000.BD40 238.24,50.51 v2(238.01,50.27)
N126183850: length 8.2
  BOTTOM w0.432: v1(69.65,102.12) 69.65,101.71 69.98,101.38 R0734.2 74.03,101.38 75.42,102.76 75.92,102.76 76.4,103.24 U0300.BN1
N126273757: length 1.1
  BOTTOM w0.203: v3(77.31,111.8) 77.64,112.13 U0300.BL14 ; v3(76.66,111.8) 76.99,112.13 U0300.BM14
  vias: v1(75.16,110.67)
N126273866: length 2
  TOP w0.089: v3(86.28,111.52) 85.81,111.98 v1(85.78,111.98)
  TOP w0.254: R1013.1 86.45,111.34 v3(86.28,111.52)
  BOTTOM w0.254: U0300.AY13 85.96,111.2 v3(86.28,111.52)
N126273877: length 1.7
  TOP w0.254: R1013.2 87.5,110.9 v3(88.12,111.52)
  BOTTOM w0.254: v3(88.12,111.52) 87.8,111.2 U0300.AU13
N126462372: length 27.9
  IN1 w0.254: v3(101.82,110.22) 101.9,110.22 102.29,109.82 102.29,107.43 102.89,106.84 109.35,106.84 109.73,106.46 109.73,105.95 110.5,105.19 114.94,105.19 115.37,105.62 118.17,105.62 119.36,104.43 v2(119.36,103.92)
  BOTTOM w0.102: SR1001.1 121.2,102.53 121.39,102.34 122.14,102.34 v1(122.48,102.01)
  BOTTOM w0.254: v3(101.82,110.22) 101.71,110.22 U0300.Y12
  BOTTOM w0.305: SR1001.1 121.2,103.52 C1000.1 120.02,104.35 119.59,103.92 v2(119.36,103.92)
N126463138: length 2.7
  TOP w0.089: v3(110.77,111.26) 110.77,112.28 T1003.1
  BOTTOM w0.102: U0300.H14 110.77,112.07 v3(110.77,111.26)
N126463140: length 2.9
  TOP w0.089: T1002.1 110.06,113.46 v3(109.26,112.66)
  BOTTOM w0.102: U0300.J14 109.49,112.43 v3(109.26,112.66)
N126721657: length 5.3
  TOP w0.102: v3(77.31,113.38) 77.07,113.62 v1(77.07,114)
  TOP w0.254: R1003.2 79.76,114.48 79.26,114.48 79.17,114.56 78.49,114.56 v3(77.31,113.38)
  BOTTOM w0.254: U0300.BL15 77.31,113.31 v3(77.31,113.38) 76.99,113.71 U0300.BM16
N126721746: length 8.6
  TOP w0.254: R1006.2 79.74,116.11 79.46,116.39 77.91,116.39 77.25,115.73 v1(76.59,115.73) 77.12,115.2 77.12,114.76 76.49,114.13 76.49,113.7 75.83,113.04 75.05,113.04 v3(74.71,113.38)
N126721910: length 12.4
  BOTTOM w0.102: R1007.2 65.28,108.83 v1(64.67,109.43)
  BOTTOM w0.381: 73.63,113.61 72.99,113.61 71.86,112.48 71.86,111.86 70.3,110.3 69.73,110.3 69.4,109.97 67.03,109.97 R1007.2
N126721980: length 4.9
  TOP w0.254: v3(76.66,112.59) 77.17,112.59 77.77,113.19 79.74,113.19 R1008.2
  BOTTOM w0.254: U0300.BM15 76.99,112.92 v3(76.66,112.59) 76.66,112.61 76.34,112.93 U0300.BN15
N126722847: length 5.4
  TOP w0.076: v3(78.16,127.74) 78.16,127.85 v1(77.27,128.73) 76.28,128.73 76.02,128.47 74.84,128.47 R1012.2
  BOTTOM w0.102: v3(78.16,127.74) 78.23,127.74 U0300.BJ35 U0300.BJ36
N127662539: length 9.3
  TOP w0.203: U3600.9 9.74,26.31 10.7,25.36 10.7,24.82 10.85,24.67 C3642.1
  TOP w0.432: C3642.1 C3630.1 10.85,22.59 11.02,22.42 C3631.1
  TOP w0.508: SR3602.2 10.92,19.1 v1(11.56,19.74) 11.02,20.29 C3631.1
N129948629: length 3
  TOP w0.229: U3300.10 282.26,102.86 v2(282.48,103.08)
  TOP w0.254: R3306.2 282.66,103.26 v2(282.48,103.08)
  BOTTOM w0.102: v1(283.52,102.9) 282.66,102.9 v2(282.48,103.08)
N129953010: length 5.3
  TOP w0.102: v1(273.81,101.42) 274.21,101.02 274.67,101.02 274.85,100.84 SR3303.1 275.36,99.92 276.49,99.92 276.87,100.3 276.87,100.8 277.03,100.96 U3300.24
N129960916: length 5
  TOP w0.102: C3617.1 v1(13.9,24.24) 13.49,24.24 11.44,26.3 11.16,26.3 10.94,26.51 U3600.12
N129960923: length 3.6
  TOP w0.102: C3617.2 C3618.1 R3607.1 R3606.1 16.39,23.3 v1(16.54,23.45)
N129962294: length 6.1
  TOP w0.229: v2(12.27,27.29) 12.19,27.37 U3600.13
  TOP w0.254: v2(12.27,27.29) 12.44,27.29 12.7,27.54 R3623.1 R3624.1 13.65,26.02 R3603.1
  BOTTOM w0.254: v1(12.83,26.3) 12.83,26.58 12.27,27.13 v2(12.27,27.29)
N129962530: length 8.1
  TOP w0.203: U3600.27 10.14,32.78 10.18,32.81 10.18,33.5 10.03,33.65 10.03,34.46 10.45,34.88 10.45,35.68 C3601.1 9.34,36.79 9.34,38.09 R3600.1
  TOP w0.254: v1(9.18,39.43) 9.18,39 R3600.1
N129962745: length 4.6
  TOP w0.203: C3604.1 7.35,36.23 7.35,34.16 7.34,34.15 U3600.34
N129962763: length 5.1
  TOP w0.203: U3600.37 5.9,32.36 v2(5.89,32.37)
  TOP w0.432: C3603.2 v2(6.89,35.92)
  BOTTOM w0.508: v2(6.89,35.92) 6.71,35.74 6.71,33.18 v2(5.89,32.37)
N129963384: length 14.7
  TOP w0.203: C3613.1 3.79,31.35 v1(4.18,30.96) 4.57,30.57 U3600.40
  TOP w0.508: L3600.2 3.82,41.27 3.82,37.41 2.95,36.55 2.95,32.61 3.49,32.08 C3613.1
N129963392: length 5.3
  TOP w0.216: U3600.46 5.52,28.17 4.88,27.54 4.43,27.54 ; 2.6,30.54 3.44,30.54 3.94,30.04 5.24,30.04 5.37,30.17 U3600.41
  vias: v1(1.78,20.73)
N130075477: length 7.6
  TOP w0.203: U3600.28 9.74,32.87 9.8,32.93 9.8,33.45 9.57,33.68 9.57,34.65 9.94,35.02 9.94,35.44 9.72,35.66 8.78,35.66 8.67,35.77 C3600.1
  TOP w0.254: C3600.1 8.67,36.84 8.53,36.97 8.13,36.97 7.5,37.6 v1(7.5,37.93)
N130159038: length 2.5
  BOTTOM w0.203: U3700.8 63.09,13.56 v1(62.85,13.32) 62.43,12.9 C3709.1
N130159071: length 2.6
  BOTTOM w0.102: U3700.7 63.78,12.8 63.98,12.61 64.38,12.61 65.07,11.92 SR3701.2
N130819676: length 343.9
  TOP w0.254: R3102.1 R3103.1 47.68,129.52 48.24,130.08 v1(48.87,130.08) 49.41,130.08 v2(49.74,130.41) ; R3104.1 210.19,39.63 v2(210.19,39.45) 209.28,38.54 209.28,37.01 R3112.2 ; v2(212.02,39.54) 212.35,39.2 R3105.1
  IN1 w0.254: v2(212.02,39.54) 212.02,37.35 208.54,33.87 206.91,33.87 205.14,32.1 205.14,28.25 202.16,25.27 195.14,25.27 194.13,24.26 190.7,24.26 189.69,25.27 142.95,25.27 140.3,27.92 128.4,27.92 127.67,28.66 119.84,28.66 116.52,25.33 113.6,25.33 112.63,24.37 71.58,24.37 70,22.79 42.63,22.79 41.07,24.35 36.27,24.35 34.6,26.02 32.39,26.02 31.14,27.28 31.14,37.42 30.3,38.26 30.3,44.4 26.15,48.55 25.34,48.55 24.57,49.32 24.57,50.48 18.17,56.89 18.17,59.32 18.04,59.44 18.04,63.86 18.65,64.47 18.65,68.99 20.46,70.81 31.32,70.81 33.83,73.31 33.83,75.77 33.33,76.27 33.33,86.52 40.23,93.42 40.23,102.71 50.66,113.14 50.66,118.16 49.31,119.51 47.29,119.51 44.81,121.99 44.81,124.87 49.74,129.8 v2(49.74,130.41)
  IN3 w0.254: v2(210.19,39.45) 210.19,39.41 210.63,38.97 211.46,38.97 v2(212.02,39.54)
N131362545: length 1.3
  TOP w0.102: T3301.1 281.59,97.25 281.29,97.55 U3300.39
N131362585: length 3.3
  TOP w0.102: U3300.38 280.89,97.56 281.03,97.41 281.03,96.27 281.65,95.65 T3302.1
N131439778: length 5.1
  TOP w0.102: v5(293.47,38.47) 293.8,38.8 U1101.N16
  BOTTOM w0.102: v1(292.88,34.21) 292.88,34.8 292.77,34.91 292.77,35.93 293.55,36.71 R1101.1 293.55,37.58 293.47,37.66 v5(293.47,38.47)
N131441491: length 18.4
  TOP w0.102: v5(294.12,43.67) 293.8,43.35 U1101.N6
  IN4 w0.102: v2(284.32,51.37) 284.32,51.07 284.61,50.78 285.1,50.78 285.65,51.34 286.6,51.34 287.08,50.87 287.08,48.83 288.9,47 291.1,47 292.81,45.3 293.61,45.3 294.44,44.47 294.44,43.99 v5(294.12,43.67)
  BOTTOM w0.102: v1(282.63,50.35) 282.63,50.55 R1102.1 284.24,51.29 v2(284.32,51.37)
N131445423: length 5.2
  TOP w0.102: v5(290.86,37.83) 290.55,38.14 290.55,38.15 U1101.Y18
  BOTTOM w0.102: v5(290.86,37.83) 290.35,37.32 289.82,37.32 289.08,36.58 288.2,36.58 R1108.1 287.32,36.9 v1(286.92,37.29)
N131647000: length 16.6
  TOP w0.102: v5(294.81,44.32) 294.62,44.52 294.58,44.52 U1101.M4
  IN4 w0.102: v5(294.81,44.32) 294.81,44.39 293.65,45.55 292.84,45.55 291.19,47.21 288.98,47.21 287.38,48.81 287.38,50.85 286.64,51.59 285.19,51.59 v2(284.95,51.35)
  BOTTOM w0.102: v2(284.95,51.35) 284.95,51.36 v1(284.27,52.04) 284.13,52.18 R1121.2
N131715858: length 8.8
  TOP w0.102: v1(291.78,51.72) 291.17,51.72 290.68,52.2 290.06,52.2 SR1203.2 290.01,53.11 291.72,53.11 292.65,54.04 293.27,54.04 293.76,54.53 293.76,55.47 U1201.F1
N131716263: length 8.2
  TOP w0.102: v1(284.99,55.63) 285.48,55.15 285.48,54.78 C1208.1 286.59,54.31 286.72,54.44 286.72,54.77 286.95,55 289.52,55 290.31,55.79 291.08,55.79 U1201.A2
N131716280: length 3.9
  TOP w0.076: U1201.K1 295.99,55.59 296.4,55.18 296.4,54.87
  TOP w0.102: C1207.1 297.33,53.03 297.34,53.04 v1(297.34,53.55) 296.87,54.02 296.87,54.4 296.4,54.87
N131716387: length 11.6
  TOP w0.102: v1(284.46,53.96) 284.92,53.5 285.38,53.5 285.68,53.19 285.68,53.08 C1221.1 286.55,53.42 287.67,53.42 287.82,53.27 289.87,53.27 289.93,53.33 291.63,53.33 292.55,54.25 293.19,54.25 293.49,54.55 U1201.E1
N135532945: length 5.4
  TOP w0.102: R5201.1 307.93,66.66 v1(307.65,66.38) 306.97,65.69 305.87,65.69 305.62,65.44 305.16,65.44 304.26,64.53 U5200.16
N135533052: length 5.5
  TOP w0.102: U5200.15 304.37,64.03 304.58,64.24 304.58,64.55 305.27,65.23 v1(306.3,65.23) 307.57,65.23 308.11,65.77 R5200.1
N135533327: length 10.8
  TOP w0.102: U5200.6 300.93,64.03 300.64,64.32 298.34,64.32 298.07,64.04 296.34,64.04 296.12,64.26 296.12,65.32 296.2,65.39 296.2,66.29 295.55,66.94 SR5201.2 294.87,67.37 294.85,67.4 294.85,67.76 295.34,68.26 v1(295.38,68.26)
N135533333: length 15.3
  TOP w0.102: U5200.7 300.92,63.53 300.72,63.74 300.72,63.75 300.35,64.12 298.45,64.12 298.1,63.77 296.24,63.77 295.92,64.09 295.92,65.89 v1(295.76,66.05) 295.74,66.07 SR5202.2 294.85,66.41 294.76,66.5 293.61,66.5 293.5,66.61 293.5,67.79 294.14,68.43 294.14,69.45 293.6,69.98 R5211.2
N135533339: length 18.5
  TOP w0.102: U5200.8 300.97,63.03 300.4,63.6 300.4,63.68 300.2,63.88 298.58,63.88 298.26,63.57 295.51,63.57 295.26,63.82 293.57,63.82 291.93,65.46 286.3,65.46 286.1,65.67 SR5203.2 285.31,66.57 v1(285.25,66.63)
N135676971: length 2.1
  TOP w0.203: C3603.1 6.89,33.81 6.94,33.76 U3600.35
N135678655: length 10.2
  TOP w0.203: C3612.1 4.11,34.36 4.53,33.94 4.53,31.31 4.87,30.97 U3600.39
  TOP w0.254: v1(4.98,38.97) 4.53,38.51 4.53,35.1 C3612.1
N135704866: length 5.8
  TOP w0.102: Q3601.1 22.35,22.7 22.21,22.84 21.19,22.84 21.05,22.7 Q3601.3 21.05,21.43 20.3,20.68 R3622.1 19.97,20.27 19.84,20.14 v1(19.84,19.72)
N135705316: length 11.1
  TOP w0.102: R3622.2 19.11,21.01 19.23,21.14 19.54,21.14 R3604.2 20.55,22.16 20.55,23.1 21,23.54 Q3602.1 22.65,23.54 22.82,23.38 22.82,21.01 22.35,20.55 Q3601.6 23.05,19.62 v1(23.6,20.17)
N135709581: length 2
  TOP w0.203: U3600.19 12.16,29.77 v1(12.45,29.48)
  TOP w0.254: v1(12.45,29.48) 12.6,29.33 R3620.2
N135714980: length 1.5
  TOP w0.229: v2(12.28,27.9) 12.15,27.77 U3600.14
  BOTTOM w0.254: T3602.1 12.66,27.9 v2(12.28,27.9)
N135717456: length 2
  TOP w0.203: C3640.1 13.14,30.72 13,30.57 U3600.21
N135717474: length 3.8
  TOP w0.203: C3639.1 13.53,31.8 12.71,30.97 U3600.22
  TOP w0.254: v1(13.95,33.13) 13.95,32.7 13.53,32.28 C3639.1
N135719044: length 24.7
  TOP w0.229: U3600.20 12.69,30.17 12.98,29.88 v2(13.8,29.88)
  TOP w0.432: R3621.2 v2(3.66,44.94)
  IN4 w0.508: v2(13.8,29.88) 12.88,29.88 11.79,30.97 11.79,32.11 9.76,34.14 9.76,36.18 3.66,42.27 v2(3.66,44.94)
  BOTTOM w0.254: v2(13.8,29.88) 13.87,29.88 14.73,29.01 v1(14.73,28.31)
N136259619: length 0.5
  TOP w0.254: v5(296.09,38.46) 296.08,38.46 U1101.J16
N136259621: length 1.1
  TOP w0.254: v5(295.39,39.11) 295.39,39.11 295.1,38.82 U1101.L16
  BOTTOM w0.305: v5(295.39,39.11) 295.19,38.91 C1183.1
N136630757: length 9.4
  TOP w0.254: v1(230.64,71.36) 230.08,71.36 229.66,70.94 SR2607.1 229.09,69.76 229.93,68.92 229.93,65 v2(229.34,64.42)
  BOTTOM w0.254: U2000.AD13 229.01,64.09 v2(229.34,64.42)
N137154023: length 18.1
  TOP w0.102: v5(294.77,44.94) 294.81,44.94 U1101.L4
  IN4 w0.102: v5(294.77,44.94) 294.77,45.01 293.91,45.88 293.38,45.88 293.07,46.18 293.07,46.64 292.84,46.87 291.81,46.87 291.27,47.41 289.36,47.41 288.6,48.17 288.6,49.92 286.72,51.8 284.59,51.8 283.96,52.43 v2(283.96,52.9)
  BOTTOM w0.102: v2(283.96,52.9) 283.52,53.33 SR1101.1 282.39,53.33 v1(282.28,53.22)
N138223875: length 8.6
  TOP w0.254: R2376.2 229.06,46.13 228.87,46.32 228.87,48.17 229.93,49.23 v1(229.93,50.79) 229.93,52.03 v2(230.48,52.59)
  BOTTOM w0.254: v2(230.48,52.59) 230.67,52.59 U2000.AJ35
N138223878: length 6.9
  TOP w0.254: v2(230.61,46.95) 230.44,46.95 230.13,47.25 230.13,47.84 229.88,48.1 229.52,48.1 229.38,47.96 v1(229.38,47.37) 229.38,46.53 229.57,46.34 229.57,45.95 R2375.1
  BOTTOM w0.178: v2(230.61,46.95) 230.63,46.95 231.06,47.37 231.06,47.75 230.79,48.01 230.79,48.5 U2000.AH44
N138274096: length 6
  BOTTOM w0.102: v1(253.91,41.41) 253.79,41.53 252.96,41.53 252.96,42.45 R2402.1 254.06,42.78 254.24,42.96 254.24,43.92 253.98,44.18 253.4,44.18 253.23,44.34 U2404.1
N138274106: length 2.5
  BOTTOM w0.102: v1(254.72,48.32) 254.72,47.4 R2498.2 255.13,46.99 U2404.4
N138278798: length 2.8
  TOP w0.102: SR3107.2 206.19,20.97 v2(206.48,20.68) v1(206.48,20.02)
  BOTTOM w0.102: v2(206.48,20.68) 206.75,20.95 CON3104.12
N138336439: length 6
  TOP w0.102: v1(34.31,27.86) 35.05,28.59 SR5104.2 35.7,28.81 36.16,28.34 36.16,27.74 v2(36.34,27.56)
  BOTTOM w0.102: CON5102.50 37.32,26.7 36.46,27.56 v2(36.34,27.56)
N138434716: length 9.2
  TOP w0.102: v2(47.1,115.3) 46.78,114.98 U5001.4
  BOTTOM w0.102: v2(47.1,115.3) 44.25,118.14 v1(43.82,118.14) 43.82,118.57 43.72,118.68 C5005.1 43.29,119.54 43.29,119.95 R5015.2
N138434827: length 3.1
  TOP w0.254: U5001.1 44.75,118.79 44.25,119.29 R5012.2 v1(44.25,121.37)
N138435027: length 3.2
  TOP w0.102: R5016.2 C5006.1 260.63,90.02 U5002.4
N138435047: length 2.1
  TOP w0.102: R5013.2 260,93.4 260.43,93.83 U5002.1
N138940937: length 4.2
  BOTTOM w0.305: U8001.3 67.93,147.19 67.91,147.17 C8065.2
  BOTTOM w0.432: C8065.2 67.06,146.9 67.06,146.18 66.69,145.82 SR8005.2 65.86,145.82 v1(65.46,145.42)
N138947971: length 1
  BOTTOM w0.102: v1(65,149.26) 65.08,149.33 R8050.1
N138948723: length 2.2
  BOTTOM w0.102: v1(65.59,147.61) 67.16,147.61 67.34,147.78 C8054.2
N138948726: length 2.4
  BOTTOM w0.102: v1(67.66,151.65) 67.6,151.58 67.6,150.48 67.33,150.21 R8050.2
N138949600: length 44.5
  IN3 w0.254: v2(57.13,174.86) 57.97,174.02 57.97,172.4 60.38,169.98 64.43,169.98 66.64,167.77 68.31,167.77 72.16,163.92 73.42,163.92 75.54,161.8 75.54,157.31 76.08,156.78 80.32,156.78 80.63,156.47 80.63,155.68 v2(80.5,155.56)
  BOTTOM w0.229: JP8050.1 v2(80.5,155.56)
  BOTTOM w0.254: R8056.2 58.86,177.32 59.29,177.76 v1(59.72,177.76) 59.72,177.1 59.95,176.87 59.95,176.08 58.15,174.28 57.71,174.28 v2(57.13,174.86) 57.08,174.81 R80125.2
N138949602: length 39.1
  TOP w0.102: v2(57.13,175.65) v1(57.63,176.14)
  IN3 w0.254: v2(81.26,155.56) 81.01,155.81 81.01,156.59 80.47,157.13 76.23,157.13 75.9,157.46 75.9,161.99 73.58,164.3 72.32,164.3 68.47,168.16 66.76,168.16 64.58,170.34 60.53,170.34 58.4,172.47 58.4,174.38 v2(57.13,175.65)
  BOTTOM w0.229: JP8051.1 v2(81.26,155.56)
  BOTTOM w0.254: v2(57.13,175.65) R8057.2
N138949618: length 1.5
  BOTTOM w0.102: v1(74.43,155.96) 75.17,155.22 C8071.2
N138972993: length 6.5
  BOTTOM w0.305: 78.47,181.54 78.47,181.1 78.48,181.08 U8002.3
  BOTTOM w0.457: v1(74.68,183.14) 75.11,183.57 76.3,183.57 76.46,183.41 SR8006.2 77.41,183.41 77.73,183.09 C8066.2 77.73,182.28 78.47,181.54
N138973068: length 46.7
  IN3 w0.254: v2(80.5,171.05) 79.61,170.16 69.66,170.16 69.16,170.67 66.3,170.67 65.13,171.84 64.34,171.84 63.43,172.75 63.43,174.3 61.82,175.92 59.18,175.92 57.22,177.88 50.07,177.88 48.72,176.53 48.72,174.71 v2(48.75,174.68)
  BOTTOM w0.102: v1(48.04,172.85) 48.75,173.57 v2(48.75,174.68) 49.03,174.68 49.36,175.01 50.09,175.01 R8058.2 50.76,175.11 51.54,175.11 51.67,175.24 51.67,175.98 R80130.2
  BOTTOM w0.229: JP8052.1 80.45,171 v2(80.5,171.05)
N138973117: length 5.2
  BOTTOM w0.254: v1(77.2,185.55) 78.39,184.36 79.18,184.36 80.34,183.2 R8051.1
N138973148: length 5.6
  BOTTOM w0.102: C8055.2 79.38,181.54 79.05,181.87 79.05,183.5 78.67,183.88 77.1,183.88 76.64,184.33 v1(75.95,184.33)
N138973150: length 1.1
  BOTTOM w0.254: v1(82.64,181.79) 82.33,182.1 R8051.2
N138973254: length 41.1
  TOP w0.102: v1(48.85,175.42) v2(49.54,175.42)
  IN3 w0.254: v2(49.54,175.42) 49.08,175.88 49.08,176.38 50.22,177.52 57.07,177.52 59.03,175.56 61.67,175.56 63.07,174.15 63.07,172.6 64.2,171.48 64.95,171.48 66.14,170.29 69.03,170.29 69.52,169.81 80.14,169.81 v2(81.39,171.05)
  BOTTOM w0.102: R8059.2 49.41,175.29 v2(49.54,175.42)
  BOTTOM w0.229: JP8053.1 81.46,170.97 v2(81.39,171.05)
N138973270: length 2
  BOTTOM w0.254: v1(87.28,172.96) 86.82,172.96 85.92,173.85 C8072.2
N138993665: length 4.4
  BOTTOM w0.102: SR8007.2 67.15,164.6 66.86,164.6 66.5,164.24 65.94,164.24 v1(65.59,164.6)
  BOTTOM w0.305: U8003.3 68.18,165.73 68.17,165.72 C8067.2
  BOTTOM w0.457: C8067.2 67.29,165.41 SR8007.2
N138993706: length 42.8
  IN3 w0.254: v2(80.5,163.3) 78.67,165.13 76.51,165.13 72.55,169.09 69.22,169.09 68.74,169.58 65.84,169.58 64.73,170.7 60.68,170.7 60.47,170.9 58.83,172.54 58.83,174.63 57.33,176.13 51.21,176.13 v2(49.69,174.61)
  BOTTOM w0.102: R80135.2 R8060.2 50.66,174.17 50.12,174.17 v2(49.69,174.61) 49.43,174.35 v1(49.43,173.9)
  BOTTOM w0.229: JP8054.1 v2(80.5,163.3)
N138993779: length 1.5
  BOTTOM w0.102: v1(65.44,169.02) 66.24,168.22 R8052.1
N138993809: length 2.4
  BOTTOM w0.102: v1(65.74,166.58) 66.1,166.22 67.44,166.22 67.6,166.38 C8060.2
N138993811: length 1.4
  BOTTOM w0.102: R8052.2 67.58,168.09 67.19,168.49 v1(67.19,169.15)
N138993926: length 41.7
  TOP w0.102: v1(50.25,176.51) 49.89,176.51 v2(49.56,176.18)
  IN3 w0.254: v2(49.56,176.18) 50.4,177.02 56.97,177.02 59.26,174.73 59.26,172.61 60.83,171.05 64.87,171.05 65.99,169.93 68.89,169.93 69.37,169.45 72.7,169.45 76.66,165.49 79.08,165.49 v2(81.26,163.3)
  BOTTOM w0.102: R8061.2 v2(49.56,176.18)
  BOTTOM w0.229: JP8055.1 v2(81.26,163.3)
N138993942: length 1.4
  BOTTOM w0.508: v1(74.81,171.43) 75.45,170.79 C8073.2
N139084693: length 1.1
  TOP w0.432: C8086.1 98.48,156.52 v1(98.1,156.14)
N139090790: length 94.3
  TOP w0.102: v2(51.92,189.85) 51.59,190.18 R8067.2 51.59,191.29 v1(51.26,191.62)
  TOP w0.203: v2(97.67,155.46) 97.82,155.3 97.82,153.8 97.05,153.03 96.45,153.03 95.13,151.71 95.13,150.94 94.66,150.48 JP8056.1
  IN1 w0.203: v2(97.67,155.46) 97.82,155.61 97.82,159.47 98.76,160.41 98.76,174.38 97.06,176.08 97.06,176.72 93.23,180.55 91.06,180.55 90.77,180.55 89.95,180.55 89.19,181.31 85.35,181.31 84.31,182.35 77.39,182.35 74.82,184.92 63.56,184.92 62.84,184.2 60.7,184.2 58.98,182.48 53.19,182.48 51.34,184.33 49.69,184.33 48.49,185.53 48.49,188.37 50.48,190.35 51.54,190.35 51.92,189.97 v2(51.92,189.85)
N139090792: length 92.4
  TOP w0.102: 52.33,189.36 52.51,189.54 v1(52.51,190.33) ; 52.33,189.36 52.47,189.22 SR8016.2 ; 52.33,189.36 51.77,189.36 v2(51.29,189.85)
  TOP w0.203: v2(98.36,155.46) 98.13,155.23 98.13,153.63 97.15,152.65 96.55,152.65 95.63,151.73 95.63,150.64 95.79,150.48 JP8061.1
  IN1 w0.203: v2(98.36,155.46) 98.13,155.68 98.13,159.34 99.07,160.28 99.07,174.51 97.36,176.21 97.36,176.84 93.35,180.86 90.94,180.86 90.64,180.85 90.64,180.85 90.08,180.85 89.31,181.62 85.48,181.62 84.44,182.66 77.51,182.66 74.95,185.22 63.43,185.22 62.71,184.5 60.58,184.5 58.86,182.79 53.4,182.79 51.54,184.64 49.82,184.64 48.8,185.66 48.8,188.25 50.6,190.05 51.09,190.05 v2(51.29,189.85)
N139092828: length 3.3
  TOP w0.254: U8005.6 C80066.2 ; C80066.2 SR8002.1 ; C80066.2 102.04,160 v1(102.14,160.1)
N139235634: length 4.4
  TOP w0.102: U5200.9 302,61.87 v1(301.4,61.27) 301.15,61.53 301.15,62.54 300.21,63.48 R5208.2
N139244830: length 5.8
  TOP w0.102: v1(33.46,37.09) 33.66,36.89 35.6,36.89 35.71,36.99 SR5105.2 36.56,37.32 v2(36.68,37.19)
  BOTTOM w0.102: v2(36.68,37.19) 37.18,36.7 CON5102.10
N139245224: length 4.1
  TOP w0.102: SR5102.2 35.2,29.53 35.51,29.22 v2(36.25,29.22)
  BOTTOM w0.102: v2(36.25,29.22) 36.79,29.75 37.68,29.75 37.73,29.7 CON5102.38
N139245248: length 6.1
  TOP w0.121: v1(33.08,26.5) 33.79,26.5 33.95,26.65 35.31,26.65 35.48,26.49 SR5103.2 36.26,26.11 v2(36.43,26.27)
  BOTTOM w0.121: CON5102.52 36.5,26.2 v2(36.43,26.27)
N139703251: length 4.9
  TOP w0.102: v1(214.64,24.7) 214.15,24.21 213.57,24.21 213.06,23.7 Q3107.3 212.32,23.53 211.72,22.92 v2(211.72,22.6)
  BOTTOM w0.102: v2(211.72,22.6) 211.72,22.52 211.75,22.49 CON3104.2
N139978690: length 20.7
  TOP w0.076: 293.73,60.99 293.73,60.45 U1201.F10
  TOP w0.102: R1239.2 R1223.2 280.04,65.01 v1(283.5,65.01) 283.74,65.25 291.57,65.25 293.53,63.28 293.53,61.2 293.73,60.99
N139982576: length 10
  TOP w0.102: v2(290.14,56.45) 289.98,56.45 R1225.2 ; v5(293.36,56.69) 293.49,56.82 U1201.E4
  BOTTOM w0.102: v5(293.36,56.69) 292.96,56.3 290.29,56.3 v2(290.14,56.45) 289.52,56.45 288.98,55.91 287.18,55.91 286.04,57.06 v1(285.53,57.06)
N139982579: length 15.3
  TOP w0.102: U1201.D5 293.04,57.64 v5(293.04,57.09) ; R1224.2 289.97,57.31 v2(289.97,57.46)
  BOTTOM w0.102: v1(280.93,57.59) 280.93,58.27 281.54,58.88 284.31,58.88 285.63,57.56 289.87,57.56 v2(289.97,57.46) 290.07,57.56 291.09,57.56 291.62,57.03 292.98,57.03 v5(293.04,57.09)
N139982678: length 6.2
  TOP w0.076: 293.23,55.46 293.23,55.94 U1201.E2 U1201.F2
  TOP w0.102: 293.23,55.46 293.23,54.61 293.07,54.45 292.37,54.45 291.73,53.8 v1(290.53,53.8) 290.02,53.8 289.92,53.7 R1226.2
N140129538: length 6.2
  TOP w0.102: SR3104.1 181.48,11.57 181.59,11.47 184.67,11.47 v1(184.82,11.61)
  TOP w0.254: U3102.28 179.97,11.99 180.23,11.74 181.09,11.74 SR3104.1
N140129583: length 2.8
  TOP w0.102: R3140.2 180.8,20.4 v1(180.52,20.12) 179.97,19.57 U3102.1
N140177504: length 392.4
  IN2 w0.102: v2(305.29,74) 304.89,74.4 302.99,74.4 302.44,73.86 302.44,71.64 299.48,68.68 293.47,68.68 292.01,67.22 288.25,67.22 286.34,65.31 284.66,65.31 282.91,63.56 279.38,63.56 278.44,62.62 278.44,60.81 266.17,48.55 266.17,47.77 252.12,33.72 250.65,33.72 249.74,32.8 247.34,32.8 240.2,25.66 235.79,25.66 235.39,25.25 226.29,25.25 225.66,24.62 208.55,24.62 208.51,24.58 204.46,24.58 202.16,22.28 184.35,22.28 183.79,22.84 180.46,22.84 180.36,22.74 166.81,22.74 166,21.93 162.9,21.93 160.81,19.84 148.53,19.84 147.31,21.06 145.71,21.06 142.37,17.72 116.89,17.72 114.44,20.17 95.43,20.17 91.57,24.04 62.96,24.04 61.19,22.27 40.48,22.27 36.81,18.6 33.39,18.6 33.11,18.88 27.86,18.88 25.97,20.78 25.97,23.45 23.98,25.43 23.98,30.58 25.1,31.7 25.1,36.38 24.54,36.94 24.54,38.31 23.72,39.14 23.72,41.4 22.99,42.12 22.99,44.03 22.33,44.69 22.33,46.41 19.46,49.28 19.46,57.74 v2(22.28,60.56)
  BOTTOM w0.102: v2(22.28,60.56) 22.28,59.54 23.64,58.18 23.66,58.15 24.19,57.62 24.26,57.55 24.31,57.52 24.95,56.88 25.23,56.59 32.21,56.59 32.33,56.72 R6005.1 32.33,65.8 29.14,68.99 CON6003.1 30.13,70.7 30.42,70.99 30.42,72.72 30.04,73.1 CON6003.2 ; v1(304.4,73.87) 304.53,74 v2(305.29,74) 305.29,74.61 305.83,75.15 Q6001.2
N140177624: length 26.4
  BOTTOM w0.102: CON6002.2 296.13,81.5 296.45,81.82 296.45,83.85 296.78,84.18 ; Q6001.1 306.42,73.25 307.07,73.9 307.07,75.62 C6001.2 R6006.2 305.42,76.26 v1(304.27,77.4) 303.64,77.4 302.16,78.87 302.16,83.37 301.1,84.44 298.94,84.44 298.68,84.18 296.78,84.18 ; 296.78,84.18 296.53,84.44 296.53,85.33 295.95,85.9 CON6002.1
N140414267: length 7.6
  TOP w0.102: U5800.11 299.06,134.15 R5806.1 298.53,134.68 v1(298.53,136.2) 298.53,136.86 299.57,137.9 R5810.1
N140503834: length 2
  TOP w0.102: T3300.1 276.82,101.36 U3300.23
N141163560: length 2.1
  TOP w0.254: v2(12.43,44.99) 12.35,45.07 L6700.2
  BOTTOM w0.254: v2(12.43,44.99) 12.5,44.99 12.79,44.7 CON6700.21
N141163567: length 4.3
  TOP w0.254: v1(10.17,42.65) 10.62,43.11 11.01,43.11 L6701.2 11.82,43.8 v2(12.4,44.38)
  BOTTOM w0.254: CON6700.20 12.79,44.2 12.6,44.38 v2(12.4,44.38)
N141512226: length 10.4
  TOP w0.102: v5(293.9,56.71) 293.99,56.79 U1201.F4
  BOTTOM w0.102: T1209.1 285.38,58.71 287.65,58.71 288.49,57.87 291.97,57.87 292.07,57.77 292.87,57.77 293.9,56.73 v5(293.9,56.71)
N141512229: length 14.5
  TOP w0.102: U1201.G4 294.49,56.75 v5(294.44,56.71)
  BOTTOM w0.102: v5(294.44,56.71) 294.44,57.25 292.63,59.06 292.21,59.06 291.45,58.3 289.06,58.3 287.79,59.56 285.95,59.56 285.69,59.82 T1210.1
N143246738: length 3.5
  BOTTOM w0.102: D9500.2 102.5,13.63 102.06,13.19 v1(101.25,13.19) SR9500.1
N143287072: length 6.2
  TOP w0.102: U1101.AA1 290.31,46.08 289.57,46.82 287.53,46.82 286.42,47.94 286.01,47.94 R1161.2
N143287155: length 31.8
  TOP w0.102: v5(297.39,44.96) 297.08,44.65 U1101.F4
  IN1 w0.102: v2(294.14,61.91) 296.32,59.73 296.32,55.81 296.65,55.48 296.65,50.4 296.09,49.84 296.09,46.26 v5(297.39,44.96)
  BOTTOM w0.102: v2(294.14,61.91) 293.81,61.91 292.6,63.13 288.32,63.13 287.19,62 SR1105.1 283.91,62 v1(282.96,62.95)
N143634505: length 4.1
  TOP w0.102: SR9703.2 203.05,190.52 203.05,190.13 v2(202.06,189.14) 202.06,189.06 201.62,188.61 U9700.5
  BOTTOM w0.102: v2(202.06,189.14) 202.11,189.19 v1(202.11,189.82)
N143634515: length 7.6
  TOP w0.203: R9729.2 196.93,191.6 197.11,191.42 198.81,191.42 v1(199.29,190.94) 199.42,191.07 R9700.1 R9728.1 200.21,191.45 199.79,191.03 199.79,190.34 199.61,190.15 U9700.9
N143634547: length 4.6
  TOP w0.102: v2(195.08,188.27) SR9700.2 195.9,188.08 196.17,187.81 197.16,187.81 197.21,187.87 198.13,187.87 198.18,187.81 U9700.13
  BOTTOM w0.102: v1(194.37,188.27) v2(195.08,188.27)
N143634634: length 4.7
  TOP w0.203: U9700.12 198.2,188.21 197.69,188.73 197.36,188.73 C9711.1
  TOP w0.254: C9711.1 v2(197.44,189.34)
  BOTTOM w0.254: v1(197.06,189.95) 197.06,189.72 v2(197.44,189.34) 197.62,189.16 R9727.1
N143634824: length 3.5
  TOP w0.102: R9723.2 204.43,191.88 204.48,191.93 v1(204.91,191.93) 205.34,191.93 205.39,191.88 R9721.2 R9716.1 C9720.2
N143642319: length 2
  TOP w0.254: C8717.2 130.32,152.96 130.46,152.81 R8744.1 130.46,151.95 130.49,151.92 v1(130.49,151.47)
N143642335: length 2.6
  TOP w0.102: v1(127.25,150.11) 127.78,150.64 R8746.1
  TOP w0.254: R8746.1 C8719.2
N143642423: length 74.2
  TOP w0.102: v1(122.1,151.34) 122.87,151.34 123.25,150.96 R8737.1
  TOP w0.254: v2(124.57,150.3) 124.57,150.55 124.31,150.81 R8738.2 R8737.1
  IN4 w0.254: v2(124.57,150.3) 125.15,150.3 125.48,149.97 129.7,149.97 130.33,150.6 130.33,152 129.19,153.14 129.19,155.1 130.18,156.09 132.57,156.09 137,160.52 147.42,160.52 148.29,161.4 v2(185.83,161.4)
  BOTTOM w0.254: R8739.2 v2(185.83,161.4)
N143646420: length 2.4
  TOP w0.102: R8750.1 184.87,162.41 185.32,161.96 v1(185.32,160.92)
N143646442:
  vias: v1(181.84,162.29)
N143646485: length 25.5
  IN3 w0.635: v4(182.73,180.7) v4(176.76,180.7) 176.76,175.88 180.7,171.94 180.7,164.45 v4(181.84,163.3)
  vias: v1(183.67,180.7)
N143646495: length 22.1
  TOP w0.635: v4(185.27,166.48) v1(184.09,166.48) 183.24,166.48 182.48,165.72
  IN3 w0.635: v4(179.17,179.43) v4(185.14,179.43) 185.27,179.3 v4(185.27,166.48)
N143742448:
  vias: v1(187.94,180.14)
N143746856: length 22.4
  TOP w0.635: v1(147.17,167.24) v4(146.34,167.24) 143.54,167.24 143.16,166.86
  IN4 w0.635: v4(146.34,167.24) 146.34,179.28 v4(146.21,179.41) 140.24,179.41 v4(140.21,179.43)
N143746974: length 1.1
  TOP w0.508: R8752.1 145.13,162.85 v1(145.8,162.85)
N143746980:
  vias: v1(142.47,163.13)
N143747012: length 37.2
  TOP w0.635: v4(147.43,169.53) 147.43,170.16 v1(145.24,172.35) 143.24,174.35 138.66,174.35
  IN3 w0.762: v4(131.93,173.08) 145.01,173.08 147.43,170.67 v4(147.43,169.53) 146.41,168.51 144.89,168.51 143.21,166.83 143.21,164.88 v4(142.4,164.07)
N143748104: length 21.8
  TOP w0.635: 157.59,166.86 157.97,167.24 v1(159.37,167.24) v4(160.76,167.24)
  IN3 w0.635: v4(160.76,167.24) 160.76,178.8 v4(160.13,179.43) v4(154.16,179.43)
N143748222:
  vias: v1(160.13,163.08)
N143748228:
  vias: v1(156.83,163.08)
N143748260: length 27.1
  IN3 w0.635: v4(156.83,164.07) 152.89,168 v4(152.89,182.99) 154.29,181.59 v4(158.86,181.59)
  vias: v1(158.48,180.09)
N143749353: length 21.7
  TOP w0.635: v4(173.72,167.24) v1(172.19,167.24) 170.92,167.24 170.54,166.86
  IN3 w0.635: v4(167.29,179.43) v4(173.2,179.43) 173.72,178.92 v4(173.72,167.24)
N143749471:
  vias: v1(173.08,162.92)
N143749477:
  vias: v1(169.78,163.1)
N143749509: length 24.7
  IN3 w0.635: v4(170.8,180.7) v4(164.83,180.7) 164.83,174.23 168.76,170.29 168.76,165.08 v4(169.78,164.07)
  vias: v1(171,179.2)
N143830677: length 2.6
  TOP w0.102: v1(93.63,183.73) 94.06,183.73 R9717.2 94.55,182.73 94.05,182.24 U9702.5
N143896429: length 4.2
  TOP w0.254: R9101.1 C9106.1 132.37,75.39 v1(131.43,75.39) 131.43,76.21 131.95,76.73 Q9107.1
N143896431: length 2.2
  TOP w0.254: Q9106.2 131.73,71.03 131.48,70.77 SR9105.2 130.61,70.34 v1(130.56,70.29)
N143896453: length 3.9
  TOP w0.254: T9116.1 134.07,74.68 R9101.2 133.46,74.33 133.48,74.3 R9113.1 133.2,74.17 132.59,74.17 132.38,73.96 Q9106.4
N143962240: length 6.2
  TOP w0.102: Q9105.1 239.23,24.43 239.17,24.37 C9134.1 238.79,25.23 R9111.1 238.92,25.76 238.84,25.69 236.91,25.69 236.43,26.17 v1(236.18,26.17)
N143962242: length 2.2
  TOP w0.102: Q9104.2 242.04,28.57 241.95,28.66 SR9104.2 242.8,29.06 v1(242.86,29.12)
N143962269: length 5
  TOP w0.102: Q9104.4 241.39,26.51 241.25,26.65 R9110.1 R9111.2 239.76,26.19 T9113.1
N143992242: length 10
  TOP w0.432: R8706.2 C8701.2 v2(131.93,165.74)
  BOTTOM w0.432: R8705.2 128.96,159.57 129.27,159.87 R8707.1 129.98,160.2 v1(130.46,160.69) 130.46,161.02 131.93,162.49 v2(131.93,165.74)
N143992301: length 1.9
  BOTTOM w0.254: v1(131.04,163.76) R8709.2 R8708.1
N144139004: length 3.1
  TOP w0.102: v1(272.47,31.91) SR8814.2 273.13,32.86 273.91,33.64 U8800.8
N144155601: length 4
  TOP w0.102: v1(272.68,28.12) 272.68,28.47 273.41,29.2 SR8809.2 273.72,30.08 274.23,30.59 U8800.15
N144155620: length 1.5
  TOP w0.102: U8800.16 275.37,30.33 274.78,29.75 T8813.1
N144172051: length 3.6
  TOP w0.102: v1(24.49,31.17) 24.5,31.19 SR5101.2 v2(25.51,30.46)
  BOTTOM w0.102: v2(25.51,30.46) 25.51,29.95 25.76,29.7 CON5103.38
N144184021: length 16.7
  TOP w0.102: v5(295.5,58.69) 295.48,58.69 295.48,58.7 U1201.H7
  BOTTOM w0.102: v5(295.5,58.69) 295.79,58.69 295.89,58.59 295.89,56.47 295.3,55.89 289.59,55.89 289.36,55.66 286.65,55.66 286.42,55.89 285.63,55.89 285.53,55.79 C1229.1 284.99,56.37 283.85,57.51 v1(283.85,57.56)
N144368781: length 5
  TOP w0.305: C80064.2 65,173.41 64.5,172.9 64.5,172.19 64.74,171.95 U8004.3
  TOP w0.432: C80064.2 65.35,174.3 65.39,174.26 SR8003.2 65.89,175.17 v1(65.94,175.22)
N144368944: length 4.7
  TOP w0.305: SR8004.2 56.14,165.12 56.48,165.46 C80019.2 56.95,166.61 v1(57.08,166.73) 57.08,166.91 56.61,167.38 U8006.3
N144464229: length 2.8
  TOP w0.102: v1(48.95,188.81) 49,188.86 C80103.1 C80111.1 SR8019.1
N144464251: length 3.7
  BOTTOM w0.102: C80109.1 C80133.1 49.13,178.72 48.75,178.34 SR8018.1 48.16,178.44 v1(48.16,178.85)
N144464349: length 2
  BOTTOM w0.102: R8096.1 61.45,175.9 v1(61.27,175.72)
  BOTTOM w0.203: R8096.1 61.8,176.64 C8031.2
N144464375: length 15.5
  IN1 w0.254: v2(62.87,181) 62.87,181.52 63.13,181.77 64.4,181.77 64.7,181.46 65.97,181.46 66.22,181.72 v2(75.29,181.72)
  BOTTOM w0.102: v2(75.29,181.72) 74.92,181.34 v1(74.78,181.34) ; v2(62.87,181) 62.87,180.73 62.85,180.7 R8081.1
  BOTTOM w0.254: R8084.2 75.47,181.54 v2(75.29,181.72)
N144464385: length 2.2
  TOP w0.102: v1(57.26,181.57) 57.07,181.57 56.9,181.73 R8049.1
  TOP w0.254: R8049.1 56.39,182.53 C8024.2
N144464387: length 3
  TOP w0.102: v1(55.89,180.42) 56.06,180.6 C8024.1
  TOP w0.254: R80100.1 56.19,181.33 C8024.1 SR8012.2
N144464409: length 2
  TOP w0.254: v1(59.62,184.08) 59.32,184.38 C8033.2 R8080.1
N144464505: length 4
  TOP w0.254: SR8014.1 48.09,183.47 47.81,183.75 v1(47.17,183.75) 47.17,184.28 47.45,184.56 R8099.2 C8007.2
N144465101: length 2.9
  BOTTOM w0.102: C8012.1 47.96,180.93 v1(47.22,180.93)
  BOTTOM w0.203: R8093.2 49.46,181.92 49.43,181.89 C8012.1
N144466140: length 3.3
  BOTTOM w0.102: R8036.1 49.69,185.78 49.71,185.76 C80106.2 v1(47.28,185.27)
N144466150: length 77.8
  TOP w0.102: R8026.2 v2(89.77,152.84) ; R8024.1 v2(53.56,187.86) v1(54.02,187.4)
  IN1 w0.102: v2(91.6,182.61) 91.19,182.2 90.8,182.2 90.51,182.49 90.51,183.18 90.19,183.5 88.18,183.5 86.25,185.43 80.69,185.43 79.6,186.52 65.18,186.52 64.75,186.95 64.75,187.04 63.64,188.15 53.84,188.15 v2(53.56,187.86)
  IN4 w0.102: v2(89.77,152.84) 90.07,153.14 90.53,153.14 95.1,157.72 95.1,164.84 92.16,167.78 92.16,174.53 91.32,175.37 91.32,176.79 92.31,177.78 92.31,179.69 91.6,180.4 v2(91.6,182.61)
N144466400: length 3.4
  BOTTOM w0.102: v1(57.93,174.79) 57.93,175.56 57.01,176.48 R80102.1 56.55,176.94 56.62,177.02 C8018.2
N144466406: length 5
  TOP w0.254: C8008.1 48.93,186.47 v1(48.11,187.28) 49.46,187.28 50.65,186.08 R8047.2
N144466450: length 47.3
  TOP w0.102: v2(51.64,179.53) 51.59,179.59 v1(50.83,179.59)
  IN3 w0.102: v2(51.64,179.53) 50.35,179.53 48.34,177.52 48.34,172.04 50.04,170.34 51.42,170.34 51.67,170.59 58.83,170.59 62.16,167.27 68.09,167.27 72.03,163.33 73.62,163.33 75.06,161.89 75.06,158.2 74.78,157.92 v2(74.66,157.92)
  BOTTOM w0.102: R80101.1 51.42,179.31 v2(51.64,179.53) ; R8082.2 v2(74.66,157.92)
N144466452: length 3
  TOP w0.102: C8007.1 48.93,185.46 48.53,185.86 47.68,185.86 47.5,185.68 v1(47.07,185.68)
  TOP w0.254: R8079.2 C8007.1
N144538696: length 2
  TOP w0.203: R9736.2 R9713.1 208.97,190.99 v1(209.33,190.63)
N144821715: length 5.8
  BOTTOM w0.102: T9607.1 244.25,16.87 242.17,16.87 241.66,17.38 Q8810.3 241.66,18.4 241.24,18.82 SR8812.1
N144850446: length 1.9
  TOP w0.432: C8206.1 SR8200.2 225.36,19.08 v1(225.1,19.34)
N144850458: length 1.6
  TOP w0.102: R8203.1 222.51,12.78 U8200.11
N144850593: length 2.6
  TOP w0.102: U8200.14 224,12.8 223.83,12.63 v1(223.83,11.72) 224.12,11.42 SR8201.2
N144850939: length 5.1
  TOP w0.203: C8216.2 R8208.2 213.54,10.29 213.7,10.14 216.08,10.14 R8207.1
N144852564: length 1.8
  BOTTOM w0.203: 123.15,60.05 123.5,59.7 R8605.2 123.5,58.88 123.55,58.83 C8605.2
  vias: v1(122.08,60.43)
N144852791:
  vias: v1(116.77,61.81)
N144852865: length 3.5
  TOP w0.102: C8602.1 118.62,60.54 118.34,60.54 v1(117.91,60.1)
  TOP w0.203: C8602.1 119.39,60.83 U8601.11
N144854261: length 2.9
  BOTTOM w0.102: v1(103.82,173.36) 104.04,173.13 104.04,171.46 103.74,171.15 SR9400.2
N144854287: length 3.6
  BOTTOM w0.102: U9400.11 104.86,166.02 R9404.1 105.85,165.03 105.85,163.96 v1(106.08,163.74)
N144854381: length 8.5
  BOTTOM w0.102: v1(102.93,160.13) 102.06,160.99 102.06,164.04 102.25,164.23 SR9401.2 102.6,164.63 102.9,164.93 103.39,164.93 103.89,165.44 103.89,165.98 103.36,166.51 U9400.14
N144854559: length 3
  BOTTOM w0.102: v1(106.99,161.86) C9416.2
  BOTTOM w0.254: R9407.1 C9416.2 R9408.2
N144856027: length 5.3
  BOTTOM w0.102: U9600.11 116.24,147.79 115.75,147.3 C9612.1 114.56,147.84 v1(112.12,147.84)
N144858298: length 0.9
  TOP w0.203: R9502.2 94.65,10.09
N144858319: length 22.5
  TOP w0.229: R9505.1 92.36,11.92 92.44,11.84 C9513.1 v1(92.82,13.11) 92.82,13.62 93.4,14.21 102.47,14.21 103.35,15.08 108.29,15.08 108.68,14.69 108.68,12.54 108.39,12.25 JP9501.1
N144858321: length 3.2
  TOP w0.102: R9502.1 94.24,11.49 v1(94.24,12.02)
  TOP w0.203: R9504.2 92.28,11.03 92.34,10.98 C9513.2 93.17,10.98 93.22,11.03 R9502.1
N144858349:
  vias: v1(94.72,2.39)
N144858623:
  vias: v1(93.83,10.07)
N144858714: length 5.8
  TOP w0.102: U9500.11 90.93,8.16 v2(90.94,8.16) 91.04,8.27 C9504.1
  BOTTOM w0.102: v1(93.86,11.13) 90.94,8.21 v2(90.94,8.16)
N144865734: length 28.7
  TOP w0.203: JP8058.1 v2(52.05,160.38)
  IN4 w0.203: v2(52.05,160.38) 53.22,161.55 53.22,165.69 57.82,170.29 61.98,170.29 63.79,172.09 63.79,176.21 64.22,176.64 v2(64.22,177.27)
  BOTTOM w0.102: v1(65.34,177.93) 64.95,177.93 R8062.2
  BOTTOM w0.152: v2(64.22,177.27) 64.22,178.26 R8062.2 64.42,178.87 64.37,178.92 R80140.2
N144865773: length 0.7
  BOTTOM w0.102: v2(56.62,167.95) 56.47,168.1 v1(56.47,168.59)
N144865775: length 1
  TOP w0.102: v1(57.26,171.72) 57.13,171.59 R8071.2
N144865814: length 29.6
  TOP w0.203: JP8057.1 v2(52.94,160.38)
  IN4 w0.203: v2(64.24,175.95) 64.09,175.8 64.09,171.97 62.11,169.98 57.94,169.98 53.52,165.56 53.52,160.97 v2(52.94,160.38)
  BOTTOM w0.102: v1(64.67,175.44) 64.67,175.52 v2(64.24,175.95)
  BOTTOM w0.152: v2(64.24,175.95) 64.24,176.41 65.03,177.2 65.49,177.2 66.1,177.81 66.1,178.87 65.67,179.3 R8064.2
N144865830:
  vias: v1(47.73,171.84)
N144865965: length 41.4
  TOP w0.203: v2(63.1,160.38) JP8059.1
  IN4 w0.203: v2(70.93,178.64) 70.45,178.16 69.14,178.16 68.25,177.26 68.25,173.57 69.03,172.79 69.03,169.83 70.14,168.72 70.14,163.74 69.17,162.77 65.49,162.77 v2(63.1,160.38)
  BOTTOM w0.152: v2(70.93,178.64) 73.51,178.64 73.84,178.98 73.84,184.54 73.46,184.92 v1(71.13,184.92) 70.67,184.92 70.21,184.46 R80145.2 R8063.2
N144865996: length 2.3
  TOP w0.457: C80042.1 63.88,174.9 R8065.1 63.1,175.47 v1(62.69,175.88)
N144866034: length 6.1
  TOP w0.102: v1(64.27,176.64) 63.76,176.13 63.76,175.75 64.55,174.96 64.55,174.05 64.29,173.79 C80042.2
  TOP w0.305: U8004.5 63.74,172.43
  TOP w0.457: C80042.2 64.12,173.21 63.74,172.83 63.74,172.43
N144866048: length 6.1
  TOP w0.254: v1(61.07,176.51) 61.07,176.38 62.41,175.04 62.41,174.07 62.93,173.56 R8065.2
  TOP w0.305: 63.07,172.37 62.74,172.04 U8004.7
  TOP w0.457: R8065.2 63.1,172.4 63.07,172.37
N144866127: length 30.1
  TOP w0.203: JP8060.1 62.44,160.38 v2(63.1,161.04)
  IN4 w0.203: v2(70.24,178.65) 69.2,178.65 67.94,177.39 67.94,173.45 68.72,172.67 68.72,169.7 69.83,168.59 69.83,163.87 69.04,163.08 65.13,163.08 v2(63.1,161.04)
  BOTTOM w0.102: v2(70.24,178.65) 70.8,178.09 v1(71.81,178.09)
  BOTTOM w0.152: R8066.2 70.71,179.01 70.6,179.01 v2(70.24,178.65)
N144868520: length 5.4
  BOTTOM w0.102: R8030.1 62.75,188.28 63.61,189.14 63.61,190.91 v1(63.15,191.37) 62.51,190.73 C8016.2
N144868544: length 37.8
  TOP w0.203: R8088.1 v2(47.73,160.43)
  IN4 w0.203: v2(47.73,160.43) 47.99,160.18 48.39,160.18 48.67,160.46 48.67,162.59 57.03,170.95 61.5,170.95 62.8,172.24 62.8,177.3 65.46,179.97 65.46,181.2 v2(68.56,184.29)
  BOTTOM w0.102: v2(68.56,184.29) 68.31,184.55 v1(68.31,184.94)
  BOTTOM w0.152: R8094.2 v2(68.56,184.29)
N144868550: length 11.5
  TOP w0.102: R8039.2 59.29,180.47 59.29,182.33 61.3,184.33 v1(61.3,188.02) v2(61.3,189.8)
  BOTTOM w0.102: R8031.1 v2(61.3,189.8)
N144868676: length 1.8
  BOTTOM w0.102: C8034.2 72.74,181.89 v1(72.94,182.09)
  BOTTOM w0.152: C8034.2 72.04,181.46 71.99,181.41 R8043.2
N144868752: length 1.8
  BOTTOM w0.102: C8021.2 v1(64.9,185.55)
  BOTTOM w0.203: R8037.1 63.33,185.6 63.38,185.55 C8021.2
N144868763: length 7.1
  BOTTOM w0.102: C8021.1 64.27,185.07 65.31,185.07 66.27,186.04 v1(66.27,186.77)
  BOTTOM w0.203: R8020.2 65.62,183.72 65.16,184.18 64.4,184.18 C8021.1 63.46,184.69 63.4,184.74 R8015.1
N144868949: length 5.5
  BOTTOM w0.102: v1(65.82,188.86) 64.52,188.86 63.3,187.64 63.3,187.26 62.95,186.9 62.69,186.9 C8009.2 R8023.1
N144869080: length 3.1
  BOTTOM w0.102: R8040.1 69.73,179.36 v1(69.15,178.77)
  BOTTOM w0.152: C8036.2 C80110.2 R8040.1
N145218678: length 4.1
  BOTTOM w0.102: v1(276.23,60.61) 276.72,60.12 SR3109.1
  BOTTOM w0.432: U3103.5 276.39,57.5 276.66,57.77 C3105.1 276.66,58.68 276.72,58.74 SR3109.1
N145218686: length 8.4
  BOTTOM w0.102: R3167.2 275.01,58.76 274.73,59.04 R3168.1 SR3108.2 274.21,57.75 272.98,56.52 v1(272.98,55.28) 274.04,55.28 274.49,54.82 U3103.3
