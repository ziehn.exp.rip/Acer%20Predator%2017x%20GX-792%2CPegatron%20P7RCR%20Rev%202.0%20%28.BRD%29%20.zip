# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_PCIE_TX3_N_C: length 15.6
  BOTTOM w0.102: 216.93,57.8 217,57.8 217.16,57.97 217.24,58.05 218.01,58.05 218.06,58.09 U2000.C24
  BOTTOM w0.121: C2018.2 209.63,50.58 209.98,50.93 211.24,50.93 211.74,51.43 211.74,51.83 211.99,52.08 211.99,52.66 212.76,53.42 212.76,53.58 ; 212.76,53.58 212.76,54.11 214.43,55.78 214.43,57 214.81,57.38 214.99,57.38 215.41,57.8 216.93,57.8 ; 212.76,53.58 v1(212.98,53.58)
TBT_PCIE_TX3_P: length 129.7
  TOP w0.089: 296.27,34.83 296.22,34.88 296.22,35.35 296.19,35.38 296.19,35.38 296.05,35.52 296.05,35.52 296.05,35.52 296.05,35.81 296.12,35.88 296.25,35.88 296.29,35.84 U1101.H23
  TOP w0.121: v2(296.92,28.5) 297.19,28.77 297.19,33.61 296.27,34.52 296.27,34.83
  IN4 w0.102: v2(296.92,28.5) 296.92,28.5 297.14,28.72 297.14,29.22 296.88,29.47 288.51,29.47 285.45,32.53 285.45,34.35 281.98,37.82 274.71,37.82 269.97,42.56 267.81,42.56 267.02,43.35 254.81,43.35 254,44.16 251.82,44.16 251.64,44.34 247.24,44.34 243.31,40.4 v2(243.31,39.72)
  BOTTOM w0.121: 214.38,32.31 213.85,32.31 208.1,38.06 208.1,39.61 206.4,41.31 206.4,48.45 206.02,48.83 206.02,50.75 206.41,51.14 207.05,51.14 C2019.1 ; 214.38,32.31 227.03,32.31 230.94,36.23 241.56,36.23 243.31,37.97 v2(243.31,39.72) ; 214.38,32.31 v1(214.38,32.09)
TBT_PCIE_TX3_P_C: length 15.5
  BOTTOM w0.102: U2000.B24 217.69,58.24 217.16,58.24 216.96,58.04 216.95,58.04
  BOTTOM w0.121: v1(209,51.03) 209,50.81 ; 209,50.81 209.53,50.81 209.88,51.16 211.14,51.16 211.51,51.53 211.51,51.93 211.76,52.18 211.76,52.76 212.52,53.52 212.52,54.2 214.19,55.88 214.19,57.1 214.71,57.61 214.89,57.61 215.31,58.04 216.95,58.04 ; 209,50.81 208.64,50.81 208.54,50.91 208.54,51.37 208.44,51.46 C2019.2
TBT_PCIE_WAKE_N: length 89.8
  TOP w0.102: v2(290.25,47.94) 290.25,47.53 291.23,46.56 U1101.W1
  IN3 w0.102: v2(257.7,56.98) 256.71,56.98 253.65,53.92 253.65,47.13 252.24,45.71 251.08,45.71 248.88,43.52 240.68,43.52 239.94,42.78 234.14,42.78 233.1,41.74 v2(231.69,41.74)
  IN4 w0.102: v2(290.25,47.94) 290.25,48.55 286.81,52 285.3,52 284.41,52.89 284.41,53.02 282.84,54.6 282.84,55.01 282.32,55.53 281.98,55.53 278.78,52.33 275.2,52.33 274.45,51.59 274.45,51.3 274.01,50.86 267.53,50.86 266.19,52.2 261.88,52.2 260.65,53.43 259.41,53.43 258.99,53.84 258.99,53.88 v2(258.96,53.91)
  BOTTOM w0.089: 229.93,47.45 229.93,47.73 230.04,47.84 230.04,48.36 230.09,48.4 U2000.AG44
  BOTTOM w0.102: 229.93,47.45 229.93,45.33 231.02,44.24 R2305.2 231.5,43.29 231.5,41.93 v2(231.69,41.74) ; v2(290.25,47.94) 289.87,47.94 289.54,48.27 R1138.1 ; v2(258.96,53.91) 258.96,54.17 257.87,55.26 v1(257.7,55.26) v2(257.7,56.98)
TBT_RBIAS: length 1
  TOP w0.102: U1101.H6 296.69,43.05 v5(296.71,43.05)
  BOTTOM w0.102: v5(296.71,43.05) 296.65,43.11 R1107.2
TBT_REFCLK_100_N: length 104.7
  TOP w0.114: U1101.T19 292.17,37.82 v5(292.17,37.82)
  TOP w0.121: SR2520.2 222.47,73.67 222.47,74.23 ; v1(222.69,74.23) 222.47,74.23 ; 222.47,74.23 222.47,74.59 225.71,77.83 228.17,77.83 229.79,79.44 235.4,79.44 236.57,78.28 237.2,78.28 237.64,77.84 238.77,77.84 241.04,75.57 241.04,75.26 v2(240.9,75.11)
  IN1 w0.102: v2(240.9,75.11) 241.31,74.71 241.74,74.71 242.21,74.24 246.45,74.24 247.11,74.9 251.53,74.9 254.44,71.99 254.44,67.95 256.9,65.49 256.9,61.35 259.92,58.33 264.55,58.33 269.26,53.61 269.26,51.89 271.94,49.21 274.33,49.21 275.23,48.31 275.23,47.45 275.66,47.02 279.86,47.02 281.63,45.26 281.63,42.45 282.37,41.71 282.37,38.5 284.73,36.14 287.07,36.14 287.4,36.48 289.08,36.48 289.64,35.91 291.76,35.91 292.18,36.33 292.18,37.01 292.18,37.02 292.18,37.3 292.06,37.42 292.06,37.71 v5(292.17,37.82)
TBT_REFCLK_100_N_R: length 7.9
  TOP w0.121: 221.13,68.3 220.93,68.1 220,68.1 v2(219.44,68.66) ; 221.13,68.3 222.75,69.92 222.75,70.84 222.58,71 222.58,72.25 SR2520.1 ; 221.13,68.3 v1(221.29,68.13)
  BOTTOM w0.121: U2000.E5 219.43,68.66 v2(219.44,68.66)
TBT_REFCLK_100_P: length 104.8
  TOP w0.114: U1101.V19 291.85,37.63 291.66,37.82 v5(291.5,37.82)
  TOP w0.121: v2(241.53,75.11) 241.28,75.37 241.28,75.67 238.87,78.07 237.74,78.07 237.3,78.51 236.89,78.51 ; SR2519.2 222.23,73.63 222.23,74.68 225.61,78.07 228.08,78.07 229.69,79.68 235.5,79.68 236.67,78.51 236.89,78.51 ; 236.89,78.51 v1(236.89,78.73)
  IN1 w0.102: v5(291.5,37.82) 291.66,37.82 291.83,37.65 291.83,37.35 291.96,37.21 291.96,36.93 291.97,36.92 291.97,36.42 291.67,36.13 289.73,36.13 289.16,36.69 287.31,36.69 286.98,36.35 284.82,36.35 282.58,38.59 282.58,41.8 281.84,42.54 281.84,45.35 279.95,47.24 275.75,47.24 275.44,47.54 275.44,48.39 274.42,49.42 272.03,49.42 269.47,51.98 269.47,53.7 264.64,58.54 260.01,58.54 257.12,61.44 257.12,65.58 254.65,68.04 254.65,72.08 251.62,75.11 247.02,75.11 246.36,74.45 242.3,74.45 241.64,75.11 v2(241.53,75.11)
TBT_REFCLK_100_P_R: length 7.8
  TOP w0.121: 222.35,71.56 222.35,72.06 SR2519.1 ; 222.35,71.56 222.35,70.9 222.52,70.74 222.52,70.02 220.83,68.33 220.16,68.33 220.08,68.41 v2(220.08,68.66) ; 222.35,71.56 v1(222.13,71.56)
  BOTTOM w0.121: v2(220.08,68.66) 219.71,68.29 219.71,68.13 219.83,68.02 220.21,68.02 U2000.G4
TBT_RESET_N: length 12.6
  TOP w0.102: U1201.F11 294.14,60.85 v2(294.14,61.27)
  BOTTOM w0.102: v2(294.14,61.27) 292.53,62.87 288.48,62.87 286.76,61.16 SR1105.2 283.76,61.16 v1(283.6,61.32)
TBT_RSENSE: length 1.4
  TOP w0.102: U1101.J6 v5(296.07,43.67)
  BOTTOM w0.102: v5(296.07,43.67) 295.87,43.67 R1107.1
TBT_SLP_S3_N: length 22.3
  TOP w0.102: SR1104.1 R1131.1 283.9,53.58 284.51,52.97 284.51,52.71 284.87,52.36 285.38,52.36 285.55,52.18 289.79,52.18 290,51.97 290.54,51.97 291.29,51.21 292.49,51.21 293.05,51.77 293.83,51.77 294.47,51.14 295.37,51.14 295.68,50.83 297.2,50.83 297.9,50.14 297.9,45.58 U1101.D2
TBT_SLP_S3_N_BUF: length 20.2
  TOP w0.102: SR1104.2 280.3,54.41 279.79,54.92 279.79,56.88 v2(279.81,56.9) ; v2(273.23,49.94) v1(273.23,50.6)
  IN2 w0.102: v2(273.23,49.94) 274.38,51.09 274.38,51.47 v2(279.81,56.9)
  BOTTOM w0.102: U1105.4 272.92,48.46 273.23,48.78 v2(273.23,49.94) 273.23,50.68 272.4,51.51 R1117.2
TBT_SNK1_DDC_CLK: length 6.7
  TOP w0.102: v5(290.87,42.37) 290.87,42.37 U1101.Y8
  BOTTOM w0.121: v5(290.87,42.37) 290.71,42.53 290.67,42.53 290.35,42.85 290.15,42.85 290.15,42.85 289.88,42.85 289.57,43.16 R1143.1 288.07,42.63 R1169.2 287.13,41.69 v1(285.91,41.69)
TBT_SNK1_DDC_DATA: length 28.5
  TOP w0.121: v5(294.08,44.32) 294.08,44.36 U1101.N4
  IN4 w0.083: v5(294.08,44.32) 293.47,44.94 292.86,44.94 291.01,46.78 288.53,46.78 v2(285.3,50.02)
  BOTTOM w0.121: v1(286.37,47.73) 287.18,47.73 R1170.2 288.07,47.63 288.42,47.99 289.46,47.99 289.95,47.51 290.84,47.51 291.4,46.95 293.58,46.95 293.94,46.59 293.94,44.47 v5(294.08,44.32) ; R1144.1 281.73,50.84 282.17,50.4 282.17,50.18 282.45,49.91 282.82,49.91 283.06,50.16 283.06,50.2 283.3,50.44 284.3,50.44 284.71,50.02 v2(285.3,50.02)
TBT_TCK: length 15.4
  TOP w0.102: U1101.T4 292.48,44.65 v5(292.16,44.33)
  IN4 w0.102: v5(292.16,44.33) 292.16,44.81 291.67,45.3 289.97,45.3 289.61,44.94 288.59,44.94 284.2,49.33 v2(281.59,49.33)
  BOTTOM w0.102: T1103.1 281.21,48.95 v2(281.59,49.33) R1114.2
TBT_TDI: length 9.5
  TOP w0.102: U1101.Y4 290.55,44.63 290.86,44.31 v5(290.86,44.31)
  BOTTOM w0.102: R1112.2 T1101.1 285.73,45.75 286.67,45.75 286.98,45.45 288.4,45.45 288.6,45.24 289.87,45.24 290.25,45.63 290.84,45.63 291.17,45.3 291.17,44.62 v5(290.86,44.31)
TBT_TDO: length 14.4
  TOP w0.102: U1101.W4 291.22,44.65 v5(291.52,44.95)
  IN4 w0.102: v2(282,47.99) 282.02,47.99 282.4,47.61 284.65,47.61 286.3,45.96 287.11,45.96 288.46,44.61 289.78,44.61 290.12,44.95 v5(291.52,44.95)
  BOTTOM w0.102: R1115.2 282.51,48.47 282.02,47.99 v2(282,47.99) 280.83,47.99 T1104.1
TBT_TEST_EN: length 20.2
  TOP w0.102: U1101.E1 297.67,50.08 297.12,50.63 295.59,50.63 295.29,50.93 294.27,50.93 293.66,51.54 293.27,51.54 292.64,50.91 291.21,50.91 290.35,51.77 289.91,51.77 289.7,51.98 285.47,51.98 285.39,52.05 284.46,52.05 v1(284.28,52.23) 283.83,52.23 R1128.1
TBT_TEST_PWG: length 7.5
  TOP w0.102: U1101.AB5 289.62,44.19 288.59,44.19 287.03,45.75 285.81,45.75 v1(285.55,46.01) 284.81,46.75 283.84,46.75 283.83,46.74 R1129.1
TBT_TMS: length 15.4
  TOP w0.102: U1101.V4 291.52,44.33 v5(291.52,44.33)
  IN4 w0.102: v2(281.06,47.4) 283.85,47.4 286.95,44.3 290,44.3 290.38,44.69 291.16,44.69 v5(291.52,44.33)
  BOTTOM w0.102: T1102.1 281.46,47 v2(281.06,47.4) 281.59,47.4 281.67,47.48 R1113.2
TBT_TMU_CLK_OUT: length 5.3
  TOP w0.102: U1101.V2 291.46,45.58 291.46,46.62 290.68,47.4 290.68,48.25 R1139.1 289.96,48.69 v1(289.16,49.49)
TBT_XTAL_25_IN: length 2.7
  TOP w0.121: X1101.1 302.79,31.36 302.52,31.63 C1130.1 R1136.2
TBT_XTAL_25_IN_TBT: length 5.1
  TOP w0.089: U1101.D22 298.35,35.92 298.35,35.51
  TOP w0.121: 298.35,35.51 298.52,35.34 298.87,35.34 300.48,33.73 301.06,33.73 R1136.1
TBT_XTAL_25_OUT: length 5.1
  TOP w0.121: X1101.3 301.76,30.01 301.76,31.32 C1131.1 R1137.2
TBT_XTAL_25_OUT_TBT: length 3.2
  TOP w0.121: R1137.1 299.69,33.5 299.69,33.61 298.13,35.17 U1101.D23
TBTA_AUX_N: length 5.8
  TOP w0.108: U1101.W15 291.2,39.45 v5(291.52,39.12)
  BOTTOM w0.108: 289.82,38.51 289.47,38.51 288.96,39.02 288.65,39.02 288.14,38.5 C1136.2 ; 289.82,38.51 291.04,38.51 291.27,38.74 291.27,38.87 v5(291.52,39.12) ; 289.82,38.51 v1(289.82,38.29)
TBTA_AUX_P: length 5.8
  TOP w0.108: v5(290.87,39.12) 290.87,39.12 U1101.Y15
  BOTTOM w0.108: v1(288.07,39.1) 288.24,38.93 ; 288.24,38.93 288.56,39.25 289.06,39.25 289.56,38.75 290.94,38.75 291.03,38.84 291.03,39.03 290.94,39.12 v5(290.87,39.12) ; 288.24,38.93 288.04,38.74 287.58,38.74 287.48,38.83 287.48,39.12 287.39,39.21 C1137.2
TBTA_CA2HD_0_N_CON: length 23.4
  TOP w0.089: 299.91,36.72 299.8,36.84 299.47,36.84 299.42,36.79 299.42,36.69 U1101.A21
  TOP w0.108: 299.91,36.72 arc(300.03,36.68) 300.16,36.67 300.56,36.67 arc(300.6,36.67) 300.65,36.67 arc(301.28,36.6) 301.89,36.43 arc(303.47,35.55) 304.69,34.21 arc(305.11,33.7) v2(305.62,33.27)
  BOTTOM w0.108: CON1201.B10 319.96,31.23 arc(319.92,31.21) 319.88,31.2 317.58,31.2 arc(317.21,31.17) 316.85,31.07 arc(316.79,31.06) 316.73,31.05 316.73,31.05 arc(316.7,31.06) 316.66,31.07 316.66,31.07 arc(316.43,31.17) 316.24,31.34 arc(316.21,31.37) D1204.1 315.98,31.12 arc(315.92,31.07) 315.84,31.05 311.16,31.05 arc(308.87,31.44) 306.83,32.55 306.77,32.6 arc(306.64,32.68) 306.5,32.73 306.48,32.73 306.39,32.74 306.14,32.74 arc(305.92,32.78) 305.74,32.91 arc(305.67,33) 305.63,33.1 305.63,33.1 arc(305.62,33.16) 305.62,33.21 v2(305.62,33.27)
TBTA_CA2HD_0_P_CON: length 23.5
  TOP w0.089: U1101.B21 299.27,36.39 299.73,36.39 299.77,36.43 300.04,36.43
  TOP w0.108: 300.04,36.43 arc(300.1,36.43) 300.16,36.43 300.55,36.43 arc(300.6,36.43) 300.64,36.43 arc(301.23,36.37) 301.8,36.21 arc(303.32,35.36) 304.5,34.08 304.84,33.57 arc(304.9,33.43) v2(304.92,33.28)
  BOTTOM w0.108: v2(304.92,33.28) arc(305.01,33.26) 305.08,33.22 305.57,32.74 arc(305.83,32.57) 306.14,32.51 306.37,32.51 306.45,32.5 arc(306.54,32.46) 306.62,32.41 306.68,32.37 arc(308.79,31.22) 311.16,30.82 315.44,30.82 arc(315.84,30.74) D1203.1 316.19,30.54 arc(316.31,30.67) 316.47,30.77 arc(316.59,30.81) 316.72,30.82 arc(316.72,30.82) 316.72,30.82 316.73,30.82 arc(316.83,30.83) 316.92,30.85 arc(317.25,30.93) 317.58,30.96 319.55,30.96 arc(319.91,30.88) CON1201.B11
TBTA_CA2HD_1_N_CON: length 22
  TOP w0.089: U1101.B15 299.27,39.15 299.74,39.15 299.88,39.29 300.22,39.29 300.23,39.28 300.26,39.28
  TOP w0.108: 300.26,39.28 300.61,39.28 arc(300.93,39.34) 301.21,39.52 301.28,39.6 arc(302.11,40.15) 303.09,40.34 306.56,40.34 arc(307.87,40.08) 308.98,39.34 313.23,35.09 arc(313.42,34.96) 313.65,34.92 313.66,34.92 arc(313.75,34.9) 313.83,34.85 D1208.1 314.28,34.85 arc(314.37,34.91) 314.48,34.93 317.78,34.93 317.91,34.8 CON1201.A10
TBTA_CA2HD_1_P_CON: length 22
  TOP w0.089: 300.26,39.51 300.23,39.51 300.22,39.5 299.79,39.5 299.69,39.61 299.4,39.61 299.31,39.52 299.31,39.41 299.36,39.37 U1101.A15
  TOP w0.108: 300.26,39.51 300.61,39.51 arc(300.84,39.56) 301.04,39.69 301.12,39.76 arc(302.02,40.37) 303.09,40.58 306.56,40.58 arc(307.96,40.3) 309.15,39.5 313.39,35.26 arc(313.51,35.18) 313.65,35.15 arc(313.73,35.17) 313.79,35.2 D1207.1 314.27,35.24 arc(314.37,35.19) 314.48,35.17 317.78,35.17 317.91,35.3 CON1201.A11
TBTA_DPSRC_AUX_N: length 30.8
  TOP w0.076: U1201.J2 295.74,55.94 295.74,55.25 v2(295.92,55.07)
  IN1 w0.095: v2(295.92,55.07) 295.31,55.07 294.98,54.74 294.98,53.99 295.71,53.26 295.71,52.17 294.56,51.02 293.26,51.02 290.84,48.6 288.43,48.6 287.97,48.15 285.99,48.15 283.27,45.43 283.27,39.1 283.66,38.72 283.83,38.72 v2(284.07,38.48)
  BOTTOM w0.108: C1136.1 286.36,38.74 285.36,38.74 R1155.1 284.85,38.74 284.33,38.74 v2(284.07,38.48)
TBTA_DPSRC_AUX_P: length 30.8
  TOP w0.076: v2(296.12,54.49) 295.93,54.68 295.75,54.68 295.52,54.91 295.52,55.16 295.54,55.17 295.54,55.65 U1201.J1
  IN1 w0.095: v2(296.12,54.49) 295.97,54.64 295.66,54.64 295.48,54.82 295.39,54.82 295.21,54.65 295.21,54.09 295.94,53.36 295.94,52.08 294.65,50.79 293.36,50.79 290.94,48.37 288.52,48.37 288.07,47.91 286.09,47.91 283.51,45.33 283.51,39.2 283.76,38.95 283.99,38.95 284.04,39.01 v6(284.04,39.24)
  BOTTOM w0.108: v6(284.04,39.24) 284.3,38.98 284.84,38.98 R1154.1 285.38,38.98 286.36,38.98 C1137.1
TBTA_HD2CA_0_N_CON: length 17.2
  TOP w0.108: CON1201.A3 317.91,31.3 317.79,31.17 314.66,31.17 arc(314.32,31.25) D1201.1 arc(313.8,31.24) 313.47,31.16 312.91,31.16 arc(312.46,31.26) 312.1,31.53 312.08,31.55 308.76,34.83 308.75,34.84 arc(308.74,34.85) 308.73,34.86 308.72,34.88 arc(308.34,35.22) 307.84,35.34 307.27,35.34 arc(306.77,35.44) 306.36,35.72 305.16,36.92 arc(304.79,37.18) 304.35,37.28 304.22,37.28 arc(303.97,37.34) C1135.2
TBTA_HD2CA_0_P_CON: length 17.2
  TOP w0.108: CON1201.A2 317.92,30.8 317.78,30.94 314.69,30.94 arc(314.34,30.86) D1202.1 arc(313.78,30.84) 313.44,30.91 313.43,30.93 312.91,30.93 arc(312.36,31.04) 311.92,31.38 311.91,31.39 308.61,34.65 arc(308.56,34.69) 308.53,34.74 308.52,34.75 arc(308.23,35.01) 307.84,35.1 307.27,35.1 arc(306.68,35.22) 306.19,35.56 304.98,36.76 arc(304.7,36.97) 304.35,37.04 304.22,37.04 arc(303.97,36.98) C1134.2
TBTA_HD2CA_1_N_CON: length 18.3
  TOP w0.108: C1133.2 303.89,38.46 arc(303.97,38.5) 304.05,38.51 306.5,38.51 arc(306.67,38.44) v2(306.74,38.27)
  BOTTOM w0.108: CON1201.B3 319.98,34.87 arc(319.91,34.91) 319.83,34.93 316.73,34.93 arc(316.53,34.89) 316.36,34.78 D1205.1 arc(316.09,34.83) 315.87,34.93 arc(315.86,34.93) 315.85,34.93 315.13,34.93 arc(314.34,35.08) 313.65,35.5 312.42,36.73 arc(310.54,38.01) 308.31,38.46 306.93,38.46 arc(306.8,38.4) v2(306.74,38.27)
TBTA_HD2CA_1_P_CON: length 18.3
  TOP w0.108: C1132.2 arc(303.85,38.83) 304.06,38.74 arc(304.06,38.74) 304.06,38.74 306.45,38.74 arc(306.47,38.74) 306.48,38.75 arc(306.63,38.79) v2(306.74,38.88)
  BOTTOM w0.108: CON1201.B2 320,35.24 arc(319.91,35.19) 319.82,35.16 arc(319.81,35.16) 319.8,35.16 316.64,35.16 arc(316.51,35.19) 316.39,35.26 D1206.1 arc(316.1,35.25) 315.88,35.16 315.13,35.16 arc(314.51,35.27) 313.94,35.56 313.74,35.75 312.59,36.9 arc(310.63,38.23) 308.31,38.69 306.93,38.69 arc(306.8,38.75) v2(306.74,38.88)
TBTA_HPD: length 19.9
  TOP w0.102: v5(292.72,59.8) 292.72,59.97 U1201.C10
  IN1 w0.102: v5(292.72,59.8) 292.28,59.37 285.5,59.37 280.85,54.72 v2(280.85,53.8)
  BOTTOM w0.102: v1(280.37,53.04) 280.37,53.32 v2(280.85,53.8) ; v1(280.37,53.04) 280.37,52.56 280.47,52.46 R1120.1 ; v1(280.37,53.04) 280.75,52.66 282.1,52.66 282.51,52.25 R1121.1
TBTA_I2C_INT: length 36.5
  TOP w0.102: U1201.C1 292.18,55.39 292.01,55.39 291.59,54.97 v2(291.59,54.25) ; U1101.J4 296.06,44.34 v5(296.06,44.32)
  IN4 w0.102: v5(296.06,44.32) 294.75,45.63 294.63,45.63 293.88,46.37 293.88,46.46 292.58,47.76 291.51,47.76 285.82,53.45 284.37,53.45 283.55,54.27 283.55,54.61 283.94,55 288.27,55 289.3,53.97 291.3,53.97 v2(291.59,54.25)
  BOTTOM w0.102: v2(291.59,54.25) 291.59,54.93 290.91,55.61 289.9,55.61 289.64,55.35 v1(286.11,55.35) 285.47,55.35 R1145.1
TBTA_LSRX: length 29.1
  TOP w0.076: U1201.K4 296.23,56.95 296.9,56.95
  TOP w0.121: v2(303.09,42.26) 303.55,42.26 R1122.1 303.46,42.83 302.95,42.83 302.73,43.05 301.75,43.05 301.59,43.21 301.01,43.21 300.9,43.32 300.78,43.32 299.89,44.21 299.73,44.21 U1101.A4 ; 296.9,56.95 297.14,56.95 299.37,54.72 300.72,54.72 300.82,54.82 301.68,54.82 v2(302.19,55.33) 302.24,55.38 v1(303.1,55.38)
  IN4 w0.083: v2(303.09,42.26) 303.94,43.11 303.94,45.92 304.2,46.19 304.2,49.74 302.98,50.97 302.98,51.47 301.64,52.81 301.64,54.78 v2(302.19,55.33)
TBTA_LSTX: length 24.7
  TOP w0.121: v2(301.54,55.81) 301.26,55.81 v1(300.96,55.51) 300.77,55.51 300.41,55.15 299.26,55.15 297.21,57.2 U1201.L4 ; v2(302.47,42.63) R1118.1 301.5,42.99 300.91,42.99 300.81,43.1 300.66,43.1 299.79,43.97 U1101.A5
  IN4 w0.083: v2(302.47,42.63) 302.68,42.63 303.54,43.49 303.54,46.14 303.82,46.42 303.82,49.57 302.55,50.84 302.55,51.34 301.25,52.65 301.25,55 301.54,55.3 v2(301.54,55.81)
TBTA_TX0_N: length 4.6
  TOP w0.089: U1101.B19 299.24,37.73 299.29,37.75 299.69,37.75 299.94,37.6 300.49,37.6 300.5,37.61
  TOP w0.108: 300.5,37.61 302.14,37.61 arc(302.35,37.56) 302.52,37.44 302.59,37.37 arc(302.7,37.3) 302.82,37.28 303.03,37.28 arc(303.19,37.35) C1135.1
TBTA_TX0_P: length 4.6
  TOP w0.089: U1101.A19 299.36,37.53 299.32,37.49 299.32,37.37 299.4,37.29 299.73,37.29 299.82,37.38 300.49,37.38 300.5,37.37 300.52,37.37
  TOP w0.108: 300.52,37.37 302.14,37.37 arc(302.25,37.34) 302.36,37.28 302.43,37.2 arc(302.61,37.08) 302.83,37.05 303.01,37.05 arc(303.19,36.97) C1134.1
TBTA_TX1_N: length 4.5
  TOP w0.089: U1101.B17 299.27,38.23 299.73,38.23 299.84,38.34 300.41,38.34 300.42,38.33 300.45,38.33
  TOP w0.108: 300.45,38.33 301.03,38.33 arc(301.17,38.36) 301.29,38.43 301.34,38.47 arc(301.43,38.52) 301.53,38.53 302.62,38.53 arc(302.67,38.53) 302.72,38.54 302.76,38.54 302.76,38.54 302.76,38.53 arc(303.03,38.48) C1133.1
TBTA_TX1_P: length 4.5
  TOP w0.089: U1101.A17 299.37,38.45 299.33,38.5 299.33,38.62 299.39,38.69 299.73,38.69 299.86,38.55 300.41,38.55 300.42,38.56 300.45,38.56
  TOP w0.108: 300.45,38.56 301.01,38.56 arc(301.09,38.58) 301.15,38.62 301.2,38.66 arc(301.36,38.74) 301.53,38.77 302.62,38.77 arc(302.63,38.77) 302.64,38.77 arc(302.67,38.77) 302.7,38.77 arc(302.71,38.77) 302.73,38.78 arc(302.75,38.78) 302.77,38.78 arc(303.04,38.87) C1132.1
TBTA_USB2_D_N: length 41.3
  TOP w0.102: v5(298.02,37.17) 298.02,36.99 298.17,36.85 U1101.D20
  TOP w0.121: R1216.1 299.21,71.41 v2(299.66,71.86)
  IN1 w0.102: v5(298.02,37.17) 297.88,37.17 297.8,37.09 297.8,36.95 298,36.74 298.33,36.74 299.38,37.79 299.38,44.22 297.48,46.12 297.48,55.47 297.07,55.87 297.07,62 296.56,62.5 296.56,64.05 296.18,64.43 296.18,65.78 297.96,67.56 297.96,70.66 298.96,71.66 299.46,71.66 v2(299.66,71.86)
TBTA_USB2_D_N_CC: length 22.4
  TOP w0.076: 297.35,57.37 297.28,57.44 296.24,57.44 U1201.K5
  TOP w0.121: 297.35,57.37 298.96,55.76 299.27,55.76 v2(299.42,55.61) ; v2(299.66,70.64) 299.56,70.54 R1215.2
  IN1 w0.102: v2(299.66,70.64) 299.5,70.48 299.1,70.48 298.74,70.11 298.74,64.68 298.02,63.97 298.02,55.96 298.38,55.61 v2(299.42,55.61)
TBTA_USB2_D_N_CHG: length 11.5
  TOP w0.121: 295.46,76.81 295,76.81 294.22,76.04 294.22,75.6 294.3,75.52 294.75,75.52 294.82,75.45 294.82,75.32 294.49,74.98 U1202.2 ; 295.46,76.81 v1(295.46,76.59) ; 295.46,76.81 297.6,76.81 298.15,76.26 298.15,74.63 299.49,73.29 299.49,73.05 R1216.2
TBTA_USB2_D_P: length 41.3
  TOP w0.102: U1101.E20 297.69,36.85 v5(297.37,37.17)
  TOP w0.121: R1214.1 299.82,71.41 v2(299.66,71.25)
  IN1 w0.102: v5(297.37,37.17) 297.58,36.96 297.58,36.86 297.74,36.7 297.91,36.53 298.42,36.53 298.89,36.99 299.6,37.7 299.6,44.31 298.89,45.02 297.69,46.21 297.69,55.56 297.29,55.96 297.29,62.09 296.78,62.59 296.78,64.14 296.4,64.52 296.4,65.69 298.18,67.47 298.18,70.57 299.05,71.44 299.47,71.44 v2(299.66,71.25)
TBTA_USB2_D_P_CC: length 22.4
  TOP w0.076: 297.42,57.63 296.55,57.63 U1201.L5
  TOP w0.121: 297.42,57.63 299.06,56 299.2,56 v2(299.42,56.22) ; v2(299.66,70.03) 300.17,70.54 R1217.1
  IN1 w0.102: v2(299.42,56.22) 298.96,56.67 298.84,56.67 298.74,56.57 298.74,56.34 298.89,56.19 298.89,55.89 298.82,55.82 298.47,55.82 298.24,56.05 298.24,63.88 298.95,64.59 298.95,70.02 299.19,70.26 299.43,70.26 v2(299.66,70.03)
TBTA_USB2_D_P_CHG: length 11.6
  TOP w0.121: 297.29,77.05 294.9,77.05 293.99,76.14 U1202.3 ; 297.29,77.05 v1(297.29,77.26) ; 297.29,77.05 297.69,77.05 298.39,76.35 298.39,74.73 299.73,73.39 299.73,73.08 R1214.2
TBTA_USB2_RBIAS: length 5.4
  TOP w0.102: v5(296.75,37.83) 296.72,37.83 U1101.H19
  BOTTOM w0.102: v5(296.75,37.83) 296.46,37.54 296.46,36.01 296.32,35.87 296.32,35.12 295.97,34.76 R1123.2 296.21,34.28 296.21,34.08 295.76,33.63 v1(295.76,33.55)
TBTB_I2C_INT: length 19.9
  TOP w0.102: R1135.1 285.36,51.8 285.38,51.77 289.62,51.77 289.83,51.56 290.27,51.56 291.2,50.63 293.05,50.63 v1(293.48,51.06) 293.86,50.68 295.26,50.68 295.51,50.43 297.03,50.43 297.44,50.02 297.44,45.57 U1101.E2
TC: length 3.1
  TOP w0.102: R9714.1 90.85,176.68 90.85,176.65 v1(90.3,176.11)
  TOP w0.254: R9714.1 91.78,177.6 91.78,177.85 92.1,178.17 U9702.13
THRO_CPU: length 242
  TOP w0.102: v2(155.51,27.96) 155.51,28.02 159,31.51 U3002.123
  IN2 w0.102: v2(155.51,27.96) 154.89,28.58 135.4,28.58 131.01,32.97 131.01,33.98 128.53,36.45 122.81,36.45 121.39,35.03 114.19,35.03 113.12,33.97 109.13,33.97 108.61,33.45 103.3,33.45 101.22,31.37 60.3,31.37 60.28,31.35 55.4,31.35 52.45,34.31 44.66,34.31 41.43,37.53 41.43,40.67 36.1,46.01 36.1,70.72 43.64,78.26 43.64,88.5 43.01,89.13 43.01,101.04 45.77,103.8 46.37,103.8 51.25,108.68 54.81,108.68 59.92,113.8 59.92,114.66 v2(60.31,115.04)
  BOTTOM w0.102: v2(60.31,115.04) 61.77,115.04 62.74,116.02 62.74,119.66 62.98,119.89 62.98,122.29 65.34,124.65 v1(65.34,126.18) 65.58,126.42 Q0702.1
TP_ATTN#: length 46.4
  IN3 w0.102: v2(204.2,36.51) 213.72,36.51 v2(214.64,37.42)
  BOTTOM w0.102: v2(204.2,36.51) 207.45,33.26 207.45,29.88 209.43,27.9 209.43,23.85 210.75,22.53 CON3104.4 ; Q2301.2 224.47,37.57 224.64,37.4 R2382.2 R2310.2 R2363.2 225.58,36.15 225.58,34.69 224.99,34.09 222.36,34.09 v1(219.68,36.77) 218.27,38.18 215.4,38.18 v2(214.64,37.42)
TP_ATTN#_Q: length 28
  TOP w0.102: v2(230.61,46.31) 231.02,46.72 231.02,47.76 230.48,48.3 v2(230.48,50.38)
  BOTTOM w0.102: Q2301.3 223.12,38.34 222.87,38.59 v1(222.87,39.22) 223.7,38.39 225.02,38.39 R2382.1 225.51,38.26 226.46,37.31 228.03,37.31 229.72,39 230.82,39 231.25,39.42 231.25,40.86 231.72,41.33 231.86,41.33 232.33,41.8 232.33,43.35 R2381.2 232.75,44.23 230.66,46.31 v2(230.61,46.31) ; v2(230.48,50.38) 230.57,50.29 U2000.AH43
TP_BL_EN: length 47.1
  TOP w0.102: v2(236,53.43) 235.35,54.08 234.54,54.08 234.12,53.66 234.12,52.25 234.19,52.18 234.19,51.16 233.57,50.54 233.57,49.52 232.8,48.75 232.8,48.54 232.04,47.78 232.04,45.4 232.16,45.27 232.16,44.48 R2435.2 232.33,43.23 232.33,41.61 231.37,40.66 231.37,39.37 228.92,36.91 222.79,36.91 221.34,35.47 219.41,35.47 217.46,33.51 214.17,33.51 212.29,31.63 v1(212.29,30.89) 212.29,27.45 213.27,26.46 Q3107.1
  BOTTOM w0.102: v2(236,53.43) 236,53.7 U2000.AW33
TP_BTN#: length 76.5
  TOP w0.102: v2(169.42,32.49) 169.42,32.93 167.44,34.91 165.92,34.91 R3081.2 164.56,34.35 164.03,33.81 163.53,33.81 163.23,33.51 U3002.128
  IN2 w0.102: v2(164.92,20.63) 165.36,20.19 172.26,20.19 172.9,20.84 180.17,20.84 180.57,21.24 188.41,21.24 188.48,21.32 199.52,21.32 200.67,20.17 206.36,20.17 v2(207.25,19.29)
  BOTTOM w0.102: CON3104.11 v2(207.25,19.29) ; v2(169.42,32.49) 169.88,32.95 v1(171.43,32.95) 171.94,32.44 171.94,23.98 171.09,23.13 168.98,23.13 168.18,22.33 168.18,21.83 168.01,21.66 168.01,20.29 167.59,19.87 165.68,19.87 v2(164.92,20.63)
TP_CHA_XMM3_S2: length 87.9
  TOP w0.102: v2(83.06,59.95) 83.29,59.95 84,60.66 84,61.78 84.87,62.65 CON1600.162
  IN3 w0.102: v2(83.06,59.95) 83.12,59.95 84.87,61.71 84.87,68.91 91.41,75.45 112.18,75.45 116.95,70.67 116.95,63.4 117.66,62.69 118.55,62.69 118.8,62.44 120.02,62.44 123.39,59.07 123.39,50.85 125.38,48.85 v2(125.38,47.71)
  BOTTOM w0.102: T1601.1 T1602.1 125.56,46.18 125.38,46.36 v2(125.38,47.71) ; v2(83.06,59.95) 82.61,59.49 82.61,57.94 82.88,57.68 CON1601.162
TP_CHA_XMM3_S3: length 88.7
  TOP w0.102: CON1600.165 85.62,57.67 85.38,57.92 85.38,58.32 85.59,58.54 86.11,58.54 87.29,59.71 87.29,60.11 v2(88.14,60.97)
  IN3 w0.102: v2(88.14,60.97) 89.01,61.83 89.01,66.88 97.17,75.04 112.01,75.04 116.54,70.51 116.54,63.23 117.49,62.29 118.38,62.29 118.63,62.03 119.79,62.03 122.98,58.85 122.98,50.58 124.13,49.44 124.13,47.5 126.94,44.69 v2(128,44.69)
  BOTTOM w0.102: v2(88.14,60.97) 87.33,60.97 86.41,61.89 85.09,61.89 84.69,62.29 84.69,63.28 84.35,63.62 83.75,63.62 83.63,63.75 CON1601.165 ; v2(128,44.69) 128.78,44.69 129.39,44.08 T1603.1 T1600.1
TP_CHB_XMM1_S2: length 50.8
  TOP w0.102: CON1700.162 84.87,51.68 83.85,50.66 83.85,48.17 v2(83.47,47.79)
  IN3 w0.102: v2(83.47,47.79) 84.05,48.37 84.05,49.94 86.59,52.48 106.61,52.48 108.54,50.55 110.68,50.55 111.52,49.71 113.87,49.71 114.79,50.63 117.31,50.63 v2(117.81,50.12)
  BOTTOM w0.102: v2(83.47,47.79) 82.88,47.19 82.88,47 83.07,46.8 83.07,45.92 82.88,45.72 CON1701.162 ; T1702.1 117.61,50.91 117.81,50.7 v2(117.81,50.12) 117.81,49.72 T1703.1
TP_CHB_XMM1_S3: length 57.1
  TOP w0.102: T1701.1 124.95,45.07 v2(124.95,45.85) 124.62,46.18 T1700.1 ; v2(85.74,49.21) 85.74,46.53 85.62,46.42 CON1700.165 85.62,42.33 87.76,40.19 v2(88.47,40.19)
  IN1 w0.102: v2(88.47,40.19) 94.29,40.19 95.48,41.38 102.22,41.38 102.98,42.15 110.32,42.15 112.66,44.48 124.33,44.48 124.95,45.09 v2(124.95,45.85)
  BOTTOM w0.102: v2(85.74,49.21) 85.7,49.21 83.63,51.29 CON1701.165
TP_CK_48M_USB_SEVR_ONLY: length 10.8
  TOP w0.102: T2204.1 233.34,69.64 232.08,68.38 232.08,67.84 232.09,67.83 232.09,63.94 v2(233.53,62.49)
  BOTTOM w0.102: v2(233.53,62.49) 233.84,62.18 233.84,62.16 U2000.AR17
TP_CLK_I2C: length 44.8
  TOP w0.121: U2301.3 233.17,47.8 232.98,47.61 232.98,47.25 232.66,46.94 232.66,44.68 233.37,43.98 233.37,43.19 233.44,43.12 233.44,41.85 R2313.2 231.87,40.28 231.87,39.17 229.12,36.42 223.03,36.42 221.55,34.93 219.57,34.93 217.66,33.01 214.37,33.01 212.78,31.43 v1(212.78,28.79) 212.78,27.92 213.8,26.9 213.8,25.59 213.18,24.96 211.79,24.96 211.31,24.48 211.31,23.64 210.65,22.98 210.04,22.98 SR3106.2
TP_CLK_I2C_CON: length 7.6
  TOP w0.121: SR3106.1 209.53,21.35 209.94,20.94 v2(210.22,20.94)
  BOTTOM w0.121: v1(208.57,26.73) 208.57,23.96 210.25,22.28 CON3104.5 210.25,20.96 210.22,20.94 v2(210.22,20.94)
TP_CLK_I2C_PCH: length 10
  TOP w0.121: v2(234.75,51.08) 235.03,50.8 v1(235.03,50.35) 235.03,47.11 234.56,46.64 233.34,46.64 233.17,46.47 U2301.4 233.17,44.93 233.87,44.23 R2379.2
  BOTTOM w0.121: U2000.AR38 v2(234.75,51.08)
TP_DATA_I2C: length 43.4
  TOP w0.121: SR3105.2 210.84,22.46 211.81,23.43 211.81,24.27 211.99,24.45 213.43,24.45 214.36,25.38 214.36,27.13 213.42,28.07 213.42,31.35 214.57,32.5 218.36,32.5 v1(218.45,32.42) 219.74,32.42 223.24,35.92 229.69,35.92 231.65,37.88 232.37,37.88 233.03,38.54 233.03,39 233.71,39.68 233.71,40.41 R2312.2 233.94,41.52 233.94,42.28 234.88,43.21 234.97,43.21 235.13,43.37 235.13,44.81 234.47,45.48 U2301.6
TP_DATA_I2C_CON: length 4.6
  TOP w0.121: v1(211.39,21.61) 211.37,21.62 SR3105.1 210.75,21.3 210.75,20.58 210.6,20.44 209.73,20.44 v2(209.63,20.53)
  BOTTOM w0.121: CON3104.6 209.75,20.65 v2(209.63,20.53)
TP_DATA_I2C_PCH: length 8.3
  TOP w0.121: R2380.2 234.47,49.82 U2301.1 234.47,47.26 v2(234.43,47.23)
  BOTTOM w0.121: U2000.AT42 234.3,49.32 234.3,47.36 v2(234.43,47.23) 234.43,46.41 235.67,45.17 v1(235.69,45.17)
TP_EXIT_HOLDOFF#: length 2.6
  TOP w0.102: v2(237.45,61.24) 237.52,61.31 R2262.1 238.51,61.63 238.51,61.91 T2203.1
  BOTTOM w0.102: v2(237.45,61.24) 237.6,61.39 U2000.BB17
TP_GPD7_RSVD: length 12.9
  BOTTOM w0.102: U2000.BD14 238.61,63.6 238.73,63.66 238.74,63.66 238.78,63.68 238.92,63.75 239.52,63.75 239.68,63.9 240.95,63.9 241.46,63.4 241.79,63.4 242.61,64.21 243.64,64.21 244.02,64.59 246.27,64.59 246.89,65.21 249.71,65.21 T2410.1
TP_GPP_B11: length 1.5
  TOP w0.102: T2400.1 233.15,57.74 v2(233.88,57.74)
  BOTTOM w0.102: v2(233.88,57.74) 233.88,57.74 U2000.AN24
TP_GPP_G0_TACH0: length 13.5
  BOTTOM w0.089: U2000.U43 225.29,48.88 225.29,48.37 225.32,48.35 225.32,47.91 225.22,47.81
  BOTTOM w0.102: 225.22,47.81 225.22,46.77 223.81,45.36 223.35,45.36 222.75,44.76 222.15,44.76 221.58,44.19 221.33,44.19 221.14,44 221.14,42.04 221.44,41.74 221.44,40.72 R2207.2 221.32,39.88 221.32,39.38 v1(220.73,38.79)
TP_GPP_H_18: length 10
  TOP w0.102: v1(244.89,48.83) 244.66,49.05 R2473.2 244.13,50.3 241.53,50.3 240.69,51.14 239.47,51.14 238.9,51.7 238.26,51.7 237.96,52.01 237.52,52.01 v2(237.32,52.21)
  BOTTOM w0.102: U2000.BC36 237.9,52.21 v2(237.32,52.21)
TP_LANPHYPC: length 8.5
  TOP w0.102: T2409.1 232.58,68.6 232.28,68.3 232.28,67.92 232.29,67.91 232.29,64.14 233.3,63.13 234.03,63.13 v2(234.42,63.53)
  BOTTOM w0.102: v2(234.42,63.53) 234.42,63.41 U2000.AR15
TP_LED_BLUE: length 72.1
  IN1 w0.102: v2(206.27,31.68) 206.7,31.25 209.86,31.25 219.03,40.42 234.07,40.42 234.5,40.85 237.55,40.85 238.41,41.71 238.41,42.42 240.36,44.36 240.36,45.56 241.24,46.44 242.68,46.44 243.45,47.21 243.45,50.88 242.79,51.53 v2(242.79,53.13)
  BOTTOM w0.102: CON3104.10 207.75,22.74 206.27,24.22 v1(206.27,26.45) v2(206.27,31.68) ; U2000.BD33 238.82,53.83 239.22,53.83 239.63,53.42 240.37,53.42 241.06,52.74 242.4,52.74 v2(242.79,53.13) 243.11,52.81 244.52,52.81 244.59,52.73 R2437.2
TP_LED_RED: length 63.7
  IN1 w0.102: v2(241.82,51.72) 241.61,51.51 241.61,47.46 239.95,45.8 239.95,44.53 238,42.58 238,41.88 237.39,41.26 234.33,41.26 233.95,40.88 218.78,40.88 210.45,32.54 207.93,32.54 v2(207.04,31.66)
  BOTTOM w0.102: v2(207.04,31.66) 206.79,31.4 v1(206.79,29.19) 206.79,24.17 208.25,22.7 CON3104.9 ; R2436.2 241.9,51.8 v2(241.82,51.72) 241.67,51.87 240.77,51.87 240.08,52.56 239.17,52.56 238.78,52.95 238.7,53 238.47,53 238.11,53.37 238.11,53.42 U2000.BB33
TP_PCH_RSVD_BD1: length 2.8
  TOP w0.102: T2500.1 237.83,70.37 v2(238.36,70.9)
  BOTTOM w0.102: U2000.BD1 238.36,70.07 v2(238.36,70.9)
TP_PCH_RSVD_BE2: length 3.6
  TOP w0.102: v2(238.36,71.51) 238.36,71.83 T2501.1
  BOTTOM w0.102: U2000.BE2 239.01,69.85 238.77,70.09 238.77,71.1 v2(238.36,71.51)
TP_PS2_CLK: length 63.7
  TOP w0.121: v2(208.01,25.38) 208.19,25.2 C3103.1 208.19,24.12 D3102.1 208.13,23.14 v1(208.13,22.44) 208.13,21.95 208.01,21.83 v2(208.01,20.68) ; v2(158.43,20.91) 158.06,20.55 U3002.89 158.06,18.73 158.17,18.63 158.17,17.44 158.25,17.36 R3073.2
  IN2 w0.083: v2(158.43,20.91) 158.43,20.95 159.24,21.76 161.71,21.76 163.17,23.23 165.13,23.23 165.18,23.18 166.19,23.18 166.43,23.42 180.07,23.42 180.25,23.6 184,23.6 184.27,23.32 184.27,23.32 184.63,22.97 201.88,22.97 204.19,25.28 207.9,25.28 v2(208.01,25.38)
  BOTTOM w0.121: CON3104.8 208.75,21.17 208.26,20.68 v2(208.01,20.68)
TP_PS2_DAT: length 65.9
  TOP w0.121: v2(159.04,20.9) 158.47,20.33 U3002.90 158.47,18.6 158.52,18.55 158.52,17.47 159.09,16.9 R3072.2 ; v2(209.02,25.38) 208.97,25.33 C3102.1 208.97,23.61 D3101.1 208.64,23.27 v1(208.64,20.64) 208.64,20.43 208.26,20.05 v2(208.01,20.05)
  IN2 w0.083: v2(209.02,25.38) 208.66,25.38 208.09,24.81 204.38,24.81 202.07,22.5 184.44,22.5 183.8,23.14 180.45,23.14 180.26,22.96 166.63,22.96 166.38,22.72 164.99,22.72 164.94,22.76 163.36,22.76 161.9,21.3 159.43,21.3 v2(159.04,20.9)
  BOTTOM w0.121: v2(208.01,20.05) 208.39,20.05 209.25,20.91 CON3104.7
TP_SENSOR: length 69.5
  TOP w0.102: v2(236.61,53.43) 237.07,52.97 237.93,52.97 238.79,52.11 239.07,52.11 239.63,51.54 240.87,51.54 241.51,50.91 v2(242.45,50.91) 245.24,50.91 245.81,51.48 R2434.2
  IN1 w0.102: v2(207.91,31.68) 208.36,32.14 210.46,32.14 219,40.67 234.03,40.67 234.41,41.05 237.47,41.05 238.21,41.79 238.21,42.5 240.16,44.45 240.16,45.71 241.08,46.64 242.59,46.64 243.24,47.29 243.24,50.12 v2(242.45,50.91)
  BOTTOM w0.102: U2000.BA33 236.84,53.65 236.83,53.65 v2(236.61,53.43) ; v2(207.91,31.68) v1(207.91,30.74) 207.91,29.8 209.63,28.07 209.63,23.93 211.25,22.32 CON3104.3
TP_SPI0_CS1#: length 5.3
  TOP w0.102: v2(235.39,53.43) 235.39,53.65 235.16,53.88 234.63,53.88 234.32,53.58 234.32,52.56 T2202.1
  BOTTOM w0.102: U2000.AW31 235.95,54.89 235.65,54.58 235.65,54.24 235.77,54.12 235.77,53.81 v2(235.39,53.43)
TP_SPI0_CS2#: length 2.9
  TOP w0.102: v2(234.25,54.37) 233.63,55 233.2,55 T2201.1
  BOTTOM w0.102: v2(234.25,54.37) 234.25,54.39 U2000.AT31
TS1#: length 184.3
  TOP w0.102: v2(164.53,18.03) 165.01,17.55 168.37,17.55 169.25,18.43 169.25,19 170.72,20.47 170.72,22.99 170.87,23.15 171.4,23.15 172.02,23.76 172.02,24.34 171.19,25.16 171.18,25.16 171.09,25.25 171.09,27.4 171.13,27.44 171.13,27.75 171.33,27.96 171.33,30.89 170.62,31.6 JP9000.2
  IN2 w0.102: v2(164.53,18.03) 165.63,19.13 195.25,19.13 196.9,17.48 207.67,17.48 209.42,19.23 209.42,19.73 210.22,20.52 213.65,20.52 214.22,21.09 215.17,21.09 217.43,23.36 226.19,23.36 226.74,23.91 236.02,23.91 236.18,23.76 238.5,23.76 239.19,24.44 240.71,24.44 247.82,31.55 252.38,31.55 254.02,33.18 259.99,33.18 261.51,34.7 265.36,34.7 265.36,34.7 265.55,34.7 269.76,38.91 269.76,40.42 v2(273.72,44.38)
  BOTTOM w0.102: v2(273.72,44.38) 274.23,44.38 278.85,39.77 279.52,39.77 280.54,38.75 v1(280.54,35.1) 280.54,31.16 279.58,30.21 279.58,29.71 282.59,26.71 285.77,26.71 286.14,27.07 287.21,27.07 287.53,27.4 287.53,27.9 287.81,28.18 R6001.2 292.16,28.18 294,26.33 CON6000.5
TS_VREF: length 1.8
  TOP w0.102: v3(148.3,84.1) 148.28,84.08 T7401.1
  BOTTOM w0.102: U7000.BF12 v3(148.3,84.1)
UART0_DEBUG_RXD: length 75
  IN3 w0.102: v2(236.97,49.16) 236.33,48.52 212.74,48.52 208.5,44.28 205.68,44.28 198.97,37.57 198.02,37.57 196.08,35.63 195.41,35.63 192.97,33.18 189.65,33.18 v2(188.97,32.51)
  BOTTOM w0.102: CON4402.4 177,21.15 177,24.55 178.11,25.66 v1(180.91,25.66) 182.12,25.66 v2(188.97,32.51) ; U2000.BA41 v2(236.97,49.16)
UART0_DEBUG_TXD: length 75.9
  IN3 w0.102: v2(189.58,32.51) 190.05,32.98 193.05,32.98 195.5,35.43 196.17,35.43 198.11,37.37 199.05,37.37 205.76,44.08 208.58,44.08 209.93,45.42 227.79,45.42 230.38,48.01 234.91,48.01 236.15,46.77 v2(236.15,46.58)
  BOTTOM w0.102: v2(189.58,32.51) 182.05,24.98 v1(178.92,24.98) 177.73,24.98 177.22,24.47 177.22,21.65 178,20.87 CON4402.2 ; v2(236.15,46.58) 236.15,46.77 235.59,47.33 U2000.AV44
USB2_COMP: length 10.6
  BOTTOM w0.102: U2000.AG3 230.38,68.81 230.12,69.07 230.12,69.46 230.06,69.54 229.3,70.3
  BOTTOM w0.203: 229.3,70.3 229.3,70.9 228.26,71.94 226.53,71.94 v1(226.36,71.76) 225.88,71.76 224.5,73.13 224.5,74.75 224.39,74.86 R2526.2
USB2_ID: length 10.7
  BOTTOM w0.102: U2000.AG2 230.32,69.25 230.32,69.52 230.22,69.67 229.57,70.32 229.57,71.04 228.42,72.19 226.99,72.19 226.63,72.55 225.77,72.55 v1(225.18,73.15) 224.76,73.57 224.76,75.63 SR2001.2
USB2_VBUSSENSE: length 4.5
  TOP w0.102: R2000.1 228.56,68.74 v1(229.01,68.28) 229.01,68 228.59,67.58 228.59,67.23 v2(228.05,66.69)
  BOTTOM w0.102: U2000.AD10 228.51,65.97 228.51,66.23 228.22,66.53 v2(228.05,66.69)
USB3_RX_H_N1: length 6.4
  TOP w0.121: CON5500.5 312,55.44 311.87,55.31 311.33,55.31 310.9,54.87 310.9,54.35 310.78,54.24 310.48,54.24 310.39,54.32 U5500.10 U5500.1 308.97,54.32 308.87,54.22 308.61,54.22 308.26,54.57 307.95,54.57 307.66,54.86 L5500.3
USB3_RX_H_N2: length 10.9
  TOP w0.121: RN5503.2 304.61,79.38 304.88,79.11 305.77,79.11 306.21,78.67 306.51,78.67 306.62,78.78 U5502.1 U5502.10 308,78.78 308.13,78.65 308.23,78.65 308.38,78.81 308.38,79.71 311.39,82.72 311.88,82.72 312,82.84 CON5501.5
USB3_RX_H_P1: length 6.5
  TOP w0.121: CON5500.6 312,54.96 311.89,55.07 311.43,55.07 311.13,54.77 311.13,54.26 310.88,54 310.55,54 310.37,53.82 U5500.9 U5500.2 308.97,53.82 308.81,53.98 308.51,53.98 308.16,54.33 307.95,54.33 307.68,54.06 L5500.2
USB3_RX_H_P2: length 10.9
  TOP w0.121: RN5503.4 304.61,78.58 304.91,78.87 305.67,78.87 306.11,78.44 306.43,78.44 306.59,78.28 U5502.2 U5502.9 307.97,78.28 308.06,78.37 308.28,78.37 308.62,78.71 308.62,79.61 311.49,82.48 311.88,82.48 312,82.36 CON5501.6
USB3_RX_N1: length 98.9
  TOP w0.121: L5500.4 305.66,54.86 305.44,54.64 305.19,54.64 305.14,54.7 v2(305.14,55.89)
  IN4 w0.102: v2(305.14,55.89) 304.9,55.89 303.44,57.35 301.64,57.35 300.51,56.21 300.51,55.42 300.22,55.14 298.8,55.14 297.91,56.03 285.06,56.03 284.71,56.37 281.36,56.37 281.07,56.08 279.16,56.08 278.4,55.32 277.79,55.32 275.71,53.23 274.85,53.23 274.26,52.65 273.07,52.65 272.41,51.99 267.88,51.99 266.6,53.27 262.05,53.27 260.43,54.88 252.66,54.88 251.73,55.81 249.51,55.81 248.9,56.42 247.97,56.42 247.61,56.79 247.09,56.79 246.73,56.42 243.44,56.42 242.45,57.41 241.89,57.41 240.15,59.15 240.15,59.7 237.9,61.96 236.28,61.96 236.19,62.05 232.1,62.05 230.94,63.2 224.52,63.2 223.23,64.49 220.11,64.49 219.75,64.13 v2(219.75,63.54)
  BOTTOM w0.121: v2(219.75,63.54) 219.75,63.57 U2000.G13
USB3_RX_N2: length 105.8
  TOP w0.121: v2(300.87,79.36) 301.73,79.36 301.93,79.16 302.7,79.16 302.92,79.38 RN5503.1
  IN4 w0.102: v2(300.87,79.36) 301,79.36 301,79.35 301.26,79.35 301.57,79.04 301.57,77.69 301.12,77.25 296.22,77.25 292.96,73.98 292.96,73.22 291.31,71.57 291.31,70.17 290.22,69.08 288.38,69.08 287.19,67.89 285.06,67.89 284.83,68.12 283.18,68.12 281.43,66.36 274.54,66.36 274.28,66.1 270.36,66.1 267.47,68.99 260.89,68.99 259.63,70.25 254.4,70.25 253.57,71.08 244.3,71.08 241.92,73.46 241.47,73.46 241.35,73.34 240.66,73.34 239.45,74.54 227.15,74.54 224.02,71.42 222.07,71.42 219.77,69.12 217.66,69.12 216.34,67.8 v2(216.34,67.12)
  BOTTOM w0.121: U2000.C8 218.16,66.31 217.96,66.5 216.34,66.5 216.11,66.74 216.11,66.89 v2(216.34,67.12)
USB3_RX_N3: length 236.3
  IN1 w0.102: v2(215.45,65.06) 214.55,65.96 212.88,65.96 211.07,64.14 209.91,64.14 208.12,62.35 204.29,62.35 199.45,57.5 199.45,45.68 194.44,40.67 193.68,40.67 189.63,36.62 171.48,36.62 171.28,36.82 161.79,36.82 161.59,36.62 148.58,36.62 144.11,41.09 113.34,41.09 110.31,38.07 99.84,38.07 97.73,35.96 46.55,35.96 46.11,36.41 v2(46.11,36.68)
  BOTTOM w0.121: v1(18.55,51.42) 18.55,51.2 ; 18.55,51.2 CON6700.34 ; 18.55,51.2 20.52,51.2 23.37,48.35 26.8,48.35 28.3,46.84 29.7,46.84 30,46.55 35.26,46.55 38,43.8 38,42.5 42.36,38.14 45.44,38.14 46.11,37.47 v2(46.11,36.68) ; v2(215.45,65.06) 215.45,65.33 215.59,65.47 217.47,65.47 217.68,65.68 U2000.B10
USB3_RX_N4: length 253.7
  IN1 w0.102: v2(51.42,29.45) 51,29.86 51,30.02 51.21,30.23 52,30.23 52.48,30.72 106.25,30.72 110.59,35.06 111.56,35.06 114.53,38.03 138.79,38.03 139.46,37.36 141.5,37.36 142.77,36.09 143.53,36.09 146,33.61 162.84,33.61 163,33.78 168.51,33.78 168.67,33.61 192.77,33.61 197.21,38.06 197.42,38.06 203.69,44.33 203.69,46.21 206.09,48.61 206.09,50.74 207.82,52.47 207.82,60.42 208.38,60.98 208.38,61.26 210.34,63.23 211.45,63.23 212.58,64.36 217.49,64.36 218.1,64.97 218.1,65.45 219.14,66.49 219.42,66.49 219.5,66.41 219.5,66.25 v2(219.06,65.8)
  BOTTOM w0.121: CON6700.43 14.42,55.7 14.6,55.51 18.57,55.51 ; v1(18.57,55.73) 18.57,55.51 ; 18.57,55.51 21.53,55.51 22.12,54.93 24.03,54.93 24.97,53.98 26.47,53.98 26.94,54.45 31.42,54.45 40.47,45.4 40.47,43.52 43.29,40.7 49.21,40.7 51.45,38.46 51.45,35.8 51.99,35.25 51.99,31.75 51.02,30.77 51.02,29.85 v2(51.42,29.45) ; U2000.E11 219.31,65.55 v2(219.06,65.8)
USB3_RX_N6: length 248.2
  IN1 w0.102: v2(222.1,63.57) 221.98,63.69 221.98,64.17 221.77,64.37 218.42,64.37 217.92,63.88 212.8,63.88 211.67,62.75 210.55,62.75 208.86,61.06 208.86,60.78 208.3,60.22 208.3,51.71 206.7,50.11 206.7,48.36 204.3,45.96 204.3,44.15 197.16,37.01 196.86,37.01 192.97,33.13 168.26,33.13 168.09,33.29 163.2,33.29 163.04,33.13 145.78,33.13 143.4,35.5 142.51,35.5 141.24,36.77 139.26,36.77 138.63,37.41 128.09,37.41 127.79,37.12 114.61,37.12 107.26,29.76 60.01,29.76 59.19,28.94 50.04,28.94 v2(49.54,29.45)
  BOTTOM w0.121: U2000.K15 222.1,63.48 v2(222.1,63.57) ; CON6700.5 14.22,36.7 14.35,36.83 14.91,36.83 15.19,37.11 15.96,37.11 16.09,36.98 U6701.6 U6701.5 17.27,36.98 17.4,37.11 17.58,37.11 18.86,35.84 22.38,35.84 23.96,37.43 23.96,39.89 25.79,41.71 33.58,41.71 34.15,41.15 37.98,41.15 47.57,31.55 47.57,28.99 48.22,28.35 49.17,28.35 49.54,28.71 v2(49.54,29.45)
USB3_RX_P1: length 98.9
  TOP w0.121: L5500.1 305.69,54.06 305.35,54.41 305.09,54.41 304.9,54.6 304.9,55.51 304.76,55.66 v2(304.55,55.66)
  IN4 w0.102: v2(220.54,63.54) 220.37,63.54 219.97,63.94 219.97,64.04 220.2,64.28 223.14,64.28 224.43,62.99 230.85,62.99 232.01,61.83 236.1,61.83 236.19,61.74 237.81,61.74 239.93,59.61 239.93,59.06 241.8,57.2 242.36,57.2 243.35,56.21 246.82,56.21 247.18,56.57 247.52,56.57 247.88,56.21 248.81,56.21 249.42,55.6 251.64,55.6 252.57,54.67 260.35,54.67 261.96,53.06 266.51,53.06 267.79,51.77 272.5,51.77 273.16,52.43 274.35,52.43 274.94,53.02 275.8,53.02 277.88,55.1 278.49,55.1 279.25,55.86 281.16,55.86 281.45,56.15 284.63,56.15 284.97,55.81 297.82,55.81 298.71,54.92 300.31,54.92 300.72,55.33 300.72,56.12 301.73,57.13 303.35,57.13 304.55,55.93 v2(304.55,55.66)
  BOTTOM w0.121: U2000.H13 220.54,63.55 v2(220.54,63.54)
USB3_RX_P2: length 105.7
  TOP w0.121: RN5503.3 302.92,78.58 302.57,78.92 301.83,78.92 301.64,79.12 301.27,79.12 v2(300.87,78.72)
  IN4 w0.102: v2(300.87,78.72) 301.14,79 301.31,79 301.35,78.95 301.35,77.78 301.03,77.46 296.13,77.46 292.74,74.07 292.74,73.31 291.09,71.66 291.09,70.26 290.13,69.3 288.3,69.3 287.1,68.1 285.15,68.1 284.92,68.33 283.09,68.33 281.34,66.58 274.45,66.58 274.19,66.31 270.45,66.31 267.56,69.21 260.98,69.21 259.72,70.47 254.49,70.47 253.66,71.29 244.39,71.29 242.01,73.68 241.38,73.68 241.26,73.55 240.75,73.55 239.54,74.76 227.06,74.76 223.93,71.64 221.98,71.64 219.68,69.34 217.57,69.34 216.12,67.89 216.12,67.52 v2(215.73,67.12)
  BOTTOM w0.121: U2000.B8 217.72,66.27 216.24,66.27 215.87,66.64 215.87,66.98 v2(215.73,67.12)
USB3_RX_P3: length 236.3
  IN1 w0.102: v2(45.34,36.68) 45.53,36.68 45.89,36.32 46.46,35.74 97.82,35.74 99.93,37.85 110.4,37.85 113.43,40.88 144.02,40.88 148.49,36.41 161.68,36.41 161.88,36.61 171.19,36.61 171.39,36.41 189.72,36.41 193.77,40.46 194.53,40.46 199.66,45.59 199.66,57.41 204.38,62.14 208.21,62.14 210,63.93 211.16,63.93 212.97,65.74 214.46,65.74 214.84,65.36 v2(214.84,65.06)
  BOTTOM w0.121: v1(26.22,47.9) 26.22,48.11 ; 26.22,48.11 23.27,48.11 20.42,50.96 14.69,50.96 14.43,50.7 CON6700.33 ; 26.22,48.11 26.7,48.11 28.2,46.61 29.6,46.61 29.9,46.31 35.16,46.31 37.77,43.7 37.77,42.4 42.26,37.9 45.35,37.9 45.87,37.38 45.87,37.2 v2(45.34,36.68) ; U2000.A9 217.28,65.71 215.49,65.71 v2(214.84,65.06)
USB3_RX_P4: length 253.7
  IN1 w0.102: v2(219.72,65.8) 219.72,66.5 219.51,66.71 219.06,66.71 217.89,65.54 217.89,65.06 217.41,64.57 212.49,64.57 211.36,63.44 210.25,63.44 208.16,61.35 208.16,61.07 207.6,60.51 207.6,52.56 205.87,50.83 205.87,48.7 203.47,46.3 203.47,44.42 197.33,38.27 197.13,38.27 192.68,33.83 168.76,33.83 168.6,33.99 162.91,33.99 162.75,33.83 146.09,33.83 143.62,36.3 142.86,36.3 141.59,37.57 139.55,37.57 138.88,38.25 114.44,38.25 111.47,35.28 110.5,35.28 106.16,30.93 52.39,30.93 51.91,30.45 51.12,30.45 50.78,30.11 v2(50.78,29.45)
  BOTTOM w0.121: v2(50.78,29.45) 50.78,30.87 51.76,31.85 51.76,35.15 51.21,35.7 51.21,38.36 49.11,40.46 43.19,40.46 40.23,43.42 40.23,45.3 31.32,54.21 27.03,54.21 26.57,53.75 24.88,53.75 23.93,54.69 22.02,54.69 21.44,55.28 20.2,55.28 ; v1(20.2,55.06) 20.2,55.28 ; 20.2,55.28 14.56,55.28 14.48,55.2 CON6700.42 ; v2(219.72,65.8) 219.72,65.48 U2000.G11
USB3_RX_P6: length 248.3
  IN1 w0.102: v2(221.37,63.54) 221.76,63.94 221.76,64.08 221.68,64.15 218.51,64.15 218.01,63.66 212.89,63.66 211.76,62.53 210.64,62.53 209.07,60.97 209.07,60.69 208.51,60.13 208.51,51.62 206.91,50.02 206.91,48.27 204.51,45.87 204.51,44.06 197.25,36.8 196.95,36.8 193.06,32.91 168.17,32.91 168,33.08 163.29,33.08 163.13,32.91 145.69,32.91 143.31,35.29 142.42,35.29 141.15,36.56 139.17,36.56 138.54,37.19 128.18,37.19 127.88,36.9 114.7,36.9 107.35,29.55 60.1,29.55 59.28,28.72 49.95,28.72 49.69,28.99 49.38,28.99 v2(48.93,29.45)
  BOTTOM w0.121: v2(48.93,29.45) 49.3,29.07 49.3,28.81 49.08,28.58 48.32,28.58 47.81,29.09 47.81,31.65 38.07,41.38 34.25,41.38 33.68,41.95 25.69,41.95 23.73,39.99 23.73,37.52 22.28,36.08 18.95,36.08 17.68,37.35 17.4,37.35 17.27,37.48 U6701.4 U6701.7 16.12,37.48 15.98,37.35 15.09,37.35 14.82,37.07 14.38,37.07 14.25,37.2 CON6700.6 ; v2(221.37,63.54) 221.37,63.61 U2000.K13
USB3_TX_H_N1: length 8.7
  TOP w0.121: L5502.3 307.76,52.58 308.03,52.31 308.22,52.31 308.59,52.69 308.84,52.69 308.97,52.82 U5500.4 U5500.7 310.36,52.82 310.52,52.66 310.9,52.66 311.24,52.32 311.24,49.51 311.41,49.34 311.88,49.34 312,49.46 CON5500.8
USB3_TX_H_N2: length 9.1
  TOP w0.121: 309.51,77.15 308.19,77.15 308.06,77.28 U5502.7 U5502.4 306.71,77.28 306.56,77.13 306.21,77.13 305.74,76.66 304.93,76.66 304.63,76.96 RN5505.2 ; 309.51,77.15 v1(309.51,77.37) ; 309.51,77.15 310.34,77.15 310.77,76.72 311.88,76.72 312,76.84 CON5501.8
USB3_TX_H_P1: length 8.8
  TOP w0.121: L5502.2 307.76,51.78 308.06,52.08 308.31,52.08 308.69,52.45 308.82,52.45 308.95,52.32 U5500.5 U5500.6 310.38,52.32 310.49,52.43 310.8,52.43 311,52.23 311,49.41 311.31,49.1 311.86,49.1 312,48.96 CON5500.9
USB3_TX_H_P2: length 8.9
  TOP w0.121: RN5505.4 304.64,76.16 304.9,76.43 305.84,76.43 306.31,76.89 306.56,76.89 306.67,76.78 U5502.5 U5502.6 308,76.78 308.13,76.91 310.25,76.91 310.68,76.48 311.88,76.48 312,76.36 CON5501.9
USB3_TX_N1: length 211.8
  TOP w0.121: 190.02,31.81 190.02,32.87 188.92,33.98 188.92,39.39 191.04,41.51 194.99,41.51 197.35,43.87 197.35,52.37 203.06,58.08 203.96,58.08 v2(204.5,58.61) ; 190.02,31.81 190.02,30.92 190.98,29.96 190.98,26.48 193.42,24.04 193.42,20.23 194.31,19.34 195.36,19.34 195.69,19.67 v2(195.69,20.38) ; 190.02,31.81 v1(189.8,31.81) ; C5509.1 303.42,52.56 v2(303.27,52.41)
  IN1 w0.102: v2(195.69,20.38) 196.18,19.88 203.55,19.88 205.75,22.08 206.61,22.08 208.87,24.34 210.78,24.34 212.96,26.52 225.66,26.52 226.42,25.76 235.31,25.76 235.69,26.14 243.35,26.14 248.26,31.05 253.7,31.05 255.02,32.37 256.04,32.37 256.25,32.15 260.61,32.15 263.21,29.55 271.62,29.55 273.37,31.3 273.37,32.72 274.83,34.18 274.83,34.6 275.1,34.86 275.1,38.55 274.96,38.68 274.96,39.4 276.92,41.36 278.75,41.36 280.62,39.48 280.62,38.27 284.36,34.53 294.38,34.53 295.61,35.76 298.71,35.76 299.55,36.6 300.39,36.6 300.64,36.85 300.64,41.74 302.79,43.89 302.79,51.93 v2(303.27,52.41)
  BOTTOM w0.089: 217.25,63.25 217.48,63.25 217.6,63.35 217.9,63.35 U2000.B14
  BOTTOM w0.121: 217.25,63.25 216.5,63.25 216.16,63.58 213.72,63.58 213.59,63.72 212.8,63.72 212.42,63.33 210.03,63.33 206.49,59.79 205.68,59.79 v2(204.5,58.61)
USB3_TX_N1_C: length 1.5
  TOP w0.121: L5502.4 305.66,52.58 305.31,52.23 305.03,52.23 C5509.2
USB3_TX_N2: length 101.5
  TOP w0.121: v2(299.5,75.19) 299.9,75.59 299.9,76.1 300.27,76.47 300.5,76.47 300.67,76.64 C5511.1
  IN4 w0.102: v2(217.3,65.06) 217.57,64.79 219.07,64.79 219.5,65.22 220.31,65.22 220.87,65.78 221.41,65.78 221.86,66.24 221.86,68.63 222.79,69.55 225.39,69.55 225.88,70.04 225.88,72.08 226.65,72.85 226.65,73.26 227.36,73.97 239.12,73.97 241.9,71.19 241.9,70.2 242.27,69.83 244.25,69.83 245.4,68.69 251.49,68.69 252.29,67.89 254.68,67.89 255.92,66.64 262.1,66.64 262.61,67.15 268.6,67.15 270.14,65.62 274.58,65.62 274.83,65.87 284.64,65.87 285.59,66.82 286.81,66.82 288.49,68.5 290.32,68.5 293.93,72.12 294.67,72.12 295.38,72.83 295.38,73.44 296.7,74.76 299.62,74.76 299.71,74.85 299.71,74.98 v2(299.5,75.19)
  BOTTOM w0.121: U2000.B12 217.81,64.55 v2(217.3,65.06)
USB3_TX_N2_C: length 1.7
  TOP w0.121: RN5505.1 302.9,76.96 302.63,76.7 301.9,76.7 C5511.2
USB3_TX_N3: length 230.3
  IN1 w0.102: v2(36.91,41.89) 36.65,42.16 36.65,42.26 36.71,42.32 37.65,42.32 37.93,42.04 37.93,41.67 37.18,40.91 37.18,39.74 38.52,38.4 41.19,38.4 45.1,34.49 98.01,34.49 98.2,34.3 106.86,34.3 109.72,37.15 110.69,37.15 113.72,40.18 142.61,40.18 147.08,35.71 161.97,35.71 162.17,35.91 170.78,35.91 170.99,35.71 190.01,35.71 191.74,37.43 192.51,37.43 200.73,45.65 200.73,57.17 203.93,60.37 204.38,60.37 204.91,60.9 204.91,61.27 v2(205.01,61.37)
  BOTTOM w0.089: U2000.C13 218.12,64.14 217.63,64.14 217.54,64.05 217.5,64.05
  BOTTOM w0.121: 32.44,45.45 35.06,45.45 36.54,43.97 36.54,42.27 v2(36.91,41.89) ; 32.44,45.45 29.95,45.45 29.42,45.98 26.09,45.98 25.09,46.99 23.03,46.99 C6709.1 ; 32.44,45.45 v1(32.44,45.67) ; v2(205.01,61.37) 204.78,61.37 204.73,61.42 204.73,61.65 205.26,62.18 206.48,62.18 207.12,62.82 207.77,62.82 209.53,64.59 211.84,64.59 212.21,64.95 213.74,64.95 214.31,64.39 216.52,64.39 216.86,64.05 217.5,64.05
USB3_TX_N3_C: length 9.5
  BOTTOM w0.121: v1(18.7,49.18) 18.55,49.03 ; 18.55,49.03 19.48,48.1 20.32,48.1 21.32,47.1 21.55,47.1 C6709.2 ; 18.55,49.03 17.88,49.7 14.59,49.7 14.59,49.7 CON6700.31
USB3_TX_N4: length 238.9
  IN1 w0.102: v2(50.76,31.83) 50.45,32.14 50.45,32.14 50.36,32.23 50.36,32.36 50.46,32.46 54.45,32.46 54.77,32.14 105.69,32.14 110.01,36.46 110.98,36.46 114.01,39.48 142.22,39.48 146.69,35.01 162.26,35.01 162.45,35.2 170.06,35.2 170.25,35.01 192.11,35.01 196.21,39.11 196.21,40.13 201.44,45.36 201.44,56.81 203.88,59.25 206.04,59.25 207.12,60.33 207.12,61.12 v2(207.22,61.22)
  BOTTOM w0.121: v2(50.76,31.83) 50.5,32.09 50.5,37.4 48.01,39.89 43.06,39.89 39.73,43.21 39.73,44.91 31.34,53.3 26.84,53.3 26.78,53.25 24.44,53.25 24.05,53.63 23.02,53.63 ; 23.02,53.63 19.62,53.63 C6711.1 ; 23.02,53.63 v1(23.02,53.85) ; v2(207.22,61.22) 207.04,61.22 206.94,61.32 206.94,61.6 207.43,62.08 208.07,62.08 209.84,63.85 212.15,63.85 212.52,64.22 213.54,64.22 213.91,63.86 216.29,63.86 216.57,63.58 217.32,63.58 U2000.A14
USB3_TX_N4_C: length 5.1
  BOTTOM w0.121: CON6700.40 14.24,54.2 14.38,54.06 16.57,54.06 16.95,53.68 18.1,53.68 C6711.2
USB3_TX_N6: length 238.5
  IN1 w0.102: v2(204.87,57.24) 205.1,57.47 205.1,57.58 205.02,57.65 204.08,57.65 202.97,56.53 202.97,45.69 197.28,40 197.28,39.11 192.48,34.31 169.36,34.31 169.17,34.5 162.74,34.5 162.55,34.31 146.37,34.31 143.83,36.85 143.02,36.85 141.75,38.12 139.72,38.12 139.1,38.74 114.26,38.74 111.27,35.76 110.3,35.76 105.98,31.44 52.06,31.44 51.73,31.11 48.81,31.11 47.26,32.66 45.36,32.66 41.73,36.28 39.44,36.28 37.14,38.58 35.88,38.58 34.83,39.63 34.83,41.28 34.52,41.59 34.19,41.59 34.14,41.64 34.14,41.81 v2(34.38,42.04)
  BOTTOM w0.121: CON6700.8 14.25,38.2 14.38,38.33 14.39,38.33 15.01,38.33 15.3,38.61 15.96,38.61 16.09,38.48 U6701.9 U6701.2 17.3,38.48 17.43,38.61 17.68,38.61 18.37,39.3 18.37,40.16 19.03,40.82 21.9,40.82 21.9,40.82 22.01,40.82 22.2,40.62 23.35,40.62 25.51,42.78 33.96,42.78 34.38,42.37 v2(34.38,42.04) ; v1(210.98,62.62) 210.98,62.4 ; 210.98,62.4 212.71,62.4 213.26,62.95 216.06,62.95 216.23,62.78 217.69,62.78 U2000.B15 ; 210.98,62.4 210.14,62.4 205.41,57.67 205.29,57.67 v2(204.87,57.24)
