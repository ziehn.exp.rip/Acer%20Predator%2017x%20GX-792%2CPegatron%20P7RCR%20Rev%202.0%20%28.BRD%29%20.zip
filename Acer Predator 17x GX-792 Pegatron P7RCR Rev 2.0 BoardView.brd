# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_D<33>: length 24.9
  IN4 w0.102: v5(175.62,96.71) 175.72,96.71 176.11,96.32 177.95,96.32 178.19,96.56
  IN4 w0.127: v5(196.23,103.31) 195.85,103.69 192.71,103.69 186.21,97.18 179.66,97.18 179.04,96.56 178.19,96.56
  BOTTOM w0.17: v5(196.23,103.31) U7801.B3
  BOTTOM w0.184: U7000.F30 175.62,96.68 v5(175.62,96.71)
FBC_D<34>: length 26.4
  IN4 w0.102: v5(174.9,95.35) 175.22,95.66 175.76,95.66 175.82,95.6 177.22,95.6 178.04,94.78
  IN4 w0.127: v5(196.23,102.01) 195.8,101.58 192.6,101.58 185.78,94.76 178.06,94.76 178.04,94.78
  BOTTOM w0.1: U7801.C4 196.88,102.01 v5(196.23,102.01)
  BOTTOM w0.184: U7000.H29 174.85,95.35 v5(174.9,95.35)
FBC_D<35>: length 26.3
  IN4 w0.102: 175.22,96.33 175.78,96.33 176.05,96.06 177.57,96.06
  IN4 w0.127: 177.57,96.06 177.62,96.01 179.15,96.01 179.68,96.54 186.22,96.54 192.77,103.09 195.22,103.09 195.38,102.93 195.75,102.93 196.02,102.66 v5(196.88,102.66) ; v5(174.89,96.67) 175.22,96.33
  BOTTOM w0.17: U7801.C3 v5(196.88,102.66)
  BOTTOM w0.184: v5(174.89,96.67) 174.93,96.67 U7000.G30
FBC_D<36>: length 30.5
  IN4 w0.075: 199.8,104.22 199.8,103.48
  IN4 w0.127: 199.8,104.22 199.42,104.6 199.42,105.09 199.3,105.2 199.3,105.61 197.73,107.18 192.64,107.18 189.62,104.16 189.62,103.51 184.44,98.33 v5(184.44,97.7) ; v5(199.48,102.66) 199.48,102.67 199.46,102.69 199.46,103.13 199.8,103.48
  BOTTOM w0.102: v5(184.44,97.7) 184.44,97.62 183.21,96.39 180.67,96.39 180.48,96.58 179.76,96.58 179.65,96.68 179.28,96.68 178.95,96.35 U7000.B30
  BOTTOM w0.17: U7801.F4 199.3,102.48 199.3,102.49 v5(199.48,102.66)
FBC_D<37>: length 27.6
  IN4 w0.127: v5(199.48,103.96) 199.03,104.4 198.26,104.4 196.39,106.27 192.66,106.27 190.71,104.32 190.71,102.48 186.22,97.99 v5(185.39,97.99)
  BOTTOM w0.1: U7801.F3 199.48,103.31 v5(199.48,103.96)
  BOTTOM w0.102: U7000.A30 180.13,96.35 180.41,96.07 183.24,96.07
  BOTTOM w0.184: 183.24,96.07 183.59,96.07 184.11,96.6 185.39,97.87 v5(185.39,97.99)
FBC_D<38>: length 38.1
  IN4 w0.075: 200.45,103 200.45,104.15 200.36,104.25
  IN4 w0.102: 174.56,97.67 174.55,97.66 174.55,96.99
  IN4 w0.127: v5(174.21,96.66) 174.55,96.99 ; 200.36,104.25 200.36,104.72 200.08,105 200.08,106.11 198.16,108.03 192.13,108.03 183.16,99.07 183.16,98.38 182.89,98.1 179.73,98.1 179.04,97.41 178.33,97.41 178.08,97.67 177.61,97.67 177.43,97.49 176.82,97.49 176.46,97.85 174.73,97.85 174.56,97.67 ; v5(200.13,102.01) 200.14,102.02 200.14,102.04 200.56,102.47 200.56,102.89 200.45,103
  BOTTOM w0.17: v5(200.13,102.01) 200.12,102.02 200.11,102.02 U7801.G4
  BOTTOM w0.184: v5(174.21,96.66) 174.24,96.66 U7000.H30
FBC_D<39>: length 30.8
  IN2 w0.075: 199.8,104.15 199.8,103.6 200.1,103.31 v5(200.13,103.31)
  IN2 w0.127: 199.8,104.15 199.32,104.63 199.32,106.05 198.36,107.01 191.34,107.01 184.73,100.4 184.73,98.64 184.38,98.29 184.03,98.29 v5(183.34,97.6)
  BOTTOM w0.102: U7000.C30 178.4,96.7 178.86,96.7 179.11,96.95 179.67,96.95 179.78,96.84 180.92,96.84 181.01,96.74 182.48,96.74 v5(183.34,97.6)
  BOTTOM w0.17: U7801.G3 v5(200.13,103.31)
FBC_D<40>: length 22.6
  IN1 w0.127: v5(195.25,97.69) 194.79,98.16 192.25,98.16 187.29,93.2 181.11,93.2 180.89,93.41 180.89,93.75 180.51,94.14 179.63,94.14 179.17,94.59 v5(177.69,94.59)
  BOTTOM w0.1: v5(195.25,97.69) 195.5,97.45 196.22,97.45 U7801.B11
  BOTTOM w0.184: U7000.D27 v5(177.69,94.59)
FBC_D<41>: length 27.1
  IN1 w0.127: v5(173.5,93.23) 173.86,92.87 173.86,92.23 174.24,91.85 175.77,91.85 176,92.08 179.36,92.08 179.82,91.62 187.71,91.62 191.57,95.49 194.22,95.49 v5(194.9,96.17)
  BOTTOM w0.1: U7801.B12 196.23,96.81 195.54,96.81 v5(194.9,96.17)
  BOTTOM w0.184: v5(173.5,93.23) 173.53,93.23 U7000.J26
FBC_D<42>: length 25
  IN1 w0.127: v5(196.88,97.46) 196.61,97.19 191.95,97.19 187.42,92.66 180.16,92.66 178.7,94.12 176.08,94.12 v5(175.62,94.57)
  BOTTOM w0.17: U7801.C11 v5(196.88,97.46)
  BOTTOM w0.184: U7000.F27 v5(175.62,94.57)
FBC_D<43>: length 26.7
  IN1 w0.127: v5(196.88,96.16) 196.37,96.67 194.53,96.67 194.05,96.2 191.62,96.2 187.55,92.13 180.03,92.13 178.49,93.67 175.78,93.67 v5(174.89,94.55)
  BOTTOM w0.1: U7801.C12 196.88,96.81 v5(196.88,96.16)
  BOTTOM w0.184: v5(174.89,94.55) 174.95,94.55 U7000.G27
FBC_D<44>: length 26
  IN1 w0.075: 198.99,98.48 199.16,98.32 199.16,97.78 v5(198.83,97.46)
  IN1 w0.127: 198.99,98.48 197.74,99.73 192.5,99.73 187.34,94.57 182.33,94.57 v5(181.67,95.23)
  BOTTOM w0.102: v5(181.67,95.23) 181.28,94.84 179.19,94.84 178.95,94.6 178.55,94.6 178.2,94.25 U7000.C27
  BOTTOM w0.17: U7801.F11 v5(198.83,97.46)
FBC_D<45>: length 25.9
  IN2 w0.075: 198.5,98.41 198.5,97.24
  IN2 w0.127: v5(198.83,96.16) 198.83,96.89 198.5,97.22 198.5,97.24 ; v5(182.92,95.25) 183.35,94.82 185.95,94.82 189.99,98.86 198.05,98.86 198.5,98.41
  BOTTOM w0.1: v5(198.83,96.16) 198.83,96.81 U7801.F12
  BOTTOM w0.102: U7000.B27 178.95,94.25 179.28,94.58 182.6,94.58 182.92,94.9 v5(182.92,95.25)
FBC_D<46>: length 25.4
  IN1 w0.127: v5(200.13,97.46) 199.84,97.75 199.84,98.25 199.42,98.67 199.42,99.07 198.1,100.39 192.49,100.39 187.35,95.25 v5(184.35,95.25)
  BOTTOM w0.102: U7000.A27 183.35,94.25 v5(184.35,95.25)
  BOTTOM w0.17: U7801.G11 v5(200.13,97.46)
FBC_D<47>: length 32.7
  IN1 w0.075: 200.49,97.75 200.49,97.32 200.31,97.13 U7801.G12 v5(199.48,96.81)
  IN1 w0.127: 200.49,97.75 200.38,97.86 200.38,98.24 199.91,98.72 199.91,99.56 198.5,100.97 192.4,100.97 187.15,95.72 180.54,95.72 180.37,95.89 177,95.89 v5(176.33,95.23)
  BOTTOM w0.102: v5(176.33,95.23) 176.3,95.27 176.3,95.88 176.19,95.99 175.59,95.99 U7000.G29
  BOTTOM w0.17: U7801.G12 v5(199.48,96.81)
FBC_D<48>: length 44.6
  IN1 w0.127: v5(207.28,98.11) 207.68,97.71 208.1,97.71 208.44,97.37 208.44,92.46 205.29,89.31 190.83,89.31 188.91,87.4 178.8,87.4 178.49,87.71 174.98,87.71 174.56,88.13 174.56,88.68 v5(174.2,89.03)
  BOTTOM w0.184: U7000.H20 174.23,89.03 v5(174.2,89.03) ; U7801.V11 v5(207.28,98.11)
FBC_D<49>: length 37.3
  IN1 w0.127: v5(177.71,88.31) 177.96,88.06 178.79,88.06 178.98,87.87 188.72,87.87 190.67,89.82 204.64,89.82 207.67,92.86 207.67,96.42 v5(207.28,96.81)
  BOTTOM w0.184: v5(177.71,88.31) U7000.D18 ; v5(207.28,96.81) U7801.V12
FBC_D<50>: length 38.9
  IN1 w0.075: 205.65,95.85 205.65,97.76
  IN1 w0.127: v5(205.98,98.11) 205.98,98.08 205.65,97.76 ; v5(175.6,89.05) 175.6,89.05 176.12,89.57 178.5,89.57 179.21,88.86 188.38,88.86 190.46,90.94 204.37,90.94 205.6,92.17 205.6,95.8 205.65,95.85
  BOTTOM w0.184: U7801.U11 206.3,97.78 v5(205.98,98.11) ; U7000.G20 175.55,89.05 175.59,89.05 v5(175.6,89.05)
FBC_D<51>: length 37.5
  IN1 w0.075: v5(205.98,96.81) 206.3,96.48 206.3,95.97
  IN1 w0.127: 206.3,95.97 206.85,95.42 206.85,92.71 204.55,90.41 190.59,90.41 188.57,88.39 179.14,88.39 178.29,89.24 177.23,89.24 v5(177.02,89.02)
  BOTTOM w0.184: v5(205.98,96.81) U7801.U12 ; v5(177.02,89.02) 176.98,89.02 U7000.E20
FBC_D<52>: length 37
  IN1 w0.127: v5(176.3,91.15) 176.79,91.64 178.95,91.64 179.47,91.12 179.64,90.95 187.81,90.95 191.71,94.85 198.62,94.85 199.23,94.23 199.23,93.7 199.63,93.3 201.58,93.3 202.69,94.41 202.69,95.17 202.55,95.31 202.55,97.91 203.16,98.52 204.24,98.52 204.65,98.11 v5(204.68,98.11)
  BOTTOM w0.17: v5(204.68,98.11) U7801.P11 ; v5(176.3,91.15) 176.29,91.14 176.26,91.14 U7000.F23
FBC_D<53>: length 34.6
  IN1 w0.075: 205,95.94 205,96.48
  IN1 w0.127: 205,95.94 205.12,95.82 205.12,95.43 204.8,95.11 204.8,94.14 204.8,93.38 202.89,91.47 190.33,91.47 188.22,89.36 179.29,89.36 178.75,89.9 177.45,89.9 v5(176.99,90.36) ; 205,96.48 v5(204.68,96.81)
  BOTTOM w0.17: U7801.P12 v5(204.68,96.81)
  BOTTOM w0.184: v5(176.99,90.36) 176.96,90.36 U7000.E21
FBC_D<54>: length 34.1
  IN1 w0.075: 203.7,95.99 203.7,97.6
  IN1 w0.127: 203.7,95.99 203.65,95.93 203.65,95.38 204.17,94.86 204.17,93.69 202.54,92.06 190.25,92.06 188.03,89.84 179.42,89.84 179.03,90.23 177.89,90.23 v5(177.71,90.41) ; 203.7,97.6 U7801.N11 v5(203.38,98.11)
  BOTTOM w0.17: v5(203.38,98.11) U7801.N11
  BOTTOM w0.184: U7000.D21 v5(177.71,90.41)
FBC_D<55>: length 32.4
  IN1 w0.127: v5(177,91.15) 177.16,91.31 178.51,91.31 179.44,90.38 187.9,90.38 190.19,92.67 202.22,92.67 203.25,93.7 203.25,95.39 202.98,95.66 202.98,96.41 v5(203.38,96.81)
  BOTTOM w0.17: U7801.N12 v5(203.38,96.81)
  BOTTOM w0.184: U7000.E23 176.95,91.15 v5(177,91.15)
FBC_D<56>: length 43.5
  IN4 w0.127: v5(207.28,102.01) 207.65,101.64 207.65,100.59 206.25,99.19 204.53,99.19 204.25,98.91 204.25,98.7 204.1,98.55 203.29,98.55 202.98,98.23 202.98,94.85 202.4,94.27 201.69,94.27 201.47,94.48 195.25,94.48 195.18,94.55 190.99,94.55 186.09,89.65 181.27,89.65 180.13,90.78 178.64,90.78 178.31,91.12 177.85,91.57 175.46,91.57 174.91,92.12 v5(174.91,92.47)
  BOTTOM w0.17: v5(207.28,102.01) U7801.V4
  BOTTOM w0.184: U7000.G24 174.93,92.47 v5(174.91,92.47)
FBC_D<57>: length 40.8
  IN4 w0.075: 206.83,103.65 206.82,103.63 205,103.63 ; 204.35,102.9 204.36,102.9 204.36,102.32 204.35,102.32
  IN4 w0.127: v5(174.22,93.23) 175.16,94.16 178.86,94.16 179.9,93.12 180.81,93.12 182.04,91.89 185.67,91.89 192.91,99.12 199.29,99.12 199.53,99.37 200.68,99.37 202.67,101.36 203.53,101.36 204.35,102.18 204.35,102.32 ; 206.83,103.65 206.94,103.65 v5(207.28,103.31) ; 205,103.63 204.35,102.98 204.35,102.9
  BOTTOM w0.17: v5(207.28,103.31) U7801.V3
  BOTTOM w0.184: U7000.H26 v5(174.22,93.23)
FBC_D<58>: length 41.1
  IN4 w0.127: v5(206.87,100.92) 206.65,100.69 206.28,100.69 205.63,100.04 204.69,100.04 204.04,99.39 203.06,99.39 202.47,98.81 202.47,95.34 202.18,95.04 201.72,95.04 201.63,94.95 195.47,94.95 195.17,95.25 191.03,95.25 185.97,90.2 181.38,90.2 180.13,91.45 178.91,91.45 178.29,92.07 175.99,92.07 v5(175.6,92.46)
  BOTTOM w0.1: U7801.U4 206.65,101.99 206.65,101.15 v5(206.87,100.92)
  BOTTOM w0.184: v5(175.6,92.46) 175.64,92.46 U7000.F24
FBC_D<59>: length 38.5
  IN4 w0.127: v5(206.63,102.66) 206.63,101.48 206.14,100.99 205.48,100.83 204.11,100.83 203.69,100.41 202.43,100.41 200.5,98.48 192.93,98.48 185.87,91.42 181.71,91.42 180.56,92.57 179.65,92.57 178.4,93.83 176.18,93.83 v5(175.59,93.24)
  BOTTOM w0.17: v5(206.63,102.66) 206.63,102.66 206.62,102.66 U7801.U3
  BOTTOM w0.184: v5(175.59,93.24) 175.28,93.55 U7000.G26
FBC_D<60>: length 37.4
  IN4 w0.127: v5(204.11,100.27) 203.78,99.94 202.83,99.94 202.18,99.3 201.98,99.3 201.04,98.35 201.04,97.72 200.83,97.51 200.83,96.21 200.41,95.78 197.88,95.78 197.1,96.56 191.67,96.56 185.89,90.78 181.64,90.78 180.38,92.05 179.37,92.05 177.96,93.46 177.94,93.46 177.94,93.46 177.64,93.46 177.64,93.46 176.51,93.46 v5(176.27,93.23)
  BOTTOM w0.1: v5(204.11,100.27) 204.11,100.87 204.04,100.94 204.04,102.02 U7801.P4
  BOTTOM w0.184: U7000.F26 v5(176.27,93.23)
FBC_D<61>: length 34.5
  IN4 w0.127: v5(204.68,103.96) 204.3,104.34 201.87,104.34 201.32,103.79 201.32,102.01 200.29,100.97 192.76,100.97 185.88,94.1 180.89,94.1 180.5,93.71 180.5,93.63 v5(180.53,93.6)
  BOTTOM w0.1: v5(204.68,103.96) 204.68,103.31 U7801.P3
  BOTTOM w0.102: v5(180.53,93.6) 180.14,93.99 179.74,93.99 179.65,93.9 177.7,93.9 U7000.D26
FBC_D<62>: length 29.9
  IN4 w0.127: v5(203.38,102.01) 203.27,102.12 202.77,102.12 200.57,99.93 199.22,99.93 199.08,99.78 192.9,99.78 185.61,92.49 182.38,92.49 v5(181.27,93.6)
  BOTTOM w0.102: U7000.B26 178.97,93.55 179.32,93.2 180.88,93.2 v5(181.27,93.6)
  BOTTOM w0.17: U7801.N4 v5(203.38,102.01)
FBC_D<63>: length 30.7
  IN4 w0.127: v5(182.45,93.6) 182.9,93.15 185.6,93.15 192.85,100.4 198.73,100.4 198.83,100.49 200.47,100.49 203.29,103.31 v5(203.38,103.31)
  BOTTOM w0.102: U7000.C26 178.4,93.2 178.93,93.2 179.16,92.97 181.82,92.97 v5(182.45,93.6)
  BOTTOM w0.17: U7801.N3 v5(203.38,103.31)
FBC_DBI<0>: length 24.3
  IN2 w0.075: v5(198.18,77.68) 198.5,77.36 198.5,76.69
  IN2 w0.127: v5(179.85,78.5) 179.61,78.26 179.61,77.14 180.19,76.56 180.73,76.56 182.17,75.12 191.11,75.12 191.85,75.87 198.27,75.87 198.53,76.13 198.53,76.66 198.5,76.69
  BOTTOM w0.17: v5(198.18,77.68) U7800.R3
  BOTTOM w0.184: v5(179.85,78.5) 179.8,78.5 U7000.A5
FBC_DBI<1>: length 22.4
  IN2 w0.075: v5(198.18,83.53) 198.18,83.53 197.85,83.2 197.85,82.56
  IN2 w0.127: v5(178.38,80.63) 182.03,80.63 182.19,80.47 188.31,80.47 189.62,81.78 197.07,81.78 197.85,82.56
  BOTTOM w0.17: v5(198.18,83.53) 198.5,83.86 U7800.R12
  BOTTOM w0.184: v5(178.38,80.63) 178.37,80.63 U7000.C8
FBC_DBI<2>: length 41.5
  IN2 w0.075: 206.3,84.63 206.3,85.02 206.24,85.09
  IN2 w0.127: 206.3,84.63 206.4,84.54 206.4,83.95 v5(205.98,83.53) ; 206.24,85.09 205.95,85.37 205.95,88.71 204.42,90.24 189.62,90.24 187.08,87.71 174.08,87.71 v5(173.51,88.28)
  BOTTOM w0.1: U7800.E12 205.33,83.53 v5(205.98,83.53)
  BOTTOM w0.184: U7000.J18 173.52,88.28 v5(173.51,88.28)
FBC_DBI<3>: length 39.1
  IN2 w0.127: v5(205.33,78.98) 205.33,79.09 204.93,79.48 204.93,79.95 204.63,80.25 203.62,80.25 202.47,81.4 202.47,84.97 201.83,85.61 201.83,86.31 201.43,86.71 189.2,86.71 187.13,84.64 177.57,84.64 177.08,85.13 176.13,85.13 176.02,85.02 176.02,84.46 v5(175.62,84.07)
  BOTTOM w0.1: v5(205.33,78.98) 205.33,78.33 U7800.E3
  BOTTOM w0.184: v5(175.62,84.07) 175.63,84.07 U7000.F12
FBC_DBI<4>: length 28.6
  IN2 w0.075: 198.5,104.18 198.5,103.63 v5(198.83,103.31)
  IN2 w0.127: 198.5,104.18 198.25,104.43 198.24,104.43 196.83,105.84 192.81,105.84 185.96,98.99 v5(185.96,98.43)
  BOTTOM w0.102: 183.24,95.72 180.3,95.72 180.02,96 177.7,96 U7000.D29
  BOTTOM w0.17: U7801.E3 198.74,103.22 198.74,103.22 v5(198.83,103.31)
  BOTTOM w0.184: v5(185.96,98.43) 185.96,97.54 184.14,95.72 183.24,95.72
FBC_DBI<5>: length 26.9
  IN1 w0.075: v5(198.18,97.46) 198.18,97.46 198.5,97.78 198.5,98.3 198.48,98.32
  IN1 w0.127: v5(177,94.58) 177.93,95.5 179.06,95.5 179.76,94.8 180.57,94.8 181.34,94.03 187.46,94.03 192.57,99.14 197.66,99.14 198.48,98.32
  BOTTOM w0.17: U7801.E12 v5(198.18,97.46)
  BOTTOM w0.184: U7000.E27 176.98,94.58 v5(177,94.58)
FBC_DBI<6>: length 35.2
  IN2 w0.127: v5(176.31,89.04) 176.68,89.41 177.96,89.41 178.04,89.33 186.86,89.33 188.65,91.12 202.48,91.12 205.57,94.21 205.57,94.83 205.7,94.95 205.7,95.16 205.57,95.28 205.57,95.92 205.33,96.16 v5(205.33,96.16)
  BOTTOM w0.1: U7801.R12 205.33,96.81 205.33,96.16 v5(205.33,96.16)
  BOTTOM w0.184: v5(176.31,89.04) 176.26,89.04 U7000.F20
FBC_DBI<7>: length 35.7
  IN2 w0.127: v5(177.79,93.09) 185.93,93.09 187.84,95.01 200.52,95.01 200.64,95.13 200.64,98.53 200.79,98.67 200.79,100.54 201.71,101.46 203.49,101.46 204.68,102.65 v5(204.68,102.66)
  BOTTOM w0.102: v5(177.79,93.09) 177.68,93.2 177.23,93.2 176.88,93.55 U7000.E26
  BOTTOM w0.17: U7801.R3 204.73,102.71 204.73,102.71 204.68,102.66 v5(204.68,102.66)
FBC_EDC<0>: length 22.7
  IN2 w0.127: v5(177.02,78.52) 177.51,79.01 180.05,79.01 180.33,78.73 181.45,78.73 181.94,78.24 189.39,78.24 190.03,78.88 194.17,78.88 195.37,77.68 v5(196.88,77.68)
  BOTTOM w0.1: U7800.T3 197.53,77.68 v5(196.88,77.68)
  BOTTOM w0.184: v5(177.02,78.52) 177.05,78.55 U7000.D5
FBC_EDC<1>: length 23.3
  IN2 w0.127: v5(177.03,80.63) 177.94,81.54 179.67,81.54 180.15,81.06 187.86,81.06 189.62,82.82 193.34,82.82 193.87,83.35 196.18,83.35 196.8,83.98 197.32,83.98 v5(197.53,84.18)
  BOTTOM w0.17: v5(197.53,84.18) 197.57,84.14 U7800.T12
  BOTTOM w0.184: U7000.D8 v5(177.03,80.63)
FBC_EDC<2>: length 35
  IN2 w0.114: 205.15,86.35 205.15,85.01 v5(205.33,84.83)
  IN2 w0.127: 205.15,86.35 204.73,86.78 204.73,88.13 203.45,89.41 189.62,89.41 186.86,86.65 178.87,86.65 178.23,87.29 177.35,87.29 v5(176.98,86.92)
  BOTTOM w0.1: v5(205.33,84.83) 205.33,84.18 U7800.D12
  BOTTOM w0.184: v5(176.98,86.92) U7000.E17
FBC_EDC<3>: length 37.2
  IN2 w0.075: 204.87,78.66 204.44,78.66
  IN2 w0.127: v5(205.33,77.68) 205.34,77.7 205.34,78.19 204.87,78.66 ; 204.44,78.66 203.69,79.41 202.77,79.41 202.62,79.56 201.01,81.17 201.01,83.08 201.25,83.31 201.25,85.65 200.81,86.09 189.69,86.09 187.23,83.62 177.47,83.62 v5(177.02,84.07)
  BOTTOM w0.17: v5(205.33,77.68) 205.33,77.68 U7800.D3
  BOTTOM w0.184: U7000.E12 176.97,84.07 v5(177.02,84.07)
FBC_EDC<4>: length 25.3
  IN2 w0.075: 196.7,102.98 197.2,102.98 v5(197.53,103.31)
  IN2 w0.127: v5(177.02,96.7) 177.46,96.26 178.16,96.26 178.74,96.84 185.77,96.84 192.74,103.82 194.14,103.82 195.03,102.92 196.64,102.92 196.7,102.98
  BOTTOM w0.17: U7000.E30 176.67,96.35 v5(177.02,96.7) ; U7801.D3 v5(197.53,103.31)
FBC_EDC<5>: length 21.2
  IN2 w0.127: v5(197.53,96.81) 188.81,96.81 186.09,94.09 181.61,94.09 180.45,95.25 180.45,95.28 v5(180.47,95.31)
  BOTTOM w0.17: U7801.D12 v5(197.53,96.81)
  BOTTOM w0.184: U7000.B29 179.28,95.12 180.29,95.12 v5(180.47,95.31)
FBC_EDC<6>: length 35.5
  IN2 w0.075: 205,95.94 205,96.38
  IN2 w0.127: v5(175.61,90.36) 176.07,89.91 186.48,89.91 188.66,92.09 202.51,92.09 204.35,93.94 204.35,94.65 205.03,95.33 205.03,95.91 205,95.94 ; 205,96.38 205.33,96.71 v5(205.33,97.46)
  BOTTOM w0.184: v5(205.33,97.46) U7801.T12 ; U7000.G21 175.56,90.36 v5(175.61,90.36)
FBC_EDC<7>: length 38.5
  IN2 w0.075: U7801.T3 205.65,102.48 205.51,102.33 205.1,102.33 205,102.24 205,101.69 205.09,101.61 205.09,101.04
  IN2 w0.127: 205.09,101.04 204.69,100.64 203.91,100.64 203.6,100.34 202.03,100.34 201.58,99.89 201.58,98.86 201.03,98.31 201.03,94.71 200.75,94.42 188.71,94.42 186.39,92.11 177.5,92.11 177.15,92.46 v5(176.99,92.46) ; U7801.T3 205.98,103.31 v5(205.98,103.31)
  BOTTOM w0.17: v5(205.98,103.31) 205.66,102.98 U7801.T3
  BOTTOM w0.184: v5(176.99,92.46) 176.96,92.46 U7000.E24
FBC_VREFC: length 14.1
  TOP w0.432: v2(202.24,88.88) 201.88,88.52 C7804.1 201.88,86.09 201.68,85.88 201.68,85.23 v5(202.08,84.83)
  TOP w0.508: v5(202.72,93.71) 202.72,95.51 v5(202.08,96.16)
  BOTTOM w0.254: v5(202.08,84.83) U7800.K13 ; v5(202.08,96.16) U7801.K13
  BOTTOM w0.432: R7809.2 R7810.1 202.24,92.62 C7803.1 202.72,93.1 v5(202.72,93.71) ; R7809.2 R7811.2 v2(202.24,88.88) ; R7809.2 v1(201.28,90.86)
FBC_VREFC_Q: length 1.4
  BOTTOM w0.432: Q7800.3 R7809.1
FBC_WCK01: length 26.1
  IN1 w0.114: v5(198.18,78.98) 198.18,78.98 198.18,79.1 198.05,79.23 197.8,79.23 197.49,79.53 197.49,79.81 197.27,80.04 194.86,80.04 194.21,79.39 187.29,79.39 186.12,80.56 179.74,80.56 179.3,81 177.34,81 177.2,81.14 175.5,81.14 175.37,81.01 175.37,80.75 175.49,80.62 v5(175.62,80.62)
  BOTTOM w0.122: U7800.T4 197.85,78.82 198.02,78.98 v5(198.18,78.98)
  BOTTOM w0.14: v5(175.62,80.62) 175.7,80.7 175.7,80.7 U7000.F8
FBC_WCK01*: length 26.3
  IN1 w0.114: v5(174.88,80.66) 174.96,80.66 175.15,80.85 175.15,81.1 175.41,81.36 177.29,81.36 177.43,81.22 179.39,81.22 179.83,80.78 186.21,80.78 187.38,79.61 194.12,79.61 194.77,80.26 197.36,80.26 197.71,79.9 197.71,79.62 197.89,79.45 197.99,79.45 v5(198.18,79.63)
  BOTTOM w0.122: v5(198.18,79.63) U7800.T5
  BOTTOM w0.14: U7000.G8 174.96,80.66 v5(174.88,80.66)
FBC_WCK23: length 41.9
  IN2 w0.114: v5(174.18,84.1) 174.29,84.21 174.29,85.01 174.97,85.69 186.91,85.69 189.01,87.79 201.42,87.79 202.94,86.27 202.94,82.16 203.41,81.69 204.72,81.69 206.3,80.11 206.3,79.5 206.3,79.5 205.98,79 v5(205.98,78.98)
  BOTTOM w0.122: v5(205.98,78.98) U7800.D4
  BOTTOM w0.14: v5(174.18,84.1) 174.2,84.1 U7000.H12
FBC_WCK23*: length 41.9
  IN2 w0.114: v5(205.94,79.69) 206.08,79.84 206.08,80.02 204.63,81.47 203.32,81.47 202.73,82.07 202.73,86.18 201.33,87.57 189.1,87.57 187,85.48 175.06,85.48 174.5,84.92 174.5,84.31 174.54,84.27 174.54,83.97 174.61,83.9 174.74,83.9 v5(174.93,84.09)
  BOTTOM w0.122: v5(205.94,79.69) 205.94,79.42 205.82,79.31 U7800.D5
  BOTTOM w0.14: U7000.G12 175.25,83.54 175.14,83.43 174.98,83.43 174.89,83.53 174.89,84.05 v5(174.93,84.09)
FBC_WCK45: length 31.1
  IN2 w0.075: 198.51,101.15 198.5,101.15 198.5,101.68 v5(198.18,102.01)
  IN2 w0.114: v5(173.49,94.57) 173.65,94.41 173.65,94.16 174,93.81 178.61,93.81 179.16,94.36 179.16,95.3 179.74,95.89 185.96,95.89 190.65,100.58 198.14,100.58 198.51,100.95 198.51,101.15
  BOTTOM w0.122: U7801.D4 v5(198.18,102.01)
  BOTTOM w0.14: U7000.J27 173.53,94.57 v5(173.49,94.57)
FBC_WCK45*: length 31.1
  IN2 w0.114: v5(174.25,94.6) 174.21,94.64 174.05,94.64 174.01,94.6 173.92,94.6 173.87,94.55 173.87,94.25 174.09,94.03 178.52,94.03 178.94,94.45 178.94,95.39 179.65,96.1 185.87,96.1 190.56,100.8 197.23,100.8 197.43,101 197.64,101 197.69,100.95 197.69,100.85 197.74,100.8 198.05,100.8 198.29,101.04 198.29,101.25 v5(198.18,101.36)
  BOTTOM w0.122: v5(198.18,101.36) 198.18,101.53 198.03,101.68 U7801.D5
  BOTTOM w0.14: v5(174.25,94.6) 174.2,94.55 174.2,94.03 174.28,93.95 174.45,93.95 174.55,94.05 U7000.H27
FBC_WCK67: length 41.5
  IN2 w0.114: v5(174.89,91.12) 174.89,91.29 175.17,91.58 177.76,91.58 178.36,90.98 186.58,90.98 188.6,93 189.62,93 189.62,93 201.42,93 202.8,94.37 202.8,99.2 203.01,99.41 204.86,99.41 206.6,101.16 206.6,101.55 206.34,101.81 206.18,101.81 v5(205.98,102.01)
  BOTTOM w0.122: v5(205.98,102.01) U7801.T4
  BOTTOM w0.14: U7000.G23 174.92,91.12 v5(174.89,91.12)
FBC_WCK67*: length 41.5
  IN2 w0.114: v5(205.98,101.36) 205.98,101.46 206.11,101.59 206.25,101.59 206.38,101.46 206.38,101.25 204.77,99.63 202.92,99.63 202.58,99.29 202.58,94.46 201.33,93.21 189.53,93.21 188.51,93.21 186.49,91.19 178.45,91.19 177.85,91.8 175.08,91.8 174.77,91.49 174.59,91.49 v5(174.22,91.12)
  BOTTOM w0.122: v5(205.98,101.36) 205.98,101.53 205.82,101.68 U7801.T5
  BOTTOM w0.14: U7000.H23 v5(174.22,91.12)
FBC_ZQ_1_B: length 3.7
  TOP w0.432: v5(203.38,84.83) 203.38,84.83 202.77,85.44 202.77,86.6 v1(202.65,86.72) 202.91,86.99 R7812.2
  BOTTOM w0.254: U7800.H13 203.38,84.83 v5(203.38,84.83)
FBC_ZQ_2_B: length 4.6
  TOP w0.432: R7813.2 199.57,93.61 199.57,94.09 v1(200.26,94.77) 200.46,94.77 200.81,95.12 200.81,95.63 200.27,96.16 v5(200.13,96.16)
  BOTTOM w0.254: U7801.H13 v5(200.13,96.16)
FBD_CLK0: length 35.2
  IN1 w0.075: v5(163.38,54.07) 163.26,54.07 163.15,53.97 163.15,53.7 163.25,53.6 163.41,53.6 163.98,54.17
  IN1 w0.114: v5(167.41,56.38) 167.41,56.25 167.31,56.15 166.96,56.15 166.73,55.93 166.73,54.95 165.96,54.17 163.98,54.17
  IN4 w0.114: v5(167.41,56.38) 167.62,56.17 168.08,56.17 168.28,56.37 168.28,71.56 166.2,73.64 166.2,76.28 165.65,76.83 165.65,80.68 165.96,80.99 166.13,80.99 v5(166.45,81.3)
  BOTTOM w0.122: U7900.K11 163.49,53.75 163.38,53.85 v5(163.38,54.07)
  BOTTOM w0.14: U7000.Y8 166.45,81.25 v5(166.45,81.3)
FBD_CLK0*: length 35.1
  IN1 w0.075: v5(162.73,54.07) 162.98,53.82 162.98,53.63 163.18,53.43 163.51,53.43 164.04,53.96
  IN1 w0.114: v5(167.41,55.73) 167.2,55.94 167.05,55.94 166.95,55.84 166.95,54.86 166.05,53.96 164.04,53.96
  IN4 w0.114: v5(166.45,80.6) 166.29,80.75 166.03,80.75 165.87,80.59 165.87,76.92 166.42,76.37 166.42,73.73 168.5,71.65 168.5,56.28 168.17,55.95 167.63,55.95 v5(167.41,55.73)
  BOTTOM w0.122: v5(162.73,54.07) U7900.K10
  BOTTOM w0.14: v5(166.45,80.6) 166.45,80.55 U7000.Y7
FBD_CLK1: length 34.8
  IN1 w0.114: v5(169.35,81.3) 169.7,80.95 169.7,80.75 169.92,80.53 169.92,76.85 169.56,76.49 169.56,69.08 173.68,64.96 173.68,56.27 174.09,55.86 174.54,55.86 v5(174.83,56.15)
  IN4 w0.114: v5(178.91,54.07) 178.8,54.18 178.8,54.4 178.3,54.89 176.07,54.89 175.86,55.1 175.86,55.44 175.8,55.5 175.46,55.84 175.13,55.84 v5(174.83,56.15)
  BOTTOM w0.122: v5(178.91,54.07) U7901.K11
  BOTTOM w0.14: U7000.R8 169.35,81.25 v5(169.35,81.3)
FBD_CLK1*: length 34.8
  IN1 w0.114: v5(174.83,55.35) 174.53,55.64 174,55.64 173.46,56.18 173.46,64.87 169.34,68.99 169.34,76.58 169.7,76.94 169.7,80.44 169.56,80.59 v5(169.34,80.59)
  IN4 w0.075: 178.55,54.34 178.58,54.3 178.58,53.75 v5(178.91,53.42)
  IN4 w0.114: 178.55,54.34 178.21,54.68 175.98,54.68 175.65,55.01 175.65,55.35 175.37,55.63 175.11,55.63 v5(174.83,55.35)
  BOTTOM w0.122: v5(178.91,53.42) U7901.K10
  BOTTOM w0.14: U7000.R7 169.34,80.56 v5(169.34,80.59)
FBD_CMD<0>: length 33.2
  BOTTOM w0.1: 156.34,52.82 157.03,52.82 157.08,52.77 158.83,52.77 U7900.H4
  BOTTOM w0.102: 163.11,72.37 163.13,72.39 163.13,75.74 162.99,75.87 162.99,76.24 163.35,76.6 U7000.AD2
  BOTTOM w0.14: 156.34,52.82 156.02,53.14 155.76,53.14 153.93,54.96 153.93,63.08 160.43,69.58 162.28,69.58 163.11,70.4 163.11,72.37
FBD_CMD<1>: length 30.2
  TOP w0.102: 155.86,54.33 v5(156,54.2)
  TOP w0.14: 155.86,54.33 155.86,54.34 R7119.1
  BOTTOM w0.1: v5(156,54.2) 156.17,54.02 157,54.02 157.05,54.07 157.53,54.07 U7900.K2
  BOTTOM w0.102: 163.35,72.47 U7000.AD1
  BOTTOM w0.14: v5(156,54.2) 155.54,54.2 154.45,55.28 154.45,62.86 160.75,69.16 162.38,69.16 163.35,70.13 163.35,72.47
FBD_CMD<2>: length 31.8
  BOTTOM w0.1: U7900.M4 158.84,54.73 156.73,54.73 156.64,54.82
  BOTTOM w0.102: U7000.AD4 163.7,77.8 163.7,75.87 163.6,75.77 163.6,72.41
  BOTTOM w0.14: 163.6,72.41 163.6,69.82 162.52,68.75 161.08,68.75 154.98,62.65 154.98,55.65 155.81,54.82 156.64,54.82
FBD_CMD<3>: length 26.4
  BOTTOM w0.1: U7900.L5 159.98,54.4 160.11,54.52 160.11,56.17 160.51,56.57 160.51,60.08 160.25,60.34 160.11,60.34
  BOTTOM w0.102: U7000.AC1 164.05,75.89 163.84,75.68 163.84,72.37
  BOTTOM w0.14: 160.11,60.34 157.94,62.51 157.94,64.87 161.4,68.33 162.59,68.33 163.84,69.59 163.84,72.37
FBD_CMD<4>: length 27.1
  BOTTOM w0.1: U7900.L4 159.48,54.07 160.19,54.07 160.31,54.19 160.31,56.08 160.73,56.5 160.73,60.16 159.59,61.3
  BOTTOM w0.102: 164.12,72.37 164.12,75.38 164.4,75.66 164.4,76.2 164.05,76.55 U7000.AC2
  BOTTOM w0.14: 164.12,72.37 164.12,69.19 159.09,64.15 159.09,61.81 159.59,61.3
FBD_CMD<5>: length 27.2
  BOTTOM w0.1: 160.04,61.3 160.94,60.39 160.94,56.43 160.51,56 160.51,54.03 160.23,53.75 U7900.K5
  BOTTOM w0.102: U7000.AC3 164.05,77.23 164.4,76.88 164.4,76.55 164.6,76.35 164.6,75.41 164.49,75.3 164.49,72.37
  BOTTOM w0.14: 164.49,72.37 164.49,68.82 159.65,63.98 159.65,61.69 160.04,61.3
FBD_CMD<6>: length 28.3
  BOTTOM w0.1: U7900.K4 159.48,53.42 160.42,53.42 160.76,53.77 160.76,55.97 161.15,56.35 161.15,60.68
  BOTTOM w0.102: 164.87,72.37 164.9,72.4 164.9,76.4 165.1,76.6 165.1,77.1 U7000.AA3
  BOTTOM w0.14: 164.87,72.37 164.87,68.47 163.07,66.66 160.18,63.77 160.18,61.65 161.15,60.68
FBD_CMD<7>: length 27.1
  BOTTOM w0.1: 160.94,61.3 161.38,60.86 161.38,56.02 160.97,55.61 160.97,53.69 160.38,53.1 U7900.J5
  BOTTOM w0.102: 165.2,72.37 165.2,75.77 165.1,75.87 165.1,76.25 165.45,76.6 U7000.AA2
  BOTTOM w0.14: 160.94,61.3 160.71,61.52 160.71,63.08 165.39,67.76 165.39,69.47 165.2,69.66 165.2,72.37
FBD_CMD<8>: length 27.3
  BOTTOM w0.1: U7900.J4 159.46,52.79 160.36,52.79 161.25,53.68 161.25,55.46 161.58,55.79 161.58,61.16 161.44,61.3
  BOTTOM w0.102: 165.52,72.44 165.51,72.44 165.51,75.99 U7000.AA1
  BOTTOM w0.14: 161.44,61.3 161.25,61.48 161.25,62.82 165.91,67.48 165.91,69.53 165.52,69.93 165.52,72.44
FBD_CMD<9>: length 29.4
  BOTTOM w0.1: 161.82,61.3 161.82,55.67 161.66,55.51 161.66,53.65 162.52,52.79 163.4,52.79 U7900.J11
  BOTTOM w0.102: U7000.AA4 165.81,77.79 165.81,72.41
  BOTTOM w0.14: 165.81,72.41 165.81,70.15 166.43,69.53 166.43,67.2 161.82,62.59 161.82,61.3
FBD_CMD<10>: length 26.2
  BOTTOM w0.1: 162.19,61.3 162.11,61.22 162.11,55.68 161.86,55.42 161.86,53.74 162.5,53.1 U7900.J10
  BOTTOM w0.102: U7000.Y1 166.15,72.37
  BOTTOM w0.14: 166.15,72.37 166.15,70.44 166.95,69.64 166.95,66.92 162.38,62.36 162.38,61.49 162.19,61.3
FBD_CMD<11>: length 25.9
  BOTTOM w0.1: 162.87,61.3 162.32,60.74 162.32,55.59 162.06,55.34 162.06,54.89 162.51,54.44 163.01,54.44 U7900.L10
  BOTTOM w0.102: 166.5,72.37 166.5,76.2 166.15,76.55 U7000.Y2
  BOTTOM w0.14: 162.87,61.3 162.95,61.37 162.95,62.12 167.47,66.65 167.47,69.62 166.5,70.6 166.5,72.37
FBD_CMD<12>: length 27.3
  BOTTOM w0.1: 163.58,61.3 162.52,60.23 162.52,55.51 162.26,55.25 162.26,54.97 162.51,54.72 163.38,54.72 U7900.L11
  BOTTOM w0.102: 166.84,72.37 166.84,74.94 166.77,75.02 166.77,76.28 166.5,76.55 166.5,76.87 166.15,77.22 U7000.Y3
  BOTTOM w0.14: 163.58,61.3 163.58,61.95 168,66.37 168,69.74 166.84,70.89 166.84,72.37
FBD_CMD<13>: length 26.4
  BOTTOM w0.1: U7900.M11 163.38,55.37 162.95,55.37 162.75,55.57 162.75,60.01 163.91,61.17
  BOTTOM w0.102: U7000.V3 167.2,77.1 167.2,76.6 166.98,76.38 166.98,75.19 167.18,75 167.18,72.37
  BOTTOM w0.14: 163.91,61.17 164.55,61.81 164.74,61.81 R7106.1 166.03,63.42 168.52,65.9 168.52,69.67 167.18,71.01 167.18,72.37
FBD_CMD<14>: length 27.2
  BOTTOM w0.1: 165.95,54.22 165.81,54.07 164.68,54.07 U7900.K12
  BOTTOM w0.102: U7000.V2 167.55,76.6 167.2,76.25 167.2,75.48 167.52,75.16 167.52,72.37
  BOTTOM w0.14: 167.52,72.37 167.52,71.1 169.04,69.58 169.04,60.24 168.87,60.07 168.87,56.02 167.3,54.45 166.42,54.45 166.19,54.22 165.95,54.22
FBD_CMD<15>: length 28.3
  BOTTOM w0.1: 166.05,52.76 164.02,52.76 U7900.H11
  BOTTOM w0.102: U7000.V1 167.55,75.55 167.91,75.19 167.91,72.37
  BOTTOM w0.14: 167.91,72.37 167.91,71.18 169.56,69.53 169.56,55.92 166.4,52.76 166.05,52.76
FBD_CMD<16>: length 38.7
  BOTTOM w0.1: 186.36,52.75 183.44,52.75 U7901.M4
  BOTTOM w0.102: U7000.L3 172.45,77.22 172.8,76.87 172.8,76.55 173,76.35 173,75.64 172.89,75.53 172.89,73.1 173.56,72.44 178.6,72.44
  BOTTOM w0.14: 186.36,52.75 188.28,54.66 188.28,63.25 179.08,72.44 178.6,72.44
FBD_CMD<17>: length 36
  TOP w0.102: 186.42,54.01 v5(186.41,54.01)
  TOP w0.14: 186.42,54.01 186.44,54.03 R7118.1
  BOTTOM w0.1: U7901.K2 184.74,53.44 186.23,53.44
  BOTTOM w0.102: U7000.L2 172.45,76.55 172.8,76.2 172.8,75.85 172.57,75.62 172.57,73.06 173.26,72.37
  BOTTOM w0.14: 186.23,53.44 186.41,53.63 v5(186.41,54.01) 186.79,54.01 187.71,54.93 187.71,62.59 178.26,72.04 173.59,72.04 173.26,72.37
FBD_CMD<18>: length 34.6
  BOTTOM w0.1: 185.69,54.23 185.55,54.23 185.42,54.09 183.55,54.09 183.45,54.19 183.45,54.74 U7901.H4
  BOTTOM w0.102: 172.86,72.38 172.27,72.97 172.27,75.66 172.45,75.84 U7000.L1
  BOTTOM w0.14: 172.86,72.38 173.6,71.63 177.91,71.63 187.15,62.39 187.15,55.52 185.85,54.23 185.69,54.23
FBD_CMD<19>: length 33.1
  BOTTOM w0.1: U7901.J5 181.82,55.06 181.82,59.85 182.81,60.84 183.52,60.84
  BOTTOM w0.102: U7000.M4 172.1,77.8 172.1,75.87 172,75.77 172,72.88 172.48,72.4
  BOTTOM w0.14: 172.48,72.4 173.66,71.22 177.58,71.22 184.38,64.42 184.38,61.71 183.52,60.84
FBD_CMD<20>: length 31.4
  BOTTOM w0.1: U7901.J4 182.81,54.07 182.35,54.07 181.62,54.8 181.62,60 182.68,61.07
  BOTTOM w0.102: 172.05,72.39 171.75,72.69 U7000.M1
  BOTTOM w0.14: 182.68,61.07 183.11,61.07 183.71,61.66 183.71,64.35 177.26,70.8 173.64,70.8 172.05,72.39
FBD_CMD<21>: length 31.2
  BOTTOM w0.1: 182.51,61.23 181.42,60.13 181.42,54.51 182.18,53.75 U7901.K5
  BOTTOM w0.102: 171.63,72.39 171.49,72.53 171.49,75.79 171.4,75.88 171.4,76.25 171.75,76.6 U7000.M2 ; 182.58,61.3 182.51,61.23
  BOTTOM w0.14: 171.63,72.39 173.63,70.39 176.94,70.39 182.35,64.98 183,64.33 183,61.72 182.58,61.3
FBD_CMD<22>: length 32.8
  BOTTOM w0.1: U7901.K4 182.81,53.42 181.96,53.42 181.21,54.17 181.21,60.31 182.2,61.3
  BOTTOM w0.102: U7000.M3 171.4,77.1 171.4,76.6 171.2,76.4 171.2,72.37 171.2,72.37
  BOTTOM w0.14: 182.2,61.3 182.48,61.58 182.48,64.11 176.61,69.97 173.6,69.97 171.2,72.37
FBD_CMD<23>: length 32
  BOTTOM w0.1: U7901.L5 181.84,53.1 181.01,53.92 181.01,60.44 181.8,61.23
  BOTTOM w0.102: 170.9,72.37 170.9,76.35 170.7,76.55 170.7,76.9 170.35,77.25 U7000.P3
  BOTTOM w0.14: 170.9,72.37 170.9,72.27 173.61,69.56 176.29,69.56 181.84,64.01 181.84,61.27 181.8,61.23
FBD_CMD<24>: length 32.2
  BOTTOM w0.1: U7901.L4 182.81,52.77 182.35,52.77 182.24,52.88 181.63,52.88 180.81,53.7 180.81,60.57 181.28,61.04 181.28,61.3
  BOTTOM w0.102: U7000.P2 170.35,76.55 170.7,76.2 170.7,75.87 170.58,75.75 170.58,72.4 170.59,72.39
  BOTTOM w0.14: 181.28,61.3 181.28,63.84 175.97,69.15 173.46,69.15 170.59,72.02 170.59,72.39
FBD_CMD<25>: length 30.6
  BOTTOM w0.1: U7901.L11 178.91,52.77 179.89,52.77 180.61,53.49 180.61,60.8 180.75,60.94
  BOTTOM w0.102: U7000.P1 170.35,72.37
  BOTTOM w0.14: 170.35,72.37 170.35,71.85 173.5,68.7 175.61,68.7 180.75,63.56 180.75,60.94
FBD_CMD<26>: length 31.3
  BOTTOM w0.1: 180.41,61.14 180.41,53.71 179.78,53.09 179.24,53.09 U7901.L10
  BOTTOM w0.102: U7000.R4 170,77.8 170,75.46
  BOTTOM w0.14: 180.41,61.14 180.15,61.39 180.15,62.8 174.78,68.17 173.24,68.17 172.78,68.63 172.78,68.94 169.97,71.75 169.97,75.43 170,75.46
FBD_CMD<27>: length 27.6
  BOTTOM w0.1: 180.04,60.94 180.21,60.77 180.21,54.72 179.89,54.4 U7901.J10
  BOTTOM w0.102: U7000.R1 169.65,75.42 169.7,75.37
  BOTTOM w0.14: 180.04,60.94 179.56,61.42 179.56,61.97 175.28,66.25 173.95,66.25 172.26,67.94 172.26,68.96 169.7,71.52 169.7,75.37
FBD_CMD<28>: length 28.6
  BOTTOM w0.1: U7901.J11 178.91,54.72 179.79,54.72 180,54.93 180,60.38 179.73,60.66
  BOTTOM w0.102: 169.34,72.37 169.34,75.42 169.3,75.46 169.3,76.25 169.65,76.6 U7000.R2
  BOTTOM w0.14: 169.34,72.37 169.34,71.41 171.74,69.02 171.74,67.69 174.38,65.04 175.35,65.04 179.73,60.66
FBD_CMD<29>: length 28.6
  BOTTOM w0.1: 179.71,60.05 179.71,55.74 179.35,55.37 178.91,55.37 U7901.H11
  BOTTOM w0.102: U7000.R3 169.3,77.1 169.3,76.6 169.1,76.4 169.1,75.47 169,75.37 169,72.38 168.99,72.37
  BOTTOM w0.14: 168.99,72.37 168.99,71.33 171.22,69.11 171.22,67.27 R7107.1 177.12,61.37 178.39,61.37 179.71,60.05
FBD_CMD<30>: length 28.7
  BOTTOM w0.1: 175.97,54.8 176.05,54.72 177.46,54.72 177.61,54.56 177.61,54.07 U7901.K12
  BOTTOM w0.102: 168.6,72.37 168.6,75.37 168.8,75.57 168.8,76.35 168.6,76.55 168.6,76.86 168.25,77.21 U7000.U3
  BOTTOM w0.14: 175.97,54.8 175.65,55.12 175.65,58.31 175.4,58.55 175.4,61.11 170.69,65.83 170.69,69.22 168.6,71.31 168.6,72.37
FBD_CMD<31>: length 30.5
  BOTTOM w0.1: 176.38,52.66 176.51,52.79 178.24,52.79 U7901.M11
  BOTTOM w0.102: U7000.U2 168.25,76.55 168.6,76.2 168.6,75.77 168.27,75.44 168.27,72.37
  BOTTOM w0.14: 168.27,72.37 168.27,71.21 170.11,69.37 170.11,65.44 173.53,62.02 173.53,55.39 175.16,53.75 175.16,53.25 175.75,52.66 176.38,52.66
FBD_D<0>: length 24.9
  IN4 w0.102: v5(158.82,81.28) 159.76,80.34 159.76,77.45 160.47,76.74
  IN4 w0.127: v5(159.37,60.47) 159.76,60.85 159.76,62.98 161.23,64.46 161.23,75.97 160.47,76.74
  BOTTOM w0.1: U7900.V4 158.85,59.25 158.85,59.89 159.37,60.41 v5(159.37,60.47)
  BOTTOM w0.184: U7000.AK8 v5(158.82,81.28)
FBD_D<1>: length 23.1
  IN4 w0.127: v5(158.81,77.84) 158.68,77.84 157.02,76.19 157.02,67.18 155.34,65.5 155.34,61.35 v5(155.73,60.97)
  BOTTOM w0.1: 158.19,60.01 158.19,59.26 U7900.V3
  BOTTOM w0.17: 158.19,60.01 157.37,60.83 155.87,60.83 v5(155.73,60.97)
  BOTTOM w0.184: U7000.AK4 158.85,77.85 158.82,77.85 158.81,77.84 v5(158.81,77.84)
FBD_D<2>: length 21
  IN4 w0.127: v5(159.35,73.95) 159.52,73.95 160.25,73.21 160.25,65.39 158.09,63.22 158.09,61.1 158.22,60.97 158.22,59.88 v5(159.48,58.62)
  BOTTOM w0.102: U7000.AK2 159.15,76.58 158.79,76.22 158.79,74.29 159.14,73.95 v5(159.35,73.95)
  BOTTOM w0.184: v5(159.48,58.62) U7900.U4
FBD_D<3>: length 22.6
  IN4 w0.127: v5(159.22,73.16) 159.49,73.16 159.77,72.88 159.77,66.31 157.49,64.03 157.49,60.61 157.91,60.19 157.91,58.89 v5(158.83,57.97)
  BOTTOM w0.102: v5(159.22,73.16) 158.85,73.16 158.53,73.47 158.53,76.33 158.79,76.59 158.79,76.85 159.15,77.21 U7000.AK3
  BOTTOM w0.184: v5(158.83,57.97) 158.51,58.3 U7900.U3
FBD_D<4>: length 25.7
  IN4 w0.075: 159.16,59.7 159.26,59.6 159.68,59.6 159.8,59.47 159.8,58.24 159.85,58.2 159.85,57.78 159.8,57.74 159.8,56.42 159.79,56.41
  IN4 w0.127: v5(159.48,56.02) 159.79,56.33 159.79,56.41 ; 159.16,59.7 158.98,59.88 158.98,63.1 160.76,64.88 160.76,73.43 v5(159.21,74.98)
  BOTTOM w0.102: U7000.AK5 159.5,78.5 159.5,75.85 159.54,75.8 159.54,75.31 v5(159.21,74.98)
  BOTTOM w0.17: U7900.P4 159.16,56.35 v5(159.48,56.02)
FBD_D<5>: length 29.3
  IN4 w0.075: v5(158.83,56.67) U7900.P3 158.5,55.79 158.41,55.7 157.24,55.7
  IN4 w0.102: 159.22,77.17 159.22,78.63 158.85,79 v5(158.85,79.2)
  IN4 w0.127: 159.22,77.17 157.69,75.64 157.69,66.38 156.03,64.72 156.03,61.93 156.11,61.86 156.11,56.01 156.52,55.6 157.15,55.6 157.24,55.7
  BOTTOM w0.17: v5(158.83,56.67) U7900.P3
  BOTTOM w0.184: U7000.AK6 158.85,79.25 v5(158.85,79.2)
FBD_D<6>: length 35.5
  IN4 w0.102: v5(158.84,81.99) 158.49,82.35 157.71,82.35
  IN4 w0.127: 157.71,82.35 157.63,82.35 157.17,81.89 157.17,77.04 156.26,76.13 156.26,67.18 153.83,64.75 153.83,56.72 155.28,55.27 156.15,55.27 156.62,54.8 158.25,54.8 v5(158.83,55.37)
  BOTTOM w0.17: v5(158.83,55.37) U7900.N4
  BOTTOM w0.184: U7000.AK9 158.84,81.96 v5(158.84,81.99)
FBD_D<7>: length 27.4
  IN4 w0.075: 157.3,56.35 157.85,56.35 v5(158.18,56.02)
  IN4 w0.102: 159.49,76.54 159.67,76.72 159.67,77.04 159.5,77.21 159.5,78.95 159.34,79.11 159.34,79.36 v5(158.81,79.89)
  IN4 w0.127: 159.49,76.54 158.45,75.5 158.45,65.99 156.67,64.22 156.67,60.64 156.9,60.41 156.9,56.74 157.3,56.35
  BOTTOM w0.17: v5(158.18,56.02) U7900.N3
  BOTTOM w0.184: v5(158.81,79.89) 158.81,79.91 U7000.AK7
FBD_D<8>: length 20.5
  IN1 w0.127: v5(163.68,60.36) 163.36,60.68 163.36,63.27 162.36,64.27 162.36,74.57 v5(161.95,74.98)
  BOTTOM w0.1: v5(163.68,60.36) 164.03,60.01 164.03,59.27 U7900.V11
  BOTTOM w0.102: U7000.AG4 161.59,77.81 161.59,75.34 v5(161.95,74.98)
FBD_D<9>: length 26.6
  IN1 w0.102: 163.12,80.94 163.12,80.94 162.14,80.94 161.92,81.16
  IN1 w0.127: v5(165.25,60.5) 165.61,60.85 165.61,63.83 164.11,65.32 164.11,74.79 163.28,75.62 163.28,78.25 163.54,78.51 163.54,80.61 163.21,80.94 163.12,80.94 ; v5(162.25,82) 161.86,81.61 161.86,81.21 161.92,81.16
  BOTTOM w0.1: v5(165.25,60.5) 164.68,59.93 164.68,59.27 U7900.V12
  BOTTOM w0.184: v5(162.25,82) 162.25,81.95 U7000.AF9
FBD_D<10>: length 22.9
  IN1 w0.127: v5(164.03,58.62) 164.05,58.64 164.05,63.54 162.83,64.76 162.83,74.77 162.45,75.15 162.45,75.81 161.59,76.67 161.59,78.56 v5(160.9,79.24)
  BOTTOM w0.17: v5(164.03,58.62) 164.03,58.62 U7900.U11
  BOTTOM w0.184: v5(160.9,79.24) 160.94,79.24 U7000.AG6
FBD_D<11>: length 25.4
  IN1 w0.127: v5(165.33,58.62) 164.83,59.12 164.83,63.64 163.53,64.94 163.53,74.64 162.91,75.26 162.91,76.2 161.91,77.2 161.91,79.11 161.75,79.27 161.75,79.79 v5(160.94,80.59)
  BOTTOM w0.1: U7900.U12 164.68,58.62 v5(165.33,58.62)
  BOTTOM w0.184: v5(160.94,80.59) 160.94,80.56 U7000.AG7
FBD_D<12>: length 24.9
  IN1 w0.075: v5(164.03,56.02) 163.7,56.35 163.02,56.35
  IN1 w0.127: 163.02,56.35 162.03,57.33 162.03,62.75 160.72,64.07 160.72,76.4 160.02,77.1 160.02,77.62 v5(160.2,77.8)
  BOTTOM w0.17: v5(164.03,56.02) U7900.P11
  BOTTOM w0.184: U7000.AJ4 v5(160.2,77.8)
FBD_D<13>: length 28.2
  IN1 w0.127: v5(164.68,56.67) 164.52,56.51 164.52,55.84 164.18,55.49 162.88,55.49 161.29,57.08 161.29,62.41 160.19,63.51 160.19,76.36 159.65,76.9 159.65,77.99 v5(160.18,78.52)
  BOTTOM w0.17: v5(164.68,56.67) U7900.P12
  BOTTOM w0.184: v5(160.18,78.52) U7000.AJ5
FBD_D<14>: length 30
  IN1 w0.127: v5(160.14,79.9) 159.53,79.28 159.53,78.53 159.25,78.25 159.25,76.64 159.72,76.17 159.72,62.88 160.66,61.94 160.66,56.49 162.43,54.72 v5(164.03,54.72)
  BOTTOM w0.1: U7900.N11 164.03,55.37 v5(164.03,54.72)
  BOTTOM w0.184: U7000.AJ6 160.14,79.84 v5(160.14,79.9)
FBD_D<15>: length 26.8
  IN1 w0.075: 165,56.35 165,56.85 164.86,57 164.51,57 164.35,57.15 164.35,57.5 164.21,57.65 163.12,57.65
  IN1 w0.127: 163.12,57.65 162.73,58.04 162.73,63.23 161.39,64.57 161.25,64.71 161.25,76.78 161.28,76.81 161.28,78.15 v5(160.92,78.5) ; v5(165.33,56.02) 165,56.35
  BOTTOM w0.1: U7900.N12 164.68,56.02 v5(165.33,56.02)
  BOTTOM w0.184: v5(160.92,78.5) 160.92,78.52 U7000.AG5
FBD_D<16>: length 43.5
  IN1 w0.127: v5(166.45,79.9) 166.78,79.57 167.42,79.57 168.08,78.9 168.08,78.53 168.22,78.4 168.22,77.03 168.66,76.59 168.66,68.37 172.13,64.9 172.13,50.56 169.96,48.39 168.58,47.01 164.51,47.01 v5(164.02,47.5)
  BOTTOM w0.1: v5(164.02,47.5) 164.02,48.23 U7900.B11
  BOTTOM w0.184: U7000.Y6 166.45,79.85 v5(166.45,79.9)
FBD_D<17>: length 37.7
  IN1 w0.075: 165.63,48.55 165,48.55 v5(164.68,48.22)
  IN1 w0.127: v5(166.45,78.5) 166.86,78.09 167.26,78.09 167.47,77.89 167.47,67.77 170.94,64.3 170.94,51.39 168.34,48.8 165.88,48.8 165.63,48.55
  BOTTOM w0.17: v5(164.68,48.22) U7900.B12
  BOTTOM w0.184: U7000.Y5 166.45,78.55 v5(166.45,78.5)
FBD_D<18>: length 40.3
  IN1 w0.127: v5(163.38,48.87) 163.43,48.87 164.45,47.85 166.58,47.85 166.71,47.98 168.53,47.98 171.52,50.97 171.52,64.54 168.08,67.98 168.08,76.38 167.81,76.65 167.81,78.19 167.52,78.48 v5(167.23,78.48)
  BOTTOM w0.17: U7900.C11 163.7,49.2 v5(163.38,48.87)
  BOTTOM w0.184: v5(167.23,78.48) 167.23,78.53 U7000.V5
FBD_D<19>: length 35.7
  IN1 w0.127: v5(166.51,77.81) 166.35,77.65 166.35,76.98 167,76.33 167,67.32 170.36,63.96 170.36,51.75 168.21,49.6 165.98,49.6 165.33,48.95 v5(165.33,48.87)
  BOTTOM w0.1: v5(165.33,48.87) 164.68,48.87 U7900.C12
  BOTTOM w0.184: v5(166.51,77.81) 166.51,77.82 166.48,77.82 U7000.Y4
FBD_D<20>: length 36.5
  IN1 w0.075: 165.13,50.5 165.5,50.5 165.55,50.45
  IN1 w0.127: 165.13,50.5 165.09,50.45 164.4,50.45 164.24,50.61 v5(164.03,50.82) ; 165.55,50.45 166.48,50.45 166.5,50.43 167.83,50.43 169.81,52.41 169.81,63.6 166.25,67.15 166.25,76.35 165.8,76.8 165.8,78.55 v5(165.13,79.22)
  BOTTOM w0.17: U7900.F11 v5(164.03,50.82)
  BOTTOM w0.184: U7000.AA6 165.13,79.23 v5(165.13,79.22)
FBD_D<21>: length 32.9
  IN1 w0.075: v5(164.68,51.47) 165,51.8 165.53,51.8
  IN1 w0.127: v5(165.14,78.5) 165.45,78.19 165.45,77.46 165.25,77.27 165.25,76.43 165.78,75.9 165.78,66.71 169.19,63.3 169.19,54 166.94,51.75 165.58,51.75 165.53,51.8
  BOTTOM w0.17: v5(164.68,51.47) U7900.F12
  BOTTOM w0.184: U7000.AA5 165.14,78.54 v5(165.14,78.5)
FBD_D<22>: length 33.6
  IN1 w0.075: v5(163.38,51.47) 163.7,51.8 163.7,52.59
  IN1 w0.127: 163.7,52.59 164.07,52.96 166.5,52.96 167.99,54.46 167.99,57.77 167.72,58.04 167.1,58.04 166.96,58.18 166.96,63.7 164.81,65.86 164.81,75.29 163.8,76.3 163.8,77.95 v5(164.35,78.5)
  BOTTOM w0.17: U7900.G11 163.7,51.8 v5(163.38,51.47)
  BOTTOM w0.184: v5(164.35,78.5) 164.35,78.55 U7000.AC5
FBD_D<23>: length 31.9
  IN1 w0.127: v5(164.03,52.12) 164.24,52.33 164.4,52.49 166.32,52.49 166.41,52.4 166.77,52.4 168.58,54.21 168.58,63.07 165.31,66.34 165.31,75.47 164.17,76.61 164.17,77.61 v5(164.36,77.81)
  BOTTOM w0.102: v5(164.36,77.81) 164.36,77.83 U7000.AC4
  BOTTOM w0.17: U7900.G12 v5(164.03,52.12)
FBD_D<24>: length 40.1
  IN4 w0.102: 163.64,76.99 163.64,79.96 v5(163.02,80.58)
  IN4 w0.127: v5(159.48,48.22) 159.83,48.57 160.59,48.57 160.71,48.45 161.17,48.45 162.31,49.59 162.31,52.31 162.62,52.61 165.19,52.61 165.7,53.12 165.7,53.75 166.45,54.51 166.45,71.97 164.98,73.44 164.98,75.65 163.64,76.99
  BOTTOM w0.17: U7900.B4 v5(159.48,48.22)
  BOTTOM w0.184: U7000.AD7 v5(163.02,80.58)
FBD_D<25>: length 43.9
  IN4 w0.102: v5(164.35,79.9) 163.99,79.54 163.99,77.26
  IN4 w0.127: 163.99,77.26 165.48,75.77 165.48,73.6 166.95,72.13 166.95,51.56 166.55,51.16 166.55,47.46 166.18,47.09 162.33,47.09 161.62,47.8 158.6,47.8 v5(158.18,48.22)
  BOTTOM w0.17: U7900.B3 v5(158.18,48.22)
  BOTTOM w0.184: v5(164.35,79.9) 164.35,79.89 164.35,79.89 164.35,79.85 U7000.AC6
FBD_D<26>: length 36.3
  IN4 w0.075: v5(158.83,48.87) 158.5,49.2 158.5,49.75 158.6,49.85 159.66,49.85
  IN4 w0.102: 161.87,77.39 161.87,78.82 v5(162.26,79.2)
  IN4 w0.127: 159.66,49.85 159.89,50.08 160.19,50.08 161.34,51.24 161.34,52.88 162.08,53.61 162.08,55.12 162.94,55.98 162.94,60.43 164.92,62.42 164.92,72.16 163.79,73.29 163.79,75.46 161.87,77.39
  BOTTOM w0.17: U7900.C4 v5(158.83,48.87)
  BOTTOM w0.184: U7000.AF6 162.26,79.24 v5(162.26,79.2)
FBD_D<27>: length 39.6
  IN4 w0.075: 159.79,49.13 159.74,49.2 159.28,49.2 159.15,49.07 159.15,48.7 159,48.55 158.63,48.55 ; 165,57.08 165,56.33 ; 165,58.29 165,57.74
  IN4 w0.102: v5(163.05,79.2) 163.35,78.9 163.35,76.58
  IN4 w0.127: 163.35,76.58 164.45,75.47 164.45,73.3 165.98,71.77 165.98,61.84 164.85,60.71 164.85,58.44 165,58.29 ; 165,56.33 163.56,54.89 163.56,54.53 163.81,54.28 163.81,53.73 163.31,53.23 162.41,53.23 161.83,52.65 161.83,50.67 160.29,49.13 159.79,49.13 ; 165,57.74 165.11,57.64 165.11,57.18 165,57.08 ; 158.63,48.55 158.52,48.55 158.2,48.87 v5(157.53,48.87)
  BOTTOM w0.1: U7900.C3 158.18,48.87 v5(157.53,48.87)
  BOTTOM w0.184: U7000.AD6 163.05,79.25 v5(163.05,79.2)
FBD_D<28>: length 33.3
  IN4 w0.102: 161.61,77.05 161.61,79.52 161.98,79.89
  IN4 w0.127: 161.61,77.05 163.26,75.41 163.26,73.16 164.25,72.17 164.25,62.86 162.33,60.95 162.33,56.04 161.52,55.23 161.52,53.8 160.87,53.15 160.87,52.16 v5(160.15,51.45) ; v5(162.26,79.89) 161.98,79.89
  BOTTOM w0.1: v5(160.15,51.45) 160.13,51.47 159.48,51.47 U7900.F4
  BOTTOM w0.184: v5(162.26,79.89) 162.26,79.94 U7000.AF7
FBD_D<29>: length 34.2
  IN4 w0.102: v5(162.28,80.58) 161.89,80.58 161.31,79.99 161.31,76.86
  IN4 w0.123: 159.26,51.25 v5(158.83,50.82)
  IN4 w0.127: 161.31,76.86 162.75,75.42 162.75,72.76 163.54,71.98 163.54,63.32 161.73,61.51 161.73,56.11 160.98,55.36 160.98,53.96 160.33,53.31 160.33,52.89 159.87,52.43 159.87,51.87 159.26,51.25
  BOTTOM w0.171: U7900.F3 v5(158.83,50.82)
  BOTTOM w0.184: U7000.AF8 162.28,80.62 v5(162.28,80.58)
FBD_D<30>: length 27.4
  IN4 w0.127: v5(158.83,52.12) 159.76,53.05 159.76,53.53 160.46,54.23 160.46,55.5 161.14,56.18 161.14,62.11 162.78,63.75 162.78,71.58 v5(161.95,72.41)
  BOTTOM w0.102: v5(161.95,72.41) 162.34,72.8 162.34,76.16 161.95,76.55 U7000.AF2
  BOTTOM w0.17: v5(158.83,52.12) U7900.G4
FBD_D<31>: length 30.1
  IN4 w0.075: 157.85,52.37 157.85,51.8 v5(157.53,51.47)
  IN4 w0.127: v5(161.95,71.28) 162.31,70.92 162.31,64.52 160.55,62.76 160.55,56.25 159.92,55.62 159.92,54.55 159.21,53.84 159.21,53.17 159,52.96 158.44,52.96 157.85,52.37
  BOTTOM w0.1: v5(157.53,51.47) 158.18,51.47 U7900.G3
  BOTTOM w0.102: 162.59,72.45 162.59,76.26 162.3,76.55 162.3,76.86 161.95,77.21 U7000.AF3
  BOTTOM w0.184: v5(161.95,71.28) 162.59,71.92 162.59,72.45
FBD_D<32>: length 23.8
  IN1 w0.127: v5(183.35,60.13) 183.35,60.74 183.49,60.87 183.49,63.44 175.77,71.16 175.77,76.51 176.04,76.78 176.04,77.7 175.58,78.16 v5(175.58,78.5)
  BOTTOM w0.1: U7901.B4 183.44,59.25 183.44,60.04 v5(183.35,60.13)
  BOTTOM w0.184: v5(175.58,78.5) 175.6,78.5 U7000.F4
FBD_D<33>: length 21.2
  IN1 w0.127: v5(176.9,75.21) 177.4,74.71 177.4,71.34 185.07,63.67 185.07,60.14 184.2,59.27 v5(184.11,59.27)
  BOTTOM w0.102: U7000.E1 176.9,75.8 v5(176.9,75.21)
  BOTTOM w0.17: v5(184.11,59.27) U7901.B3
FBD_D<34>: length 23.3
  IN1 w0.127: v5(175.58,77.16) 175.58,77.11 174.88,76.41 174.88,71.09 182.71,63.26 182.71,60.83 182.4,60.53 182.4,59.68 v5(182.81,59.27)
  BOTTOM w0.1: v5(182.81,59.27) 182.81,58.62 U7901.C4
  BOTTOM w0.184: U7000.F3 175.66,77.16 v5(175.58,77.16)
FBD_D<35>: length 25.4
  IN1 w0.127: v5(183.46,58.62) 183.46,59.48 183.74,59.76 183.74,60.11 184.3,60.67 184.3,63.53 176.46,71.37 176.46,77.74 175.97,78.23 175.97,78.83 v5(175.62,79.17)
  BOTTOM w0.17: v5(183.46,58.62) U7901.C3
  BOTTOM w0.184: v5(175.62,79.17) 175.65,79.15 U7000.F5
FBD_D<36>: length 28.9
  IN1 w0.075: 184.98,55.7 184.43,55.7
  IN1 w0.127: 184.43,55.7 184.11,56.02 v5(183.46,56.02) ; v5(178.37,75.07) 187.41,66.03 187.41,57.11 186.35,56.05 186.07,56.05 185.72,55.7 184.98,55.7
  BOTTOM w0.102: U7000.D2 177.7,76.4 177.7,75.74 v5(178.37,75.07)
  BOTTOM w0.17: U7901.F4 v5(183.46,56.02)
FBD_D<37>: length 26.4
  IN1 w0.127: v5(184.76,56.02) 184.96,56.22 185.52,56.22 185.83,56.53 185.83,56.78 186.03,56.98 186.42,56.98 186.71,57.26 186.71,65.86 178.38,74.19 v5(178.38,74.31)
  BOTTOM w0.1: v5(184.76,56.02) 184.11,56.02 U7901.F3
  BOTTOM w0.102: U7000.D1 177.35,75.34 v5(178.38,74.31)
FBD_D<38>: length 26.4
  IN4 w0.127: v5(182.81,55.37) 182.36,54.92 182.05,54.92 181.77,55.2 181.77,59.99 182.38,60.6 182.38,73.02 179.55,75.85 179.55,76.52 179.26,76.81 178.69,76.81 v5(178.38,77.12)
  BOTTOM w0.17: v5(182.81,55.37) 182.82,55.38 U7901.G4
  BOTTOM w0.184: v5(178.38,77.12) 178.37,77.13 U7000.C3
FBD_D<39>: length 31.6
  IN1 w0.127: v5(184.11,55.37) 184.08,55.37 183.73,55.03 183.73,54.45 184,54.19 185.71,54.19 188.14,56.62 188.14,66.5 179.93,74.71 179.55,74.71 178.82,75.43 178.82,75.97 v5(178.38,76.42)
  BOTTOM w0.17: U7901.G3 v5(184.11,55.37)
  BOTTOM w0.184: U7000.C2 v5(178.38,76.42)
FBD_D<40>: length 22.2
  IN4 w0.127: v5(173.54,78.5) 173.9,78.14 173.9,76.89 174.87,75.92 174.87,74.61 175.44,72.94 178.44,69.93 178.44,60.78 178.14,60.48 v5(178.14,60.04)
  BOTTOM w0.1: U7901.B11 178.25,59.28 178.25,59.93 v5(178.14,60.04)
  BOTTOM w0.184: U7000.J5 173.54,78.54 v5(173.54,78.5)
FBD_D<41>: length 21.2
  IN4 w0.127: v5(176.97,60.6) 176.97,69.85 174.33,72.49 174.33,73.27 174.3,73.3 174.3,73.3 v5(173.86,73.88)
  BOTTOM w0.1: U7901.B12 177.61,59.27 177.61,59.96 v5(176.97,60.6)
  BOTTOM w0.102: U7000.J4 174.2,77.8 174.2,75.85 174.3,75.75 174.3,74.32 v5(173.86,73.88)
FBD_D<42>: length 27.5
  IN4 w0.127: v5(172.73,81.78) 172.2,81.25 172.2,77.08 173,76.28 173.72,76.28 174.34,75.66 174.34,74.71 175.13,72.37 175.13,72.35 177.67,69.81 177.67,59.21 v5(178.26,58.62)
  BOTTOM w0.102: v5(172.73,81.78) 172.45,81.5 U7000.L8
  BOTTOM w0.17: v5(178.26,58.62) U7901.C11
FBD_D<43>: length 21.6
  IN4 w0.127: v5(173.84,74.97) 173.33,74.46 173.33,72.71 175.83,70.21 175.83,59.22 176.24,58.82 176.77,58.82 v5(176.96,58.62)
  BOTTOM w0.1: U7901.C12 177.61,58.62 v5(176.96,58.62)
  BOTTOM w0.102: U7000.J2 173.85,76.58 173.46,76.19 173.46,75.36 v5(173.84,74.97)
FBD_D<44>: length 23.6
  IN4 w0.075: 179.1,56.35 U7901.F11 178.31,56.63 v5(178.26,56.67)
  IN4 w0.127: 179.1,56.35 179.47,56.35 179.98,56.86 179.98,69.83 v5(177,72.82)
  BOTTOM w0.102: U7000.F1 175.8,75.9 175.8,73.94 176.93,72.82 v5(177,72.82)
  BOTTOM w0.17: U7901.F11 178.26,56.67 v5(178.26,56.67)
FBD_D<45>: length 25.1
  IN4 w0.075: 179.09,57 178.04,57 177.98,56.93
  IN4 w0.127: 177.98,56.93 177.71,56.67 v5(176.96,56.67) ; 179.09,57 179.43,57.33 179.43,60.45 179.15,60.73 179.15,69.99 176.43,72.71 176.43,73.67 v5(176.88,74.12)
  BOTTOM w0.1: U7901.F12 177.61,56.67 v5(176.96,56.67)
  BOTTOM w0.102: v5(176.88,74.12) 176.3,74.7 176.3,76.4 U7000.F2
FBD_D<46>: length 31
  IN4 w0.127: v5(174.84,77.8) 174.84,77.8 174.67,77.63 174.67,77.12 175.02,76.77 176.02,76.77 176.71,76.08 177.27,76.08 177.75,75.6 177.75,75.03 178.09,74.69 178.88,74.69 181.61,71.95 181.61,60.99 181.13,60.5 181.13,55.91 179.89,54.68 179.3,54.68 178.6,55.37 v5(178.26,55.37)
  BOTTOM w0.17: v5(178.26,55.37) U7901.G11
  BOTTOM w0.184: v5(174.84,77.8) 174.84,77.85 U7000.H4
FBD_D<47>: length 30.3
  IN4 w0.075: 178.56,55.7 U7901.G12 v5(177.61,56.02)
  IN4 w0.127: v5(174.9,78.55) 174.3,77.95 174.3,77.03 174.82,76.51 175.6,76.51 176.44,75.67 177.06,75.67 177.37,75.36 177.37,73.93 180.87,70.43 180.87,61.12 180.52,60.78 180.52,56.51 179.68,55.67 178.59,55.67 178.56,55.7
  BOTTOM w0.17: v5(177.61,56.02) U7901.G12
  BOTTOM w0.184: U7000.H5 174.85,78.55 v5(174.9,78.55)
FBD_D<48>: length 41.5
  IN2 w0.127: v5(178.91,48.22) 178.54,47.85 176.05,47.85 175.65,48.26 174.53,48.26 170.61,52.18 170.61,72.84 167.1,76.35 167.1,77.16 167.66,77.72 167.66,80.18 v5(167.24,80.6)
  BOTTOM w0.17: v5(178.91,48.22) U7901.V11
  BOTTOM w0.184: U7000.V7 167.24,80.56 v5(167.24,80.6)
