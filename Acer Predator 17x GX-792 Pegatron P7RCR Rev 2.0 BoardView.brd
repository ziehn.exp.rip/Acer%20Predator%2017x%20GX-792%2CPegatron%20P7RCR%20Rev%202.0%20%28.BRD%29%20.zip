# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS_TPM: length 29.2
  TOP w0.254: C6204.1 233.84,27.87 233.79,27.92 U6200.19 ; C6204.1 235.64,27.29 C6203.1 236.25,27.9 236.81,27.9 237.04,28.12 U6200.24 ; C6204.1 233.77,27.29 232.63,26.14 232.14,26.14 231.98,26.3 C6205.1 230.89,26.3 230.74,26.14 229.41,26.14 v1(228.01,27.54) 228.01,30.15 228.58,30.72 229.25,30.72 229.51,30.97 SR6202.2
  TOP w0.381: C6202.1 233.23,36.43 233.79,35.87 U6200.10
  TOP w0.508: SR6202.2 229.51,32.75 C6206.1 229.65,33.55 230.49,34.39 230.49,35.74 230.88,36.14 231.9,36.14 232.7,36.94 C6202.1
+3VS_TYPEC: length 19.7
  TOP w0.203: U1201.B1 291.95,55.7 291.31,55.05 291.31,54.94 291.19,54.82 ; U1201.H1 294.8,55.51 294.8,55.29 294.58,55.07 294.58,55.04 294.57,55.02 294.57,54.55 295.38,53.74 C1203.1
  TOP w0.381: R1228.2 R1230.2 ; R1230.2 R1232.2 R1231.2 287.56,56.43 v2(288.09,56.43) ; R1230.2 285.78,55.73 R1227.2
  TOP w0.432: 291.19,54.82 290.91,54.54 v2(290.18,54.54) 289.64,54.54 C1204.1
  TOP w0.508: C1203.1 295.36,53.66 v2(294.68,52.98)
  IN1 w0.508: v2(294.68,52.98) 294.1,52.39 292.83,52.39 292.39,52.84 291.17,52.84 290.18,53.83 v2(290.18,54.54) 289.99,54.54 v2(288.09,56.43)
  vias: v1(286.42,51.98)
+3VS_VGA: length 14.2
  TOP w0.279: U4601.27 v2(300.69,111) ; 295.97,114 U4601.6 ; U4601.36 301.1,115.5 301.48,115.88 C4636.2 ; U4601.9 296.27,112.5 ; U4601.30 v2(300.72,112.5) ; U4601.12 v2(296.04,111) ; U4601.33 v2(300.72,114) ; U4601.3 296.27,115.5 295.97,115.81
  TOP w0.432: v2(295.05,112.61) C4605.1 295.43,112 295.94,112.5 296.27,112.5 ; v2(302.22,116.26) C4636.2 ; v2(295.28,114.43) 295.28,114.23 295.05,114 C4612.1 295.62,113.66 295.97,114 ; v2(295.05,116.54) C4613.1 295.38,115.93 295.51,115.81 295.97,115.81 ; v2(302.88,121.55) 303.05,121.37 R4607.1
  vias: v1(294.87,106.76) v2(296.04,107.12) v2(296.65,107.12) v2(305.59,110.73) v2(305.59,110.09)
+3VS_WLAN: length 9.4
  BOTTOM w0.102: R5309.2 R5307.2 284.71,89.19 283.95,89.19 283.83,89.06 283.83,88.86 283.7,88.73 Q5303.1 283.25,89.02 282.63,89.64 280.52,89.64 279.95,89.07 Q5304.1 v1(279.95,87.05)
+3VSUS: length 879.9
  TOP w0.203: v2(240.31,61.27) 240.77,61.73 C2617.1 C2616.1 239.48,62.44 239.48,62.51 239.14,62.85 238.68,62.85 237.99,62.15 237.72,62.15 237.02,61.45 237.02,61.43 v2(236.82,61.24)
  TOP w0.254: R2107.1 v2(227.18,42.32) ; R2473.1 243.54,49.51 v2(242.84,49.51) 242.47,49.51 R2472.1 ; v2(246.87,65.87) 246.75,65.87 R2442.1 ; v2(244.23,58.2) 244.1,58.07 R2410.1 ; R2302.1 v2(230.21,42.3) ; v2(231.07,42.32) 231.03,42.36 R2304.1 ; v2(249.76,56.85) 249.16,56.85 R2335.1 ; v2(240.06,38.62) R2329.1 R2330.1 241.96,40.24 ; R2435.1 232.87,42.46 v2(232.73,42.32) ; R2327.1 237.6,41.43 v2(237.29,41.74) ; R2331.1 R2333.1 237.01,39.98 v2(237.01,39.58) ; R2432.1 244.89,53.07 v2(244.89,53.29) 244.89,53.32 R2431.1 ; v2(214.74,42.3) 214.48,42.55 R2243.1 ; v2(223.25,42.3) 223.25,41.26 222.23,40.24 R2113.1 ; v2(230.83,39.58) 230.83,40.12 R2309.1 ; v2(250.37,57.66) 251.01,57.66 251.25,57.42 R2406.1 252.02,57 252.36,56.67 252.36,55.79 251.84,55.27 R2407.1 ; v2(231.91,42.32) 231.92,42.33 R2303.1 ; R9202.1 182.43,41.47 182.32,41.36 U9201.5 183.18,40.41 183.5,40.09 v2(183.5,39.45) ; v2(225.15,42.32) R2108.1 R2119.1 ; v2(119.54,53.42) 119.34,53.42 119.06,53.14 119.06,50.12 119.28,49.89 120.76,48.42 120.76,31.35 v2(121.6,30.51) ; U9200.5 170.14,40.02 169.88,39.77 v2(169.88,39.45) ; R2328.1 239.24,41.65 v2(239.3,41.71) ; v2(249.59,52.58) 249.59,52.8 249.2,53.19 R2428.1 248.95,53.2 R2429.1 ; v2(246.97,49.28) 247.48,49.28 247.68,49.48 R2416.1 R2417.1 ; v2(237.55,79.42) 237.55,79.25 237.95,78.85 238.59,78.85 R2378.1 ; R2410.1 R2411.1 ; R2410.1 R2422.1 ; v2(228.45,42.33) R2105.1 ; R2248.1 v2(218.04,41.74)
  TOP w0.305: R2259.1 222.99,47.15 v2(223.15,47)
  TOP w0.356: v2(248.48,46.91) 248.78,47.2 Q2602.1 249.14,47.93 248.89,48.18 247.59,48.18 246.23,46.82 246.23,45.02 246.6,44.65 Q2601.3
  TOP w0.432: v2(238.87,72.51) 238.87,73.64 239.22,73.99 R2447.1 239.5,75.65 v2(239.22,75.93) 238.66,76.49 236.36,76.49 236.2,76.65 231.56,76.65 231.15,76.23 C2621.1 231.45,75.78 231.45,74.84 231.02,74.4 R2617.2 ; R6745.1 IC220.1 ; v2(247.25,51.77) 247.1,51.77 247.05,51.72 R2434.1 ; R3621.1 v2(3.66,46.97) ; R2334.1 242.53,42.17 ; R1242.1 292.74,69.22 v2(293.73,69.22)
  TOP w0.508: v2(252.52,51.89) SP2601.2 ; v2(177.5,27.58) 178.38,27.58 180.29,25.67 SR3101.2 ; R8838.1 R8837.1 271.05,31.17 v2(270.74,31.48) ; v2(297.41,62.97) 297.59,63.15 298.43,63.15 298.76,63.48 R5208.1 ; v2(62.85,123.96) 62.24,124.57 61.42,124.57 60.92,124.06 60.92,123.68 59.88,122.64 v2(59.88,120.89) 59.88,120.59 59.26,119.97 54.9,119.97 53.27,121.6 v2(47.43,121.6) ; v2(242.65,47.28) 242.54,47.17 SR2606.2
  TOP w1.524: 251.29,74.56 251.29,67.88 252.71,66.45 252.71,64.52 254.31,62.92 254.31,61.32 253.19,60.2 253.19,57.56 253.88,56.88 253.88,53.04 254.31,52.61 254.31,47.61 252.94,46.24 252.94,44.76 251.8,43.61 251.8,41.94
  IN1 w0.508: v2(242.84,49.51) 242.84,48.38 242.65,48.19 v2(242.65,47.28) ; v2(249.76,56.85) 250.17,56.85 250.37,57.05 v2(250.37,57.66) ; v2(285.24,54.35) 287.08,52.51 287.08,50.3 286.06,49.28 283.34,49.28 282.78,48.72 281.29,48.72 280.68,49.33 278.67,49.33 276.31,51.7 274.61,51.7 274.25,51.34 v2(273.92,51.34) 273.63,51.34 273.26,51.71 273.26,52.51 274.17,53.42 274.17,58.82 274.38,59.02 v2(274.38,60.28)
  IN2 w0.508: v2(245.95,74.94) 244.61,74.94 242.63,72.95 242.63,72.35 241.89,71.61 239.54,71.61 238.87,72.28 v2(238.87,72.51) ; v2(285.24,54.35) 286.76,54.35 287.36,54.95 289.19,54.95 290.02,55.79 295.69,55.79 296.08,56.18 297.41,57.51 v2(297.41,62.97) 298.86,64.42 298.86,65.44 301.11,67.69 v2(301.56,67.69) ; v4(259.58,37.57) 259.58,37.92 259.77,38.11 260.86,38.11 265.27,42.52 265.76,42.52 272.27,49.03 272.27,50.3 273.31,51.34 v2(273.92,51.34)
  IN2 w1.524: 252.3,74.96 252.3,76.87 252.38,76.94 252.38,83.27 253.73,84.61 253.73,85.27 254.84,86.39 254.84,86.9 254.82,86.93
  IN3 w0.381: 184.46,27.87 183.6,27.01 182.61,27.01 182.15,27.46 178.97,27.46
  IN3 w0.508: 169.92,28.24 177.49,28.24 ; v2(47.43,121.6) 45.78,121.6 44.56,120.38 44.56,119.31 46.13,117.74 46.13,114.6 44.84,113.31 44.84,93.25 46.72,91.37 46.72,86.03 30.67,69.98 24.54,69.98 22.18,67.62 22.18,63.46 19.03,60.31 ; v2(59.88,120.89) 62.31,118.45 62.31,113.14 62.19,113.01 62.19,108.47 v2(62.21,108.44) ; v2(149.18,27.52) 149.18,26.63 ; 170.47,26.97 174.88,26.97 175.18,27.26 177.63,27.26
  IN3 w0.635: 178.52,27.92 178.87,28.28 184.06,28.28 184.46,27.87
  IN3 w1.016: 228.86,35.95 236.99,35.95 238.16,37.12 241.89,37.12 ; 184.46,27.87 185.59,27.87 187.03,26.43 189.85,26.43 190.37,26.95 195.85,26.95 199.77,30.87 204.24,30.87 206.21,32.85 216.97,32.85 217.66,32.16 220,32.16 222.31,34.47 225.08,34.47 225.58,34.98 ; 19.95,59.8 20.3,59.44 20.3,56.24 24.16,52.38 24.16,47.56 25.13,46.59 27.54,46.59 28,46.13 28.63,46.13 29.85,44.91 29.85,30.25 29.03,29.42 29.03,26.45 30.49,24.99 30.49,23.53 31.47,22.54 31.47,21.54 32.71,20.3 34.45,20.3 35.41,21.26 39.51,21.26 40.98,19.79 54.46,19.79 55.1,19.16 60.13,19.16 63.3,22.33 95.31,22.33 96.02,21.62 108.34,21.62 111.69,24.98 116.49,24.98 121.37,29.85 122.08,29.85 ; 168.35,27.22 167.76,26.63 147.88,26.63 142.35,32.16 136.89,32.16 133.97,29.24 127.87,29.24
  IN3 w1.524: 257.05,88.58 259,88.58 261.23,90.8 261.23,93.52 262.31,94.6 264.33,94.6 264.76,95.03 265.03,95.03 266.63,96.63 266.93,96.63
  IN4 w0.305: v2(223.15,47) 223.15,43.34 223.24,43.24 223.24,42.3 v2(223.25,42.3)
  IN4 w0.508: 225.91,38.69 225.91,36.47 226.65,35.73 v2(226.65,35.36) ; v2(270.74,31.48) 270.74,32.09 268.03,34.81 266.2,34.81 265,36 265,36.65 264.13,37.52 263.76,37.52 263.23,38.06 260.05,38.06 259.58,37.58 v4(259.58,37.57)
  IN4 w1.27: 18.94,59.86 18.85,59.95 7.58,59.95
  IN4 w1.524: 286.97,98.51 287.84,98.51 288.4,99.06 291.54,99.06 293,100.51 295.51,100.51
  BOTTOM w0.203: v2(236.82,61.24) 236.83,61.23 236.83,60.94 U2000.BA20
  BOTTOM w0.254: v2(224.24,42.32) 224.24,42.55 R2114.1 ; R2436.1 244.05,51.72 244.51,51.72 v2(244.61,51.62) ; R2157.1 230.13,42.49 230.21,42.41 v2(230.21,42.3) ; R3167.1 275.88,58.4 275.38,58.89 SR3109.2 ; v2(249.59,52.58) 249.11,52.58 R2437.1 ; v2(62.85,123.96) 62.71,124.09 R4411.1 ; v2(244.89,53.29) 244.38,53.29 R2430.1 ; R2115.1 223.25,41.43 v2(223.25,42.3) 223.25,42.65 R2116.1 ; R2102.1 230.83,40.24 ; 230.83,40.24 v2(230.83,39.58) ; 230.83,40.24 R2103.1 ; v2(246.92,59.06) 246.92,59.13 246.5,59.56 R2409.1 246.85,59.77 246.92,59.7 R2408.1 ; R2363.1 226.27,35.74 v2(226.65,35.36) ; v2(249.59,51.36) 249.44,51.36 R2469.1 ; R2104.1 R2103.1 ; R2103.1 v2(230.02,39.58) ; v2(177.5,27.58) 177.5,28.3 183.5,34.3 v2(183.5,39.45) 183.01,39.94 170.37,39.94 v2(169.88,39.45) ; v2(232.73,42.32) 232.75,42.34 R2381.1 ; R2444.1 246.41,65.41 v2(246.87,65.87) 247.32,66.32 247.79,66.32 R2446.1 ; v2(231.91,42.32) R2100.1 ; R2357.1 R2332.1 238.64,42.29 239.21,41.71 v2(239.3,41.71) ; R2420.1 244.22,59.74 v2(244.24,59.72) ; U0702.5 121.14,79.47 121.15,79.48 C0702.1 121.72,75.14 121.01,74.43 119.14,74.43 116.54,71.84 116.54,66.43 116.63,66.34 116.63,61.07 118.55,59.15 118.55,53.88 119.01,53.42 v2(119.54,53.42) ; v2(236.96,42.32) R2358.1 ; R2120.1 227.51,39.66 v2(227.59,39.58) ; R2415.1 247.3,49.61 v2(246.97,49.28) 246.97,48.95 R2414.1 R2466.1 248.15,46.91 v2(248.48,46.91) 248.48,47.15 249.46,48.13 R2463.1 R2464.1 250.22,49.89 R2433.1 ; v2(239.22,75.93) 239.22,77.5 237.55,79.17 v2(237.55,79.42) ; v2(231.07,42.32) 231.07,42.37 231.02,42.42 R2305.1 ; R2371.1 236.03,42.44 v2(236.15,42.32) ; R2412.1 R2423.1 243.84,57.8 v2(244.23,58.2) ; R2107.1 v2(227.18,42.32) ; R2421.1 250.37,57.79 v2(250.37,57.66) ; v2(228.45,42.33) R2105.1
  BOTTOM w0.356: C2405.2 253.32,74.43 252.86,74.43 252.49,74.8 U2402.5 ; C0703.2 147.3,26.54 147.7,26.14 U0703.5 ; U2403.5 249.42,76.06 249.23,76.26 249.23,76.86 C2404.2
  BOTTOM w0.406: U2404.5 255.63,44.15 255.63,41.54 v4(254.39,40.3)
  BOTTOM w0.432: R2323.1 243.9,42.86 v2(244.02,42.73) ; v2(149.18,27.52) 149.18,27.49 148.63,26.94 147.9,26.94 147.86,26.98 C0703.2 ; R2804.2 251.42,61.83 251.82,61.42 251.82,60.1 v2(252.05,59.87) ; v2(250.25,75.52) 250.25,76.18 249.76,76.66 249.76,76.84 C2404.2 ; v2(253.14,75.22) 253.5,75.22 C2405.2 ; R2465.1 247.04,51.72 247.1,51.77 v2(247.25,51.77)
  BOTTOM w0.457: R0755.1 65.53,102.04 62.21,105.36 v2(62.21,108.44)
  BOTTOM w0.508: v2(3.66,46.97) 3.66,53.09 3.08,53.68 ; R5717.1 273.85,100.5 273.34,99.98 v2(273.26,99.98) ; SR3109.2 275.38,60.04 275.14,60.28 v2(274.38,60.28) ; v2(297.41,62.97) 298.38,62.01 298.38,50.96 301.35,47.99 301.35,45.83 302.64,44.54 302.64,43.69 301.86,42.91 301.86,40.88 301.57,40.59 R1160.1 ; v2(293.73,69.22) 298.05,69.22 299.59,67.69 v2(301.56,67.69) ; v2(275.6,98.51) 275.01,98.51 274.77,98.75 SR3305.1
  BOTTOM w1.016: 3.44,54.52 4.45,54.52 6.76,56.83 6.76,58.33
  vias: v2(2.6,54.19) v2(3.26,54.21) v2(6.38,59.34) v2(19.49,60.18) v2(241.23,39.02) v2(241.31,38.39) v2(241.46,45.57) v2(241.92,39.02) v2(241.94,38.41) v2(242.07,45.55) v2(242.7,45.55) v2(249.97,74.33) v2(250.6,74.33) v2(251.21,74.3) v4(7.14,59.24) v4(8.92,57.54) v4(19.41,59.39) v4(241.74,32.09) v4(242.17,31.22) v4(242.7,32.09) v4(243.03,31.22) v4(243.57,32.09) v4(243.9,31.22) v4(244.46,32.09) v4(254.96,86.97) v4(255.38,34.07) v4(255.83,86.93) v4(267.19,97.39) v4(268.24,97.89) v4(296.53,102.72) v4(296.53,101.84)
+3VSUS_IO: length 33.9
  IN3 w1.016: 10.7,83.34 9.48,82.13 5.59,82.13 4.52,81.06 v4(2.59,81.06)
  BOTTOM w1.016: 3.21,56.42 2.59,57.03 v4(2.59,81.06)
  vias: v1(11.41,83.37) v2(3.28,56.01) v2(3.94,55.99) v2(12.15,83.01) v2(12.17,83.62)
+3VSUS_LAN: length 28.5
  TOP w0.229: U3300.1 282.91,98.56 v2(283.42,98.05) ; v2(279.7,103.46) 279.69,103.45 U3300.16
  TOP w0.254: R3307.1 289.38,93.95 v2(289.41,93.98) 289.41,94.75 290.05,95.38 R3301.2
  IN2 w0.508: v2(279.7,103.46) 280.45,102.71 281.8,102.71 282.55,101.97 282.55,98.92 v2(283.42,98.05)
  IN4 w0.508: v2(283.42,98.05) 283.42,96.66 286.16,93.91 289.34,93.91 v2(289.41,93.98)
  BOTTOM w0.508: SR3305.2 C3311.1 276.59,101.09 C3309.1 277.24,102.1 C3322.1 278.83,102.59 v2(279.7,103.46)
  vias: v1(281.16,97.75)
+3VSUS_LC: length 19.5
  TOP w0.254: U1101.R6 292.82,43.67 v5(292.82,43.67)
  IN4 w0.254: v2(284.11,50.02) 284.11,49.82 288.71,45.22 289.11,45.22 289.47,45.58 291.79,45.58 292.82,44.55 v5(292.82,43.67)
  BOTTOM w0.127: v1(283.24,46.51) 283.37,46.64 R1113.1
  BOTTOM w0.254: R1112.1 R1113.1 R1115.1 R1114.1 283.83,49.33 284.11,49.61 v2(284.11,50.02) ; C1185.1 292.61,44.94 292.82,44.74 v5(292.82,43.67)
+3VSUS_PGPPA: length 37.6
  TOP w0.432: v2(250.98,59.42) 250.88,59.52 C2630.1
  TOP w0.508: v2(252.13,53.23) SP2601.1 v1(251.19,54.21)
  IN1 w0.381: v2(252.13,53.23) 252.7,53.8 252.7,56.97 250.98,58.68 v2(250.98,59.42)
  IN4 w0.381: v2(244.24,61.58) 245.28,61.58 245.94,60.92 247.92,60.92 248.52,60.32 250.08,60.32 v2(250.98,59.42)
  IN4 w0.508: v2(236.84,54.41) 236.84,54.08 239.58,51.34 240.08,51.34 240.11,51.37 240.62,51.37 241.79,50.2 247.2,50.2 248.97,51.97 249.84,51.97 251.1,53.23 v2(252.13,53.23)
  BOTTOM w0.203: U2000.BA31 237.04,54.74 236.84,54.54 v2(236.84,54.41)
  BOTTOM w0.254: v2(244.24,61.58) 244.2,61.58 244.12,61.49 R2250.1
+3VSUS_SPI: length 44.2
  TOP w0.254: R3101.1 171.63,21.44 175.37,21.44 175.86,21.94 175.86,22.5 175.89,22.52 175.89,22.53 175.92,22.55 175.98,22.61 v2(175.98,23.91)
  TOP w0.432: 176.92,33.59 177.15,33.82 177.15,35.64 176.33,36.46 175.11,36.46 174.8,36.76 173.11,36.76 172.83,36.48 R3116.1 ; v2(175.98,23.91) 175.98,24.29 175.72,24.54 R3124.1 U3101.8 176.32,26.25 C3100.1 C3101.1
  TOP w0.508: 176.92,33.59 176.92,32.14 177.68,31.38 177.68,28.84 175.37,26.52 U3101.8 ; C3101.1 178.87,25.69 v1(179.53,25.03) 180.23,24.33 SR3101.1 182.25,24.33 v2(182.51,24.07)
  BOTTOM w0.279: CON4402.3 177.5,19.72 177.7,19.52 178.3,19.52 178.5,19.72 CON4402.1 178.5,21.27 178.54,21.32
  BOTTOM w0.406: 178.54,21.32 C4404.2 179.25,22.16 181.17,24.07 v2(182.51,24.07)
  BOTTOM w0.432: R3117.2 175.93,23.86 v2(175.98,23.91)
+3VSUS_SX: length 61
  TOP w0.254: U1101.F8 297.06,42.7 v5(297.37,42.39) ; R1135.2 R1132.2 ; R1132.2 281.82,50.91 281.44,51.29 281.44,52.89 282.12,53.58 R1131.2 ; R1132.2 282.51,50.27 283.37,49.41 R1146.2 R1161.1 284.36,48.37 v2(283.95,48.37)
  TOP w0.305: v2(280.3,48.72) 280.84,48.18 U1102.5 ; C1109.1 276.49,48.24 v2(276.36,48.37) 276.15,48.37 275.14,49.38 275.14,49.54 v1(275.01,49.66) 275.01,50.83 v2(275.27,51.09)
  TOP w0.432: R1141.2 v2(291.06,49.56) ; R1140.2 v2(293.6,49.56)
  IN1 w0.508: v5(297.37,42.39) 297.37,42.23 296.95,41.81 295.84,41.81 295.41,42.24 295.41,45.09 294.92,45.58 292.54,45.58 292.05,46.07 292.05,46.86 293.6,48.42 v2(293.6,49.56)
  IN4 w0.254: v2(276.36,48.37) 278.09,48.37 278.44,48.72 v2(280.3,48.72) 283.6,48.72 v2(283.95,48.37)
  BOTTOM w0.254: R1138.2 289.54,50.05 ; 287.51,51.16 287.36,51.32 285.73,51.32 284.45,52.59 284.45,53.47 R1145.2
  BOTTOM w0.305: U1104.5 281.22,54.2 281.01,54.41 280.42,54.41 280.02,54.01 280.02,53.75 279.63,53.37 279.63,52.18 279.53,52.08 279.53,51.39 278.72,50.58 278.72,48.85 278.24,48.37 v2(276.36,48.37) ; v2(275.27,51.09) 274.68,51.67 C1110.1 274.68,52.71 274.5,52.89 271.91,52.89 271.66,52.64 271.66,51.54 272.31,50.89 U1105.5
+3VSUS_TPM: length 7.7
  TOP w0.305: U6200.5 237.04,36.16 236.97,36.22 C6200.1
  TOP w0.508: 240.59,36.67 240.59,36.16 240.98,35.77 v1(241.23,35.77) ; 240.59,36.67 240.08,36.16 239.04,36.16 C6201.1 237.61,37 237.45,36.84 C6200.1 ; 240.59,36.67 SR6201.1
+5V_FAN0: length 10.2
  TOP w0.762: 46.56,119.21 46.56,121.14 v4(45.42,122.28)
  BOTTOM w0.762: v4(45.42,122.28) 46.08,122.28 46.59,122.79 48.24,122.79 50.55,125.1 50.91,125.1
  vias: v1(51.59,125.1)
+5V_FAN1: length 17.9
  TOP w0.432: v2(256.71,84.82) 256.71,84.86 257.66,85.81 C5001.1
  TOP w0.508: v2(262.64,91.47) 262.46,91.29 U5002.3
  IN3 w0.508: v2(262.64,91.47) 262.64,90.63 259.47,87.46 259.33,87.46 256.71,84.84 v2(256.71,84.82)
  BOTTOM w0.508: CON5001.4 259.92,84.15 259.55,83.78 257.46,83.78 v1(257.36,83.67) 257.19,83.67 256.71,84.15 v2(256.71,84.82)
+5V_LED: length 3.5
  TOP w0.254: CON1.6 237.45,191.88 238.11,192.54 238.82,192.54 239.34,192.02 LR800.2
+5V_LED_RLED1_Q2: length 4.8
  TOP w0.254: v1(232.35,192.02) v2(231.83,191.5) LQ803.3
  BOTTOM w0.254: v2(231.83,191.5) 230.49,191.5 229.7,190.71 LLED802.2
+5V_LED_RLED2: length 6.6
  TOP w0.254: LR802.1 225.08,186.88 v1(225.47,187.27) 226.27,188.07 226.27,188.2 v2(227.38,189.31)
  BOTTOM w0.254: v2(227.38,189.31) 228.78,189.31 229.15,188.95 LLED802.1
+5V_RLED1: length 5.9
  TOP w0.254: v2(240.57,190.61) 240.68,190.72 LR800.1 241.31,191.58 v1(241.64,191.9)
  BOTTOM w0.254: v2(240.57,190.61) 241.1,190.08 242.04,190.08 243.17,188.95 LLED800.1
+5V_RLED1_Q: length 5.1
  TOP w0.254: v1(247.88,191.07) LQ800.3 v2(244.91,191.07)
  BOTTOM w0.254: v2(244.91,191.07) 244.08,191.07 243.7,190.69 LLED800.2
+5V_RYLED_R: length 12.7
  TOP w0.254: LQ801.3 v2(245.04,187.84)
  IN1 w0.254: v2(245.04,187.84) 244.79,188.09 237.5,188.09 236.43,189.17 v2(235.39,189.17)
  BOTTOM w0.254: LLED801.2 235.64,189.96 235.39,189.7 v2(235.39,189.17)
+5V_RYLED_R1: length 15.7
  TOP w0.254: LR803.1 248.32,187.21 248.16,187.36 v1(247.82,187.36) 247.7,187.25 v2(247.7,186.58)
  BOTTOM w0.254: v2(247.7,186.58) 247.69,186.57 236.35,186.57 236.19,186.74 LLED801.1
+5V_RYLED_Y: length 11.7
  TOP w0.254: v2(228.35,187.85) LQ802.3
  BOTTOM w0.254: v2(228.35,187.85) 231.67,187.85 232.82,189.01 233.83,189.01 235.51,190.69 236.91,190.69 237.2,190.4 LLED803.2
+5V_RYLED_Y1: length 6
  TOP w0.254: v2(241.46,187.48) 241.46,187.29 241.77,186.97 LR801.1
  BOTTOM w0.254: LLED803.1 238.12,188.02 240.92,188.02 241.03,187.91 v2(241.46,187.48)
+5V_USB: length 1
  TOP w0.508: v1(310.39,70.9) 310.24,71.05 310.24,71.84
  vias: v2(309.94,74.38) v2(309.94,73.77) v2(309.94,73.13) v2(309.94,72.52)
+5VA: length 377.4
  TOP w0.432: R5302.2 297.36,94.52 v2(297.11,94.27)
  IN1 w0.508: v2(94.85,185.66) 96.12,185.66 96.51,185.26 135.05,185.26 139.1,189.32 139.1,190.3 141.08,192.29 190.07,192.29 193.58,188.78 194.49,188.78 194.85,189.14 194.85,189.16 195.64,189.95 199.95,189.95 201.52,188.38 201.52,188.11 202.34,187.28 204.74,187.28 207.5,184.52 207.5,175.88 210.52,172.85 210.52,124.57 211.06,124.03 211.06,118.1 213.01,116.15 213.01,111.92 210.93,109.84 210.93,104.88 214.36,101.45 223.37,101.45 226.8,98.03 227.82,98.03 231.63,94.22 238.74,94.22 243.36,89.59 252.21,89.59 252.74,89.06 253.62,89.06 254.47,89.91 256.86,89.91 259.25,92.3 259.25,93.07 259.49,93.3 v2(262.59,93.3)
  IN2 w0.508: v2(297.11,94.27) 296.68,94.7 289.23,94.7 288.7,94.16 288.32,94.16 287.46,93.3 v2(262.59,93.3)
  IN4 w0.508: v2(267.01,58.53) 267.44,58.1 272.83,58.1 274.02,59.29 276.06,59.29 278.39,61.63 283.44,61.63 283.65,61.83 286.7,61.83 288.6,63.74 291.45,63.74 293.66,65.95 296.5,65.95 296.81,66.25 297.64,66.25 302.23,70.84 302.23,71.32 304.04,73.13 304.04,78.64 305.49,80.09 305.49,82.4 302.62,85.27 302.62,95.92 301.76,96.78 298.02,96.78 297.11,95.87 v2(297.11,94.27)
  BOTTOM w0.279: CON5602.27 94.75,185.05 94.85,185.15 v2(94.85,185.66)
+5VA_LED: length 17.8
  TOP w0.254: CON1.7 237.95,190.59 238.1,190.43 v2(238.92,190.43) ; LR803.2 250.82,187.21 v2(250.88,187.26) v1(250.88,188.35) ; v2(241.61,188.91) 242.21,188.31 LR801.2
  IN1 w0.254: v2(250.88,187.26) 250.82,187.21 247.09,187.21 245.57,188.73 241.63,188.73 241.61,188.75 v2(241.61,188.91) 240.44,188.91 v2(238.92,190.43)
+5VAO: length 3.5
  TOP w0.216: U8100.13 262.24,59.67 262.33,59.59 262.74,59.59 263.02,59.32 263.64,59.32 C8100.1
  TOP w0.381: C8100.1 264.02,59.54 T8100.1
+5VO: length 371.6
  TOP w0.203: C9105.1 196.88,37.17 196.74,37.02 U9100.4 ; U9101.4 C9114.1
  TOP w0.381: v2(33.36,50.3) 33.36,49.73 SR8302.1
  TOP w0.432: C9105.1 197.36,36.91 197.8,36.48 v2(198.62,36.48) ; v2(243.52,18.02) 243.26,18.27 C9114.1
  IN2 w0.508: v2(33.36,50.3) 33.36,48.57 31.25,46.46 31.25,35.52 31.98,34.78 33.18,34.78 35.39,32.57 40.08,32.57 45.46,27.19 103.38,27.19 104.83,28.63 107.98,28.63 109.73,26.88 120.67,26.88 122.32,28.53 124.26,28.53 126.58,30.84 128.99,30.84 129.5,30.84 134.95,25.39 161.28,25.39 162.46,26.57 165.68,26.57 165.82,26.72 176.25,26.72 176.38,26.84 181.48,26.84 182.87,28.22 187.85,28.22 188.94,27.13 196.39,27.13 199.87,30.62 202.59,30.62 203.56,29.65 220.63,29.65 222,28.28 v2(225.74,28.28)
  IN3 w1.016: 285.1,74.15 283.06,72.12 283.06,69.98 282.91,69.83 282.91,69.77 282.76,69.62 282.76,68.61 282.33,68.18 282.33,67.21 278.64,63.53 278.64,59.42 ; 225.46,28.28 225.46,32.13 226.08,32.75 230,32.75 231.04,33.79 238.68,33.79 239.42,34.53 242.88,34.53 244.84,36.48 250.49,36.48 251,35.97 251.9,35.97 252.89,36.96 256.58,36.96 257.58,37.95 258.54,37.95 259.35,38.77 260.48,38.77 267.19,45.47 268.21,45.47 270.74,48.01 270.74,53.38 275.21,57.84 276.97,57.84
  BOTTOM w0.508: 225.09,26.4 224.49,25.8 224.49,25.03 224.87,24.65 227.35,24.65 227.96,25.25 235.84,25.25 236.74,24.35 238.86,24.35 243.52,19.7 v2(243.52,18.02) ; 224.26,28.28 220.94,28.28 220.12,29.09 212.53,29.09 204.5,37.12 203.59,37.12 202.09,35.62 198.94,35.62 198.62,35.94 v2(198.62,36.48)
  vias: v4(285.73,77.48) v4(285.73,76.59) v4(286.62,78.32) v4(286.65,77.45) v4(286.65,76.56) v4(287.48,78.32) v4(287.51,77.45) v4(287.51,76.56) v4(288.35,78.32) v4(288.37,77.45) v4(288.37,76.56) v4(289.29,78.44) v4(289.31,77.58) v4(289.31,76.69)
+5VO_1_1: length 3.3
  TOP w0.508: v1(261.85,71.84) 261.42,72.27 D8102.3 ; C8120.1 259.48,71.09
+5VO_1_2:
  vias: v1(260.84,76.05)
+5VO_2_2: length 4
  TOP w0.508: D8103.3 255.12,71.2 255.85,70.48 ; 255.85,70.48 C8122.2 ; 255.85,70.48 256.73,71.36 v1(257.26,71.36)
+5VS: length 675.1
  TOP w0.305: C80025.2 67.15,169.82 U8004.29 ; C80082.2 53.99,164.59 U8006.29
  TOP w0.432: SR8002.2 103.42,161.69 103.53,161.81 108.44,161.81 109.5,160.74 115.29,160.74 116.34,161.79 116.34,162.7 117.2,163.56 119.77,163.56 120.25,163.08 v2(120.25,162.92) 120.25,162.54 R8718.1 ; R8717.1 R8720.1 v2(120.12,160.03) ; v2(54.72,164.45) SR8004.1 ; v2(274.68,84.67) 274.68,85.2 274.99,85.5 C1320.1 276.03,85.5 276.39,85.14 U1302.3 ; R8719.1 v2(120.1,158.73) ; SR8003.1 65.89,173.08 66.78,172.19 66.78,171.81 v2(67.42,171.18) 67.67,170.92 C80025.2
  TOP w0.508: v2(61.42,112.1) 60.99,112.53 49.23,112.53 47.61,114.15 44.18,114.15 43.47,114.87 43.47,116.57 ; C80082.2 v2(54.72,164.45) ; 261.38,92.56 v2(262.57,92.56) ; v2(268.08,87.48) 267.68,87.08 D5002.3
  IN1 w0.508: v2(120.25,162.92) 119.23,162.92 118.54,163.62 118.54,167.58 115.02,171.1 111.06,171.1 100.95,181.21 99.8,181.21 99.29,180.7 v2(99.29,180.45) ; v2(245.17,80.25) 245.65,79.76 253.61,79.76 254.72,80.87 254.72,81.64 v2(255.81,82.73) ; v2(70.74,184.29) 69.03,182.58 v2(61.8,182.58)
  IN1 w1.016: 263.12,85.07 266.43,85.07 267.85,86.49 ; 267.85,86.49 267.75,86.49 ; 267.85,86.49 275.6,86.49 279.13,90.02 280.65,90.02 282.56,91.93 295.36,91.93 295.64,91.65 307.1,91.65 308.53,90.22 308.53,87.2 308.11,86.78 308.11,84.67 306.58,83.14
  IN2 w0.254: v2(61.8,182.58) 61.78,182.58 60.71,183.65 60.71,186.01 59.95,186.77 58.76,186.77 58.58,186.6 54,186.6 52.73,187.86 v2(51.29,187.86)
  IN2 w0.508: v2(74.71,179) 74.71,179.58 v2(76.94,181.82) ; v2(74.03,161.6) 73.76,161.6 72.02,159.85 72.02,155.02 72.01,155.02 72.01,154.38 70.52,152.89 70.52,149.43 70.03,148.95 v2(70.03,143.62) ; v2(61.8,182.58) 62.76,182.58 64.95,180.39 64.95,177.07 v2(65.26,176.77) ; v2(43.64,117.13) 43.64,115.91 42.93,115.2 42.93,107.72 38.16,102.95 38.16,87.9 35.11,84.85 35.11,74.86 29.17,68.92 29.17,65.51 28.07,64.42 22.87,64.42 18.58,60.13 17.68,60.13 17.05,59.49 17.05,56.95 17.96,56.04 17.96,49.76 21.6,46.13 21.6,39.45 23.04,38.01 v2(23.04,33.84) ; v2(274.68,84.67) 274.68,85.07 274.05,85.71 270.54,85.71 268.76,87.48 v2(268.08,87.48) ; v2(67.16,144.79) 65,142.63 65,135.24 63.56,133.79 63.56,129.04 64.14,128.46 64.14,122.92 63.84,122.61 63.84,117.95 63.81,117.92 63.81,117.63 63.13,116.95 63.13,113.8 v2(61.42,112.1)
  IN3 w0.508: v2(120.25,162.92) 120.63,163.3 120.63,163.94 121.8,165.11 128.45,165.11 130.08,166.73 133.25,166.73 136.98,163.01 143.58,163.01 144.76,164.19 144.76,165.72 145.47,166.43 v2(146.26,166.43) ; v2(268.08,87.48) 265.38,87.48 263.34,89.52 263.34,91.64 262.57,92.41 v2(262.57,92.56) ; 66.73,165.28 67.6,164.42 67.6,164.04 67.9,163.74 v2(67.9,163.58) ; 66.73,165.28 57.33,165.28 56.54,164.5 54.77,164.5 v2(54.72,164.45) 54.72,165.01 54.31,165.41 50.58,165.41 48.16,167.82 48.16,170.77 47.68,171.25 v2(47.68,173.54) ; 66.73,165.28 66.76,165.28 67.47,166 68.38,166 70.36,164.01 70.36,163.36 72.12,161.6 v2(74.03,161.6) ; v2(99.29,180.45) 98.81,180.93 97.01,180.93 96.73,181.21 95.56,181.21 94.82,181.95 v2(94.82,182.02) 94.19,181.38 90.31,181.38 89.87,181.82 v2(76.94,181.82) 76.08,181.82 74.66,183.24 71.79,183.24 v2(70.74,184.29) ; v2(67.42,171.18) 67.42,173.84 66.02,175.24 66.02,176 v2(65.26,176.77)
  IN4 w0.254: v2(54.3,189.84) 54.3,189.24 53.71,188.65 52.08,188.65 v2(51.29,187.86)
  IN4 w0.508: v2(47.68,173.54) 48.75,173.54 49.21,174 50.04,174 50.86,174.81 55.24,174.81 56.08,173.97 v2(57.26,173.97) 59.47,176.18 v2(59.47,176.41) 59.47,180.22 59.32,180.37 59.32,181.06 60.84,182.58 v2(61.8,182.58) ; v2(186.29,165.59) 186.29,166 187.23,166.94 187.23,171.25 192.82,176.84 v2(192.82,186.7)
  IN4 w1.524: 20.2,48.67 20.2,57.74 21.04,58.58 21.04,63.25 21.67,63.89 21.67,70.21 24.33,72.87 24.33,74.85 24.35,74.88 24.33,74.9 31.47,82.04 32.23,82.04 32.65,82.46 32.65,94.14 35.34,96.83 35.34,99.35 43.54,107.55 43.54,115.7
  BOTTOM w0.254: R8034.1 53.57,174.73 53.83,174.98 R8007.1 R8006.1 54.72,174.23 54.97,173.97 v2(57.26,173.97) ; R8032.1 51.29,187.4 v2(51.29,187.86) ; v2(59.47,176.41) 59.01,176.87 57.97,176.87 R8008.1 ; v2(54.3,189.84) 54.26,189.79 SR8000.2
  BOTTOM w0.279: CON5602.26 94.25,183.59 94.42,183.42 94.42,182.43 v2(94.82,182.02)
  BOTTOM w0.305: U8001.29 70.22,144.44 C8068.2 ; U8002.29 75.74,178.66 C8069.2 75.39,179 v2(74.71,179) ; C8070.2 70.48,162.99 U8003.29 ; v2(206.49,22.6) 206.49,22.46 206.25,22.23 CON3104.13 ; v2(191.52,20.5) 191.52,20.2 191.75,19.97 192.34,19.97 192.5,19.8 CON3110.2 ; v2(192.15,20.5) 192.38,20.5 193,19.88 CON3110.1
  BOTTOM w0.381: R8905.1 245.17,80.6 v2(245.17,80.25) ; v2(65.26,176.77) 66.5,176.77 67.94,178.2 R80103.1 ; SR8017.1 R8091.1 71,184.03 v2(70.74,184.29)
  BOTTOM w0.432: v2(70.03,143.62) C8068.2 ; v2(67.16,144.79) 66.97,144.98 SR8005.1 ; v2(67.9,163.58) 67.9,163.38 68.49,162.8 C8070.2 ; v2(120.25,162.92) 120.12,162.8 v2(120.12,160.03) 120.12,158.76
  BOTTOM w0.457: SR8007.1 67.58,163.9 v2(67.9,163.58) ; SR8006.1 76.82,181.95 v2(76.94,181.82)
  BOTTOM w0.508: v2(192.82,186.7) 194.6,186.7 197.42,183.88 R9710.1 ; v2(255.81,82.73) 256.34,82.2 256.83,82.2 257.23,81.8 260.61,81.8 261.08,82.27 v4(261.51,82.27) ; v2(61.42,112.1) 61.42,112.53 60.74,113.22 D5000.3 ; v2(70.03,143.62) 67.67,143.62 67.16,144.13 v2(67.16,144.79) ; v2(120.1,158.73) 121.04,159.67 122.23,159.67 122.97,158.93 122.97,158.3 123.55,157.72 123.55,156.57 124.31,155.81 R8749.1 ; SR4502.1 99.29,183.77 v2(99.29,180.45)
  vias: v2(25.43,12.85) v2(72.37,10.65) v2(73.39,5.95) v2(74.15,5.95) v2(146.87,166.4) v2(160.69,166.43) v2(161.3,166.4) v2(173.77,166.4) v2(174.4,166.38) v2(185.63,165.64) v2(261.52,81.52) v2(262.36,83.55) v2(306.37,82.47) v2(307.02,82.46) v4(23.2,33.05) v4(23.2,32.19) v4(24.7,12.97) v4(42.91,117.58) v4(42.91,116.72) v4(70.85,8.62) v4(71.86,8.62) v4(261.51,83.13) v4(262.26,82.7) v4(262.26,81.62)
+5VS_AVDD: length 10.9
  TOP w0.203: C3606.1 10.6,33.33 10.54,33.28 U3600.26
  TOP w0.432: L3606.1 12.01,35.36 C3605.1 11.03,35.94 v2(11.03,34.65) 10.6,34.22 C3606.1
  BOTTOM w0.102: v2(11.03,34.65) 11.21,34.65 12.02,33.84 12.02,30.39 v1(12.53,29.88)
+5VS_FAN2:
  vias: v1(71.13,6.1) v2(68.81,4.68) v2(69.45,4.68)
+5VS_HDD:
  vias: v1(22.03,11.51) v2(21.16,10.75) v2(21.47,10.19) v2(21.77,10.75)
+5VS_HDD_2:
  vias: v1(17.41,12.63) v4(16.49,12.43) v4(16.49,11.54)
+5VS_HDMI: length 2.1
  TOP w0.508: D4800.3 309.89,88.95 v1(309.89,90.3)
  vias: v2(309.73,87.48) v2(310.11,86.98) v2(310.24,87.99) v2(312.27,93.45) v2(312.78,93.96)
+5VS_LED: length 21.8
  TOP w0.254: LR802.2 223.03,187.48 223.19,187.64 225.11,187.64 226.52,189.05 v2(226.52,189.31) LR804.1 v1(225.56,190.95) ; CON1.8 v2(238.45,191.96)
  IN1 w0.254: v2(238.45,191.96) 237.17,190.68 227.24,190.68 226.52,189.95 v2(226.52,189.31)
+5VS_LGF: length 7.3
  TOP w0.254: CON4500.37 104.25,189.27 v2(104.24,189.28)
  BOTTOM w0.508: SR4502.2 100.64,187.76 T4509.1 101.23,187.81 101.66,187.38 C4538.1 102.67,187.38 103.15,187.86 103.15,188.62 103.81,189.28 v2(104.24,189.28)
+5VSUS: length 507.5
  TOP w0.254: v2(295.51,65.34) 295.46,65.34 295.33,65.21 R5209.1
  TOP w0.432: v2(297.03,65.36) 296.74,65.06 R5207.1
  TOP w0.762: 2.81,14.21 2.27,13.66 2.27,8.74 4.99,6.02 51.18,6.02 52.25,7.09 52.25,9.82 53.01,10.58 54.15,10.58 55.1,9.63 66.15,9.63 68.18,7.6 72.62,7.6 73.8,8.78 73.8,11.89
  TOP w3.048: 73.97,16.29 72.24,16.29 62.83,25.7 62.83,34.41 57.05,40.19 51.82,40.19 51.26,40.75 41.71,40.75 36.96,45.5 36.96,76.18 35.57,77.58
  IN1 w0.508: v2(103.62,179.69) 100.24,183.07 97.69,183.07 96.3,184.46 91.12,184.46 90.75,184.83 v2(90.75,185.63) 90.75,185.64 90.12,186.27 81.29,186.27 80.12,187.43 v2(67.04,187.43)
  IN2 w0.508: v2(67.04,187.43) 66,188.47 48.75,188.47 45.67,185.39 45.67,156.66 49.31,153.01 51.95,153.01 52.79,152.18 52.79,147.07 54.11,145.75 54.11,136.81 v4(47.22,129.93)
  IN3 w1.27: 270.36,21.24 269.27,21.24 267.09,19.06 254.34,19.06 252.13,16.85 242.73,16.85 241.69,17.89
  IN3 w3.048: 235.92,22.97 241.92,22.97 248.22,29.27 255.95,29.27 257.34,30.65 260.62,30.65 262.61,28.66 270.64,28.66 273.59,25.71
  BOTTOM w0.279: CON5602.19 v2(90.75,185.63)
  BOTTOM w0.508: v4(47.22,129.93) 47.22,126.88 40.54,120.2 40.54,110.73 35.92,106.1 35.92,91.83 ; U4501.5 104.76,185.27 104.37,185.66 103.51,185.66 103.15,185.29 103.15,183.88 103.35,183.67 103.37,183.67 103.62,183.42 v2(103.62,179.69)
  BOTTOM w0.762: 2.81,14.21 2.27,13.66 2.27,8.74 4.99,6.02 48.18,6.02 48.75,6.59 48.75,9.76 49.89,10.9 53.83,10.9 55.1,9.63 70.47,9.63
  vias: v4(1.89,14.59) v4(2.77,15.86) v4(3.16,14.59) v4(34.02,79.74) v4(34.02,78.85) v4(34.02,77.96) v4(34.02,77.07) v4(72.62,12.81) v4(72.62,11.92) v4(73.51,12.81) v4(73.51,11.92) v4(74.4,12.81) v4(75.29,12.81) v4(281.62,58.19) v4(282.51,58.19) v4(283.37,58.19) v4(285.53,70.97) v4(285.53,70.09) v4(286.42,70.97) v4(286.42,70.09) v4(287.31,70.97) v4(287.31,70.09) v4(288.19,70.97) v4(288.19,70.09) v4(289.01,70.52) v4(304.83,67.07) v4(304.81,66.15) v4(305.29,68.18)
+5VSUS_CHARGING:
  vias: v1(305.85,60.69) v4(308.58,45.56) v4(309.48,45.56) v4(309.86,62.08) v4(309.86,61.2) v4(309.86,60.31) v4(310.43,45.56)
+5VSUS_PVDD: length 1.8
  BOTTOM w0.229: U3700.3 67.07,14.46 v4(67.29,14.23) 67.07,14.01 U3700.4
  vias: v1(66.66,10.78)
+5VSUS_TYPEC: length 40
  TOP w0.254: v5(295.49,59.72) 295.43,59.72 294.99,60.17 U1201.H10
  TOP w0.279: 295.97,75.52 295.61,75.17 295.21,75.17 294.99,74.95 U1202.1
  TOP w0.432: 295.97,75.52 C1201.2 v2(296.65,76.18) ; v2(291.65,76.84) R1205.1 ; 288.5,73.62 R1201.1
  TOP w0.508: v2(291.65,76.84) 291.45,77.05 290.76,77.05 288.5,74.78 288.5,73.62
  IN1 w0.508: v2(292.64,65.97) 292.64,65.36 291.98,64.7 291.14,64.7 288.4,61.96 v2(288.4,61.93) ; v2(292.16,71.66) 292.16,72.7 292.36,72.91 292.36,74.51 292.72,74.86 292.72,76.05 291.93,76.84 v2(291.65,76.84)
  IN3 w0.508: v2(291.65,76.84) 292.79,76.84 293.45,76.18 v2(296.65,76.18)
  BOTTOM w0.508: v2(292.73,61.3) 293.72,60.31 295.28,60.31 ; v2(288.4,61.93) 288.4,61.84 289.51,60.72 290.7,60.72 v2(291.18,61.21) ; v2(292.64,65.97) 292.64,71.18 v2(292.16,71.66)
  vias: v1(290.96,63.08)
+12V: length 2.8
  TOP w0.254: Q9103.4 180.96,21.91 R9108.1 181.59,22.16 v2(181.84,22.41)
  BOTTOM w0.254: T9110.1 181.54,22.41 v2(181.84,22.41)
+12VO: length 1.4
  BOTTOM w0.508: v2(253.68,76.23) 254.42,76.98 JP8107.1
+12VS: length 3.2
  TOP w0.254: Q9102.4 186.66,29.56 186.87,29.78 R9107.1 187.31,29.2 186.62,28.51 T9107.1
+12VSUS: length 335.8
  TOP w0.254: v2(183.09,27.58) 183.8,26.87 183.8,23.02 184.13,22.69 184.13,22.23 183.85,21.95 183.42,21.95 183.09,22.29 183.09,22.64 182.09,23.64 179.53,23.64 178.92,23.04 178.92,22.16 178.67,21.91 Q9103.3
  TOP w0.381: v2(239.68,27.26) 239.68,27.46 240.07,27.86 Q9104.3
  TOP w0.406: 132.9,70.85 132.38,71.37 Q9106.3 ; v2(183.09,27.58) 184.2,28.69 Q9102.3
  TOP w0.508: 132.9,70.85 133.2,70.54 133.2,53.35 134.21,52.34 134.21,45.36 131.48,42.63 T8127.1 130.26,36.43 130.26,31.25 v2(129.25,30.23) ; v2(192.98,54.4) 188.99,50.41 188.99,46.76 190.71,45.04 194.19,45.04 194.62,44.61 194.62,43.69 193.87,42.93 192.64,42.93 192.45,42.74 190.47,42.74 187.69,39.96 187.69,31.4 187.92,31.17 187.92,28.02 v2(187.4,27.5)
  IN2 w0.508: v2(129.25,30.23) 134.69,24.78 161.61,24.78 162.79,25.96 165.93,25.96 166.08,26.11 176.5,26.11 176.62,26.23 181.74,26.23 v2(183.09,27.58) 187.36,27.58 187.4,27.55 v2(187.4,27.5) 187.45,27.5 188.45,26.5 196.62,26.5 200.13,30.01 202.34,30.01 203.31,29.04 220.35,29.04 221.72,27.67 225.99,27.67 227.08,28.76 238.18,28.76 v2(239.68,27.26)
  IN3 w0.508: v2(255.5,80.53) 255.02,81.01 255.02,82.55 253.85,83.72 253.85,87.36 251.62,89.59 245.09,89.59 241.23,93.45 240.65,93.45 240.27,93.83 239.12,93.83 238.74,94.22 231.63,94.22 227.82,98.03 227.13,98.03 225.1,100.06 224.77,100.06 223.37,101.45 217.35,101.45 v2(215.58,99.68) ; v2(200.55,73.16) 200.55,72.3 197.18,68.93 197.18,66.26 193.08,62.17 193.08,54.5 v2(192.98,54.4)
  IN4 w0.508: v2(200.55,73.16) 200.55,73.24 201.18,73.87 205.16,73.87 205.59,74.3 209.23,74.3 210.62,75.7 210.62,76.47 211.83,77.68 214.08,77.68 215.7,79.31 215.7,94.72 214.97,95.46 214.97,99.07 v2(215.58,99.68)
  BOTTOM w0.508: JP8107.2 255.78,78.09 256.06,78.37 256.06,79.97 v2(255.5,80.53)
+AVDDH: length 18.6
  TOP w0.229: C3319.1 276.97,101.83 277.04,101.76 U3300.22 ; C3318.1 282.64,101.76 U3300.9
  TOP w0.432: C3318.1 C3317.1 285.19,103.26 v2(285.63,103.69)
  TOP w0.457: C3319.1 276.26,101.76 v2(275.34,101.76)
  IN2 w0.508: v2(285.63,103.69) 285.25,104.07 278.24,104.07 275.93,101.76 v2(275.34,101.76)
  BOTTOM w0.508: v2(285.63,103.69) 285.71,103.61 v1(285.71,102.98)
+AVDDL: length 32.1
  TOP w0.229: C3316.1 284.03,100.51 283.95,100.44 282.81,100.44 282.69,100.56 U3300.6 ; U3300.31 278.09,97.6 277.55,97.06 276.25,97.06 C3308.2 ; U3300.13 v2(280.89,103.41) ; U3300.19 278.49,103.36 v2(278.5,103.37)
  TOP w0.457: C3316.1 284.75,100.35 C3315.1 285.39,100.58 v2(285.76,100.95)
  TOP w0.508: v2(276.74,97.64) 276.38,97.64 C3308.2
  IN2 w0.508: v2(285.76,100.95) 285.15,100.95 284.53,100.33 284.53,98.22 282.99,96.68 277.71,96.68 v2(276.74,97.64)
  BOTTOM w0.432: C3320.1 281.58,104.14 281.83,103.89 281.83,102.87 282.61,102.09 284.61,102.09 v2(285.76,100.95) ; C3320.1 280.92,103.44 v2(280.89,103.41) ; C3320.1 279.97,104.14 279.86,104.25 C3321.1 278.67,103.64 278.5,103.47 v2(278.5,103.37)
  vias: v1(278.7,90.79) v2(277.22,92.56) v2(277.83,92.56)
+AVDDVCO: length 0.7
  TOP w0.229: U3300.34 279.29,97.45 v2(279.15,97.31)
  vias: v1(279.63,96.5)
+DVDDIO_AUDIO_W10MIL: length 14.9
  TOP w0.254: v2(236.76,63.55) 236.76,63.62 237.23,64.09 237.52,64.09 238.21,64.78 238.57,64.78 C2629.1 239.29,65.5 239.91,65.5 v2(240.77,66.36)
  IN1 w0.254: v2(246.23,72.12) 245.98,72.12 240.77,66.9 v2(240.77,66.36)
  BOTTOM w0.203: U2000.BA15 236.81,63.33 236.76,63.38 v2(236.76,63.55)
  BOTTOM w0.254: v1(246.86,72.74) v2(246.23,72.12)
+DVDDL: length 1
  TOP w0.203: 280.64,97.02 280.49,97.17 U3300.37
  vias: v1(283.04,91.7)
+V1P0A_VCCAMPHYPLL_W25MIL:
  vias: v1(212.02,47.84) v2(212.93,47.89) v2(213.59,47.89)
+V1P0A_VCCAPLL_W15MIL: length 16.7
  TOP w0.381: C2628.1 230.55,69.03 v1(229.7,69.88) ; C2628.1 231.28,69.03 C2619.1 231.94,68.77 231.65,68.49 v2(231.65,67.75) ; C2628.1 230.91,68.59 231.05,68.44 231.05,64.55 231.41,64.19 R2607.2 L2603.2 231.41,61.9 231.46,61.85 231.46,61.51 232.04,60.93 C2618.1 232.8,60.93 233.03,61.16 v2(233.03,61.37)
  BOTTOM w0.203: U2000.AL5 231.7,67.79 v2(231.65,67.75) 231.61,67.79 U2000.AJ5 ; v2(233.03,61.37) 233.03,61.03 U2000.AN19
+V1P0A_VCCF24_W15MIL: length 1.3
  BOTTOM w0.203: U2000.K3 221.86,69.13 221.77,69.23 U2000.K2 221.77,70.04 v2(221.68,70.12)
  vias: v1(220.62,74.96)
+VBUS1: length 15.5
  TOP w0.305: CON1201.B4 319.45,34.3 CON1201.A9
  TOP w0.432: R1247.2 297.54,70.49 v2(297.54,70.06)
  IN1 w0.508: v4(296.14,61.63) 295.41,62.36 295.41,63.48 294.54,64.35 294.54,68.18 295.33,68.97 296.45,68.97 v2(297.54,70.06)
  IN3 w0.432: 318.81,34.25 CON1201.B4 ; 319.5,31.16 CON1201.B9
  IN3 w0.457: CON1201.B9 318.92,31.85 ; CON1201.B4 319.5,34.83
  vias: v1(306.76,30.92) v2(290.35,59.82) v2(290.96,60) v2(299.26,61.94) v2(299.89,61.94) v4(300.46,61.45) v4(305.8,30.97) v4(305.8,30.08) v4(305.8,29.19) v4(310.88,28.81) v4(310.88,27.92) v4(311.77,28.3)
+VCC_RTC: length 96.9
  TOP w0.508: SR2605.2 249.51,68.94 249.84,68.61 v2(249.84,67.55)
  IN1 w0.508: v2(249.84,67.55) 250.25,67.55 251.06,66.73 v2(251.06,65.82)
  IN2 w0.508: v2(251.06,65.82) 252.13,65.82 253.19,64.75 256.98,64.75 258.53,66.3 265.4,66.3 265.56,66.45 266.2,66.45 269.81,70.06 272.17,70.06 272.85,69.37 v2(272.95,69.37)
  IN3 w0.508: v2(276.58,64.67) 278.28,64.67 281.26,67.65 281.26,69.34 282.05,70.13 282.05,73.31 284.79,76.06 284.79,78.44 285.48,79.13 287.79,79.13 292.08,83.42 292.08,86.09 293.48,87.48 296.91,87.48 298.94,89.52 299.57,89.52 299.8,89.74 299.8,90.41 300.3,90.91 301.36,90.91 301.73,90.55 301.73,87.26 v2(301.94,87.05)
  BOTTOM w0.254: v2(249.84,67.55) R2448.1
  BOTTOM w0.432: v2(276.58,64.67) 276.58,64.96 D2801.3 274.93,66.01 274.73,66.2 C2826.1 R2810.1 R2812.1 272.32,66.46 v1(272.32,67.37) ; R6006.1 304.37,78.29 303.64,78.29 302.55,79.38 302.55,83.75 301.1,85.2 301.1,86.21 v2(301.94,87.05)
  BOTTOM w0.508: v1(272.32,67.37) 272.95,68 v2(272.95,69.37)
+VCC_SYS_HV: length 13.5
  BOTTOM w0.102: v2(291.04,58.94) 290.61,58.5 289.21,58.5 287.89,59.82 285.98,59.82 285.49,60.31 281.24,60.31 T1206.1 280.57,59.82 279.99,60.41 T1205.1
+VCCDSW: length 65.3
  TOP w0.356: v2(250.3,48.75) 250.44,48.89 Q2602.4
  TOP w0.508: R2617.1 v2(229.12,73.34)
  IN1 w0.508: v2(250.45,54.54) 250.45,52.43 250.81,52.07 250.81,51.11 250.3,50.6 v2(250.3,48.75) 250.3,44.66 249.92,44.28 249.92,43.47 v2(250.65,42.73)
  IN3 w0.254: 229.24,69.25 228.58,68.59 227.99,68.59 227.54,68.14 227.54,64.15 v2(227,63.61) ; 229.24,69.25 236.54,69.25 237.36,68.43 237.36,67.89 237.26,67.8 237.26,67.11 237.98,66.4 237.98,59.6 236.35,57.98 v2(236.35,57.74) ; 229.24,69.25 228.65,69.84 228.65,72.42 229.12,72.89 v2(229.12,73.34)
  IN4 w0.508: v2(236.35,57.74) 236.35,57.95 236.74,58.33 237.55,58.33 238,57.88 238,56.73 239.66,55.07 240.58,55.07 240.85,54.8 247.85,54.8 248.46,54.19 250.1,54.19 v2(250.45,54.54)
  BOTTOM w0.203: v2(236.35,57.74) 236.91,58.29 U2000.BA24
  BOTTOM w0.254: v2(227,63.61) 227,63.34 U2000.W15
  vias: v1(250.02,42.35)
+VCCGT: length 48.3
  IN3 w0.508: v2(68.51,163.58) 68.51,163.15 69.12,162.54 69.12,155.11 68.74,154.73 60.73,154.73 v2(59.57,155.89) ; v2(72.57,182.61) 69.2,182.61 67.67,184.13 v2(67.67,184.29)
  IN4 w0.102: 79.3,120.46 79.68,120.46
  IN4 w0.508: v2(68.51,163.58) 69.38,164.45 69.38,168.4 68.1,169.67 68.1,172.33 67.04,173.39 67.04,177.25 72.4,182.61 v2(72.57,182.61)
  BOTTOM w0.381: R8019.1 v2(67.67,184.29)
  vias: v1(87.71,133.76) v2(62.72,136.76) v2(63.28,136.4) v2(81.49,132.9) v3(76.09,130.67) v3(79.01,130.67) v3(79.73,129.04) v3(79.73,128.39) v3(79.73,127.74) v3(79.73,125.78) v3(79.73,125.13) v3(80.52,129.04) v3(80.52,128.39) v3(80.52,127.74) v3(80.52,125.78) v3(80.52,125.13) v3(81.3,130.67) v3(81.72,112.54) v3(81.72,111.53) v3(82.09,129.04) v3(82.09,128.39) v3(82.09,127.74) v3(82.09,125.79) v3(82.09,125.14) v3(82.88,129.04) v3(82.88,128.39) v3(82.88,127.74) v3(82.88,125.79) v3(82.88,125.14) v3(83.55,111.52) v3(83.58,122.71) v3(83.58,121.95) v3(83.58,121.19) v3(83.58,120.43) v3(83.96,117.76) v3(83.96,117.13) v3(84.45,129.04) v3(84.45,128.39) v3(84.45,127.74) v3(84.45,125.79) v3(84.45,125.14) v3(84.47,115.09) v3(84.47,114.46) v3(84.47,113.82) v3(84.47,113.19) v3(84.47,112.53) v3(84.47,111.54) v3(84.85,123.48) v3(84.85,122.71) v3(84.85,121.95) v3(84.85,121.19) v3(84.85,120.43) v3(85.24,129.04) v3(85.24,128.39) v3(85.24,127.74) v3(85.24,125.79) v3(85.24,125.14) v3(85.36,115.09) v3(85.36,114.46) v3(85.36,113.82) v3(85.36,113.19) v3(85.36,111.54) v3(85.87,117.76) v3(85.87,117.13) v3(86,130.67) v3(86.03,129.04) v3(86.03,128.39) v3(86.82,129.04) v3(86.82,128.39) v3(86.82,127.74) v3(86.82,125.79) v3(86.82,125.14) v3(87.01,112.53) v3(87.6,129.04) v3(87.6,128.39) v3(87.6,127.74) v3(87.6,125.79) v3(87.6,125.14) v3(88.03,123.35) v3(88.03,122.71) v3(88.03,121.95) v3(88.03,121.19) v3(88.03,120.43) v3(88.1,112.53) v3(89.18,129.04) v3(89.18,128.39) v3(89.18,127.74) v3(89.18,125.79) v3(89.18,125.14) v3(89.43,117.76) v3(89.43,117.13) v3(89.55,123.35) v3(89.55,122.71) v3(89.55,121.95) v3(89.55,121.19) v3(89.55,120.43) v3(89.97,129.04) v3(89.97,128.39) v3(89.97,127.74) v3(89.97,125.79) v3(89.97,125.14) v3(90.06,115.09) v3(90.06,114.46) v3(90.06,113.82) v3(90.06,113.19) v3(90.06,112.55) v3(90.82,130.54) v3(90.75,129.04) v3(90.75,128.39) v3(90.86,111.52) v3(91.54,129.04) v3(91.54,128.39) v3(91.54,127.74) v3(91.54,125.79) v3(91.54,125.14) v3(91.78,111.52) v3(92.33,129.04) v3(92.33,128.39) v3(92.33,127.74) v3(92.33,125.79) v3(92.33,125.14) v3(92.6,123.35) v3(92.6,122.71) v3(92.6,121.95) v3(92.6,121.19) v3(92.6,120.41) v3(92.6,115.09) v3(92.6,114.46) v3(92.6,113.82) v3(92.6,113.19) v3(92.6,112.55) v3(92.68,111.52) v3(92.85,117.76) v3(92.85,117.13) v3(93.9,129.04) v3(93.9,128.39) v3(93.9,127.74) v4(57.38,147.43) v4(57.51,151.49) v4(57.51,150.6) v4(57.54,149.66) v4(57.49,146.26) v4(57.99,148.88) v4(58.27,147.43) v4(58.4,151.49) v4(58.4,150.6) v4(58.45,149.69) v4(59.16,147.43) v4(59.29,151.49) v4(59.29,150.6) v4(59.34,149.69) v4(60.05,147.43) v4(60.18,151.49) v4(60.18,150.6) v4(60.23,149.69) v4(61.08,150.59) v4(62.36,150.3) v4(62.87,135.64) v4(67.04,136.51) v4(67.04,135.62) v4(67.93,136.51) v4(67.93,135.62) v4(68.81,136.51) v4(68.81,135.62) v4(69.7,136.51) v4(69.7,135.62) v4(70.59,136.51) v4(70.59,135.62) v4(73.26,135.74) v4(73.26,134.86) v4(73.26,133.97) v4(74.15,135.74) v4(74.15,134.86) v4(74.15,133.97) v4(75.04,135.74) v4(75.04,134.86) v4(75.04,133.97) v4(75.93,135.74) v4(75.93,134.86) v4(75.93,133.97) v4(76.82,135.74) v4(76.82,134.86) v4(76.82,133.97) v4(77.7,135.74) v4(77.7,134.86) v4(77.7,133.97) v4(78.59,135.74) v4(78.59,134.86) v4(78.59,133.97) v4(79.48,135.74) v4(79.48,134.86) v4(79.48,133.97) v4(81.01,135.74) v4(81.01,134.86) v4(81.01,133.97) v4(81.9,135.74) v4(81.9,134.86) v4(81.9,133.97) v4(82.78,135.74) v4(82.78,134.86) v4(82.78,133.97) v4(83.67,135.74) v4(83.67,134.86) v4(83.67,133.97) v4(84.56,135.74) v4(84.56,134.86) v4(84.56,133.97) v4(85.45,135.74) v4(85.45,134.86) v4(85.45,133.97) v4(86.34,135.74) v4(86.34,134.86) v4(86.34,133.97)
+VCCIO: length 116.3
  TOP w0.254: R0300.1 115.41,128.86 116.29,128.86 v3(116.57,128.58) ; R0745.1 73.03,117.05 R0754.1 71.46,116.64 70.77,117.33 69.2,117.33 68.56,117.96 R0700.1 68.18,118.55 v2(67.42,119.31)
  TOP w0.432: C1022.1 C1021.1 109.49,116.92 v3(109.31,116.75) ; C1020.1 109.96,118.18 v3(109.34,117.56)
  IN1 w0.102: 111.9,114 113.1,114 ; 110.52,109.29 111,109.29 ; 111.24,113.22 113,113.22 ; 110.57,110.85 111.03,110.85 ; 111.19,118.73 112.95,118.73 ; 111.14,115.58 112.34,115.58 ; 111.92,114.8 112.34,114.8 ; 110.55,110.07 111,110.07 ; 111.87,107.7 113.01,107.7 ; 110.81,119.52 112.56,119.52 ; 113.01,108.49 111.77,108.49 ; 110.42,120.3 112.33,120.3 ; 110.5,108.49 110.95,108.49 ; 111.79,109.28 112.93,109.28 ; 111.84,110.85 112.4,110.85 ; 111.22,117.94 112.97,117.94 ; 112.38,106.92 113.01,106.92
  IN1 w0.254: v3(96.36,110.93) 96.79,110.93 97.86,112 109.1,112
  IN2 w0.102: 110.61,120.31 111.02,120.31 ; 111.24,120.31 112.32,120.31 ; 111.18,115.58 112.43,115.58 ; 111.26,118.73 112.95,118.73 ; 111.9,110.85 112.41,110.85 ; 111.27,119.52 112.36,119.52 ; 111.2,113.23 113.02,113.23 ; 110.65,110.85 110.98,110.85 ; 111.9,114.8 112.32,114.8 ; 111.24,117.93 112.97,117.93 ; 111.82,114 113.09,114 ; 112.54,109.29 112.99,109.29
  IN2 w0.305: v2(119.26,102.79) 119.4,102.94 119.57,103.1 120,103.53 120,105.1 118.41,106.69 115.94,106.69 115.38,107.25 115.38,109.43
  IN3 w0.102: 76.33,110.62 77.6,110.62 ; 77.7,110.45 77.7,110.01
  IN3 w0.127: 77.53,111.41 76.38,111.41 ; 76.97,108.26 77.65,108.26 ; 76.94,112.2 76.26,112.2 ; 76.89,109.84 76.33,109.84
  IN3 w0.508: 71.87,112.58 71.87,113.35 68.2,117.03 68.2,118 67.42,118.78 v2(67.42,119.31)
  IN4 w0.102: 111.24,117.93 113.06,117.93 ; 112.28,115.57 111.19,115.57 ; 112.29,120.3 110.6,120.3 ; 111.84,114 113.04,114 ; 112.99,113.21 111.18,113.21 ; 111.84,114.8 112.3,114.8 ; 111.24,118.73 113.06,118.73 ; 111.23,119.51 112.31,119.51
  IN4 w0.254: v2(60.14,129.32) 60.14,127.58 59.59,127.04 59.59,123.35 63.1,119.84 66.88,119.84 v2(67.42,119.31)
  BOTTOM w0.254: v2(60.14,129.32) 60.15,129.32 60.4,129.06 R4409.1 ; v2(67.42,119.31) 67.42,119.59 R0744.1 ; v3(96.36,110.93) 95.98,110.55 U0300.AG12
  BOTTOM w0.305: v2(119.26,102.79) 119.47,102.79 120.65,101.62 121.82,101.62 122.59,100.85 122.59,100.43 122.29,100.13 121.7,100.13 121.65,100.18 R0600.1
  vias: v2(119.97,122.53) v3(109.24,122.33) v3(109.24,121.7) v3(109.24,114.99) v3(109.31,114.39) v3(109.31,113.62) v3(110.79,117.55) v3(110.79,114.4) v3(110.79,113.61) v4(111.49,155.68) v4(111.49,154.79) v4(112.38,155.68) v4(112.38,154.79) v4(113.26,155.68) v4(113.26,154.79) v4(114.15,155.68) v4(114.15,154.79) v4(119.21,123.81) v4(119.92,123.27) v4(120.18,119.31) v4(120.79,119.93) v4(120.86,118.6) v4(121.42,119.31) v4(121.98,119.97) v4(122.03,118.6) v4(122.53,119.31) v4(123.03,118.6)
+VCCIO_PWRGD: length 174.6
  TOP w0.102: v2(164.12,43.03) 164.12,42.84 SR9209.1 ; T9209.1 105.11,164.98 v2(104.73,165.36)
  IN2 w0.102: v2(164.12,43.03) 163.4,43.75 155.44,43.75 151.62,47.57 151.62,50.08 147.77,53.93 145.68,53.93 144.94,54.68 144.94,55.4 144.45,55.89 v2(144.41,55.89)
  IN3 w0.102: v2(104.73,165.36) 107.02,163.07 107.02,158.51 111.55,153.98 116.71,153.98 118.69,152 121.08,152 121.75,151.33 122.81,151.33 123.07,151.06 123.07,149.54 122.75,149.22 121.91,149.22 120.72,148.03 117.55,148.03 114.81,145.3 114.81,136.34 116.21,134.94 116.21,134.68 116.78,134.11 118.52,134.11 119.8,132.82 119.8,130.62 119.36,130.18 119.36,127.07 120.05,126.37 121.08,126.37 123.9,123.55 123.9,111.75 124.54,111.1 124.54,75.06 127.19,72.41 127.19,70.26 129.47,67.98 129.47,67.14 140.73,55.89 v2(144.41,55.89)
  BOTTOM w0.102: v2(104.73,165.36) 104.6,165.48 104.6,166.29 104.36,166.53 U9400.12
+VCCPFUSE_W20MIL: length 14
  TOP w0.457: C2610.1 239.63,68.97 v2(239.52,69.08)
  IN1 w0.508: v2(239.52,69.08) 239.81,69.37 239.81,70.95 240.39,71.53 240.95,71.53 v2(241.64,72.22)
  IN2 w0.254: v2(239.52,69.08) 238.38,69.08 238.21,69.25 235.63,69.25 v2(233.85,67.47)
  BOTTOM w0.203: U2000.AN5 233.57,67.74 v2(233.85,67.47)
  BOTTOM w0.254: U2000.BD3 238.66,68.92 U2000.BE3 ; U2000.BE4 U2000.BE3 ; U2000.BE3 239.36,68.92 v2(239.52,69.08)
  vias: v1(242.35,72.7)
+VCCPGPPCD_W15MIL: length 10.4
  IN2 w0.508: v2(245.61,46.21) 244.28,46.21 243.01,44.94 241.23,44.94 v2(240.77,45.4)
  BOTTOM w0.381: v2(245.61,46.21) 245.75,46.07 v1(245.75,45.4)
  BOTTOM w0.457: 238.86,47.21 239.23,46.84 240.04,46.84 240.77,46.11 v2(240.77,45.4)
  BOTTOM w0.508: SR2601.1 v2(245.61,46.21)
+VCCPLL_OC: length 3.1
  TOP w0.102: 77.73,109.98 77.73,111.1 77.88,111.26 78.52,111.26
  BOTTOM w0.305: U0300.BH13 79.48,111.2 79.79,110.9 v3(79.89,110.9) ; U0300.G11 111.11,110.01 110.93,109.81 110.92,109.81 v3(110.79,109.67)
  vias: v1(78.11,108.08)
+VCCRTC_W8MIL: length 19.5
  TOP w0.203: v2(236.71,59.02) 237.5,59.02 C2624.1 238.2,58.5 240.43,58.5 C2625.1 241.02,58.98 241.46,59.42 v2(241.61,59.42)
  TOP w0.254: 247.5,67.8 v1(247.5,67.8) ; 247.5,67.8 247.5,68.18 247.6,68.27 SR2605.1 ; 247.5,67.8 v2(247.5,67.01)
  IN2 w0.254: v2(247.5,67.01) 247.5,67.03 247.1,67.44 246.7,67.44 245.38,66.12 245.38,65.37 241.53,61.52 241.53,59.49 v2(241.61,59.42)
  BOTTOM w0.178: v2(236.71,59.02) 236.71,59.2 U2000.BA22
+VCCSA: length 99.1
  TOP w0.432: R8075.2 v2(48.06,180.19)
  TOP w0.508: 101.2,153.14 v2(101.2,154.67)
  IN1 w0.508: v2(48.06,180.19) 48.06,179.43 50.79,176.7 57.5,176.7 58.4,175.8 61.82,175.8 62.28,175.34 65.49,175.34 69.75,179.61 76.43,179.61 76.5,179.53 78.06,179.53 79.48,180.96 v2(82.28,180.96)
  BOTTOM w0.508: v2(82.28,180.96) 82.7,180.96 83.27,181.53 83.27,181.6 83.67,182 89.97,182 91.47,180.5 95.05,180.5 95.64,181.08 98.09,181.08 98.68,180.49 98.68,179.96 98.25,179.53 97.64,179.53 96.83,178.72 96.83,177.32 97.33,176.83 97.33,175.38 89.9,167.95 89.9,159.06 92.13,156.83 100.08,156.83 100.67,156.24 100.67,155.2 v2(101.2,154.67)
  vias: v1(118.09,135.52) v2(110.22,143.29) v3(108.08,128.38) v3(108.08,127.74) v3(108.08,127.08) v3(108.08,126.43) v3(108.07,125.13) v3(108.87,128.39) v3(108.87,127.73) v3(108.87,126.43) v3(108.87,125.78) v3(108.87,125.14) v3(109.66,128.39) v3(109.65,127.73) v3(109.65,127.08) v3(109.65,126.43) v3(114.05,127.01) v3(114.51,127.34) v3(115.65,127.57) v3(115.65,127.01) v3(116.21,127.54) v3(116.29,128.09) v4(105.34,151.31) v4(105.34,150.43) v4(106.61,151.31) v4(106.61,150.43) v4(107.88,151.31) v4(107.88,150.43) v4(108.81,131.39) v4(109.15,138.83) v4(109.15,137.9) v4(109.15,151.31) v4(109.15,150.43) v4(109.16,140.75) v4(109.16,139.77) v4(109.55,131.93) v4(109.56,133.78) v4(109.56,132.86)
AGND: length 225.5
  TOP w0.203: v2(4.98,31.5) 5.12,31.37 U3600.38 ; C3606.2 11.28,33.71 11.28,33.26 10.94,32.92 U3600.25
  TOP w0.254: 57.87,11.39 52.79,11.39 51.64,10.24 51.64,7.78 50.49,6.64 50.46,6.64 50.45,6.63 12.66,6.63 11.26,8.03 11.26,11.26 v2(11.54,11.54) 11.54,11.75 12.09,12.3 12.51,12.3 13.11,11.7 v2(13.11,11.59) 13.27,11.44 13.27,8.54 13.65,8.16 49.86,8.16 50.12,8.41 50.12,11 52.05,12.94 56.5,12.94 ; C6704.2 12.99,43.29 v2(12.5,43.77)
  TOP w0.305: v2(12.5,43.77) 12.86,43.77 C6705.2
  TOP w0.432: v2(10.19,39.05) 10.57,38.67 R3600.2 10.57,38.07 C3601.2 ; C3607.2 14.23,29.27 v2(13.8,29.27) ; C3647.2 15.81,30.51 v2(15.6,30.72) ; C3606.2 12.43,32.93 v2(12.43,32.7)
  TOP w0.508: v2(3.79,32.75) C3613.2 ; v2(12.01,36.9) 11.43,37.48 C3605.2 ; v2(8.03,39.68) 8.67,39.05 C3600.2 ; C3612.2 v2(3.79,36.43)
  IN1 w0.254: 12.35,32.7 11.94,32.29 11.94,28.43 11.77,28.25 11.77,27.1 12.48,26.39 12.48,25.69 9.91,23.12 9.91,15.83 11.69,14.05 11.69,11.69 v2(11.54,11.54) 11.51,11.51 11.51,10.9 11.82,10.6 12.81,10.6 13.15,10.94 13.15,11.55 v2(13.11,11.59) 13.11,14.59 11.28,16.42 11.28,22.54 13.75,25 13.75,28.61 13.32,29.04 13.32,32.29 12.91,32.7 v2(12.43,32.7) 12.35,32.7 ; 10.22,42.35 13.06,42.35 13.52,42.81 14.41,42.81 14.71,42.5 v2(14.99,42.5) 15.27,42.78 15.27,43.42 v2(15.32,43.47) 15.27,43.52 15.27,43.98 14.98,44.28 13.01,44.28 v2(12.5,43.77) 12.3,43.57 9.68,43.57 8.16,42.04 8.16,39.81 v2(8.03,39.68) 8.16,39.55 8.16,37.93 9.15,36.94 9.15,35.82 8.74,35.41 8.57,35.41 8.24,35.08 8.24,33.92 8.49,33.66 8.94,33.66 9.25,33.97 9.25,34.14 10.37,35.26 10.37,37.62 9.56,38.44 9.56,41.69 10.22,42.35
  BOTTOM w0.254: v2(61.07,13.95) 60.51,14.51 R3712.1 60.23,14.71 58.4,14.71 58.15,14.46 58.15,14.21 ; v2(63.1,12.43) 63.1,11.54 62.87,11.31 61.8,11.31 61.7,11.41 60.05,11.41 59.96,11.5 57.42,11.5 56.98,11.95 56.98,12.4
  BOTTOM w0.305: v2(14.99,42.5) 14.69,42.2 CON6700.16 ; v2(14.84,45.42) 14.56,45.7 CON6700.23 12.93,45.7 12.73,45.5 11.21,45.5 v2(11.03,45.32)
  BOTTOM w0.381: R3711.1 58.73,12.73 v2(58.78,12.68)
  BOTTOM w0.508: v2(63.1,12.43) 63.53,12 C3709.2 64.41,12 v2(64.42,11.98)
  vias: v1(4.81,43.95) v2(2.65,39.22) v2(2.65,38.59) v2(2.65,37.32) v2(2.77,41) v2(4.81,44.81) v2(5.44,45.32) v2(5.44,44.69) v2(6.08,45.32) v2(6.08,44.69) v2(7.98,45.19) v2(57.77,13.19)
