# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
U3300  E2400-RIV1-RL  [VX_QFN_40P_16_S197_P_QUA_9V]  279.89 100.36 90 top
U3401  GST5009  [VX_TRANS_24P_39_595X394_BO]  299.93 149.04 270 top
U3600  ALC255-CGT  [VX_QFN_48P_16_S236_P_REA_9V]  8.74 29.57 0 top
U3700  ALC1001-VB-CGT  [VX_DFN_12P_18_S118_P_T01_7V]  65.13 14.23 270 bottom
U4501  TVLST2304AD0  [VX_SOT23_S6_FITI_H57]  104.76 186.04 0 bottom
U4502  G524B1T11U  [VX_SOT23_S5_2D4_H57]  110.98 186.42 270 bottom
U4601  PI3DPX1203ZHEX  [VX_QFN_42P_358X142_P_12V]  298.43 112.5 270 top
U4602  AP2171WG-7  [VX_SOT25_DI]  308.57 113.11 180 top
U4801  AP2331SA-7  [VX_SOT23_2D4_H47]  307.24 85.96 0 bottom
U5000  G781P8F  [VX_SOIC_8P_26_122X193_H48]  292.72 132.19 270 top
U5001  APL5606AKI-TRG  [VX_SOIC_8P_50_197X236_COLAY]  47.91 116.89 270 top
U5002  APL5606AKI-TRG  [VX_SOIC_8P_50_197X236_COLAY]  264.22 91.93 270 top
U5003  G709T1UF  [VX_SOT23_S5]  282.2 108.69 270 bottom
U5004  APL5606AKI-TRG  [VX_SOIC_8P_50_197X236_COLAY]  74.91 4.05 270 top
U5200  TPS2546RTER  [VX_QFN_16P_20_S118_PAD_RIC]  302.75 63.78 180 top
U5500  PUSB3F96  [VX_DFN_10P_20_98X39_NXP]  309.68 53.32 270 top
U5501  APL3518ABI-TRG  [VX_SOT23_S5_H57]  304.27 70.85 90 top
U5502  PUSB3F96  [VX_DFN_10P_20_98X39_NXP]  307.35 77.78 270 top
U5701  UM6K1NG1DTN  [VX_SC70_S6]  206.36 135.69 270 top
U5702  UM6K1NG1DTN  [VX_SC70_S6]  236.58 28.02 270 bottom
U5703  UM6K1NG1DTN  [VX_SC70_S6]  127.92 146.69 90 top
U5704  UM6K1NG1DTN  [VX_SC70_S6]  125.91 166.63 180 bottom
U5800  BMA250E  [VX_LGA_12P_20_79X79_BOSCH]  302.5 133.9 0 top
U6200  NPCT650AAAWX  [VX_SOIC_28P_26_386X252]  235.41 31.95 180 top
U6701  PUSB3F96  [VX_DFN_10P_20_98X39_NXP]  16.69 37.98 270 bottom
U6901  ANT_CLIP_PAD  [ANT_CLIP_1P_102X107_EMI]  302 138.7 270 bottom
U6902  ANT_CLIP_PAD  [ANT_CLIP_1P_102X107_EMI]  296 138.7 270 bottom
U7000  N17E-G3  [VX_BGA_2152P_28_1484X1484_N]  161.6 93.9 90 bottom
U7001  UM6K1NG1DTN  [VX_SC70_S6]  130.92 91.93 270 bottom
U7002  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  131.45 89.16 180 bottom
U7003  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  143.49 64.75 90 bottom
U7401  W25Q80EWSNIG  [VX_SOIC_8P_50_193X156T02X01]  132.92 64.45 0 bottom
U7402  UM6K1NG1DTN  [VX_SC70_S6]  148.32 60.05 0 bottom
U7403  UM6K1NG1DTN  [VX_SC70_S6]  138.2 56.27 180 bottom
U7404  UM6K1NG1DTN  [VX_SC70_S6]  146.13 64.39 180 bottom
U7405  UM6K1NG1DTN  [VX_SC70_S6]  152 69.45 0 bottom
U7406  UM6K1NG1DTN  [VX_SC70_S6]  148.16 67.01 180 top
U7407  UM6K1NG1DTN  [VX_SC70_S6]  141.84 70.21 0 top
U7408  UM6K1NG1DTN  [VX_SC70_S6]  149.29 69.43 0 bottom
U7409  UM6K1NG1DTN  [VX_SC70_S6]  149.59 50.91 0 bottom
U7410  UM6K1NG1DTN  [VX_SC70_S6]  146.54 50.91 180 bottom
U7411  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  142.98 48.78 270 bottom
U7412  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  145.65 59.54 90 bottom
U7413  UM6K1NG1DTN  [VX_SC70_S6]  144.76 56.5 270 bottom
U7414  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  145.01 62.72 180 top
U7415  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  144.76 65.64 90 top
U7416  SN74LVC1G08DCKR  [VX_SOT23_S5_SC70_RD4]  141.08 56.37 90 bottom
U7417  UM6K1NG1DTN  [VX_SC70_S6]  140.7 63.35 0 bottom
U7600  MT58K256M32JA  [VX_BGA_190P_26_555X398]  166.22 134.05 270 bottom
U7601  MT58K256M32JA  [VX_BGA_190P_26_555X398]  146.92 134.05 90 bottom
U7700  MT58K256M32JA  [VX_BGA_190P_26_555X398]  202.01 115.99 180 bottom
U7701  MT58K256M32JA  [VX_BGA_190P_26_555X398]  181.57 134.1 90 bottom
U7800  MT58K256M32JA  [VX_BGA_190P_26_555X398]  201.75 80.93 180 bottom
U7801  MT58K256M32JA  [VX_BGA_190P_26_555X398]  201.75 100.06 0 bottom
U7900  MT58K256M32JA  [VX_BGA_190P_26_555X398]  161.43 53.75 90 bottom
U7901  MT58K256M32JA  [VX_BGA_190P_26_555X398]  180.86 53.75 270 bottom
U8000  ISL95829AHRTZ  [VX_QFN_48P_16_S240_PD_5V]  56.37 183.54 270 bottom
U8001  SIC631CD-T1-GE3  [VX_MLP_28P_20_S197_S_H31_7V]  70.97 147.94 90 bottom
U8002  SIC631CD-T1-GE3  [VX_MLP_28P_20_S197_S_H31_7V]  79.23 177.91 0 bottom
U8003  SIC631CD-T1-GE3  [VX_MLP_28P_20_S197_S_H31_7V]  71.23 166.48 90 bottom
U8004  SIC631CD-T1-GE3  [VX_MLP_28P_20_S197_S_H31_7V]  63.99 169.07 180 top
U8005  ISL95808HRZ  [VX_DFN_8P_20_S79_P_I_H39_1V]  100.95 157.59 0 top
U8006  SIC631CD-T1-GE3  [VX_MLP_28P_20_S197_S_H31_7V]  53.24 168.13 90 top
U8100  TPS51225CRUKR  [VX_QFN_20P_16_S118_P_H31_2V]  260.54 59.67 270 top
U8200  NB685GQ-Z  [VX_QFN_16P_20_118X118_MPS]  223.75 14.59 90 top
U8300  RT8231BGQW  [VX_QFN_20P_16_S118_P_H31_4V]  27.71 49.51 270 top
U8400  G918T11U  [VX_SOT23_S5_2D4_H57]  222.15 27.21 180 top
U8601  NB671GQ-Z  [VX_QFN_16P_118X188_MPS]  122.41 60.43 0 top
U8700  NCP81274MNTXG  [VX_QFN_40P_16_S197_P_T01_5V]  125.96 158.74 180 top
U8702  NCP81151MNTBG  [VX_DFN_8P_20_79X79_PAD_ON]  183.5 164.57 90 top
U8703  NCP81151MNTBG  [VX_DFN_8P_20_79X79_PAD_ON]  144.05 165.34 90 top
U8704  NCP81151MNTBG  [VX_DFN_8P_20_79X79_PAD_ON]  158.48 165.34 90 top
U8705  NCP81151MNTBG  [VX_DFN_8P_20_79X79_PAD_ON]  171.43 165.34 90 top
U8800  BQ24780SRUYR  [VX_QFN_28P_16_S157_PAD_4V]  276.17 32.44 180 top
U8900  RT8816AGQW  [VX_QFN_20P_16_122X122_P_5V]  248.77 82.83 0 top
U9100  G5016KD1U  [VX_DFN_10P_16_118X79_PAD]  194.99 37.02 90 top
U9101  TPS22966DPUR  [VX_SON_14P_16_118X79_PAD]  240.77 18.65 90 top
U9102  G5016KD1U  [VX_DFN_10P_16_118X79_PAD]  259.65 81.19 0 top
U9200  Vcc=2~5.5  [VX_SC70_S5_TI]  169.27 39.37 180 top
U9201  Vcc=2~5.5  [VX_SC70_S5_TI]  181.13 39.76 180 top
U9400  NB685GQ-Z  [VX_QFN_16P_20_118X118_MPS]  103.61 168.26 90 bottom
U9500  NB671GQ-Z  [VX_QFN_16P_118X188_MPS]  90.53 5.82 270 top
U9600  NB671GQ-Z  [VX_QFN_16P_118X188_MPS]  118.47 148.19 0 bottom
U9700  RT8816AGQW  [VX_QFN_20P_16_122X122_P_5V]  200.01 187.81 90 top
U9702  INA3221AIRGVR  [VX_QFN_16P_26_S157_PAD_SIGE]  93.07 180.22 90 top
X1101  25MHZ  [A_XTAL_4P_130X102_PER]  301.73 29.73 180 top
X7200  27MHZ  [VX_XTAL_4P_126X98_HELE]  137.27 74.04 90 bottom
XDP4400  BtoB_CON_60P  [BTOB_60P_20_F_SAM]  55.47 139.2 270 bottom
Y2500  32.768KHZ  [VX_XTAL_4P_272X55]  249.41 69.88 0 bottom
Y2501  24MHZ  [VX_XTAL_4P_126X98_RAK]  208.39 68.23 270 bottom
Y3300  25MHZ  [VX_XTAL_4P_126X98_TXC_H35]  289.06 103.51 90 top

## Library data of the parts
C0501 C0502 C0600 C0601 C0602 C0603 C0604 C0605 C0606 C0607 C0608 C0609 C0610 C0611 C0612 C0613 C0614 C0615 C0616 C0617 C0618 C0619 C0620 C0621 C0622 C0623 C0624 C0625 C0626 C0627 C0628 C0629 C0630 C0631 C0701 C0702 C0703 C0900 C0901 C0902 C0903 C0904 C0905 C0906 C0907 C0908 C0909 C0910 C0911 C0912 C0913 C0914 C0915 C0916 C0917 C0918 C0919 C0920 C0921 C0922 C0923 C0924 C0925 C0926 C0927 C0928 C0929 C0930 C0931 C0932 C0933 C0934 C0935 C0936 C0937 C0938 C0939 C0940 C0941 C0942 C0943 C0944 C0945 C0946 C0947 C0948 C0949 C0950 C0951 C0952 C0953 C0954 C0955 C0956 C0957 C0958 C0959 C0960 C0961 C0962 C0963 C0964 C0965 C0966 C0967 C0968 C0969 C0970 C0971 C0972 C0973 C0974 C0975 C0976 C0977 C0978 C0979 C0980 C0981 C0982 C0983 C0984 C0985 C0986 C0987 C0988 C0989 C0990 C0991 C0992 C0993 C0994 C0995 C0996 C0997 C0998 C0999-C1002 C1004 C1005 C1008-C1010 C1015-C1022 C1101-C1107 C1109-C1111 C1129 C1130 C1132-C1135 C1137 C1138 C1140 C1143 C1147 C1151-C1153 C1155 C1158 C1159 C1164 C1167 C1168 C1173-C1180 C1182 C1184 C1187 C1188 C1191 C1201-C1204 C1206 C1209-C1212 C1219-C1221 C1229 C1302 C1303 C1305 C1308 C1310-C1313 C1315-C1324 C1403-C1414 C1501-C1517 C1600-C1610 C1612-C1620 C1700-C1710 C1712-C1715 C1717-C1719 C1801-C1869 C1872 C1880-C1883 C1886 C1888 C1893-C1899 C2000-C2003 C2012-C2021 C2200-C2204 C2300-C2311 C2400-C2406 C2500-C2503 C2600-C2630 C2826-C2828 C3000-C3005 C3009 C3011 C3015 C3019-C3025 C3100-C3105 C3300-C3325 C3400-C3404 C3600-C3624 C3626-C3631 C3633 C3639 C3640 C3642 C3645-C3649 C3700 C3701 C3705-C3709 C3711 C4400-C4404 C4515 C4516 C4519-C4522 C4526 C4529-C4536 C4538-C4542 C4545 C4546 C4601-C4608 C4612 C4613 C4618-C4641 C4801 C4806 C4809-C4811 C5000-C5009 C5106 C5107 C5116-C5120 C5125-C5128 C5131-C5139 C5147 C5150 C5151 C5154 C5155 C5158-C5162 C5167 C5168 C5173 C5175-C5185 C5200-C5202 C5300-C5303 C5306 C5307 C5342 C5347-C5349 C5501-C5503 C5505-C5511 C5600 C5801 C5802 C6001 C6200-C6206 C6700 C6704 C6705 C6707-C6712 C6715-C6717 C7000-C7026 C7029-C7044 C7049-C7055 C7100-C7107 C7201-C7206 C7209-C7217 C7219-C7223 C7225 C7226 C7230 C7231 C7234 C7235 C7301 C7302 C7400 C7409 C7410 C7501-C7523 C7531-C7599 C7601-C7666 C7701-C7766 C7801-C7866 C7901-C7966 C09100 C09101 C09102 C09103 C09104 C09105 C09106 C09107 C09108 C09109 C09110 C09111 C09112 C09113 C09114 C09115 C09116 C09117 C09118 C09119 C09120 C09121 C09122 C09123 C09124 C09125 C09126 C09127 C09128 C09129 C09130 C18100-C18112 C75100-C75121 C75124 C75125 C75127-C75159 IC220 IC221 LC800-LC803 = C
C1003 C1006 C4517 C4518 C8000-C8036 C8053-C8055 C8059 C8060 C8064-C8099 C80002 C80004-C80006 C80008-C80010 C80012 C80013 C80017 C80019 C80020 C80022-C80027 C80029 C80031 C80032 C80036 C80038-C80042 C80044 C80046 C80049 C80050 C80052 C80055-C80057 C80059 C80062 C80064 C80066 C80068-C80070 C80073-C80079 C80082 C80083 C80087 C80091 C80092 C80095 C80098 C80102-C80119 C80121-C80134 = C: room: COR
C1007 C1011 = C: room: NV_PLACEBYPAGE_PAGE8
C1012 C1013 = C: room: NV_PLACEBYPAGE_PAGE5
C1014 = C: room: NV_PLACEBYPAGE_PAGE6
C1023 = CAP: room: SYS
C1108 C1139 C1141 C1149 C1150 C1169 C1181 = C: room: NV_PLACEBYPAGE_PAGE3
C1131 C1136 C1145 C1154 C1161 C1165 C1166 C1171 C1192 C1208 C1217 C1218 C1222 C1226 C1227 = C: room: NV_PLACEBYPAGE_PAGE16
C1142 C1146 C1228 = C: room: NV_PLACEBYPAGE_PAGE21
C1144 C1160 C1163 C1170 = C: room: NV_PLACEBYPAGE_PAGE17
C1148 C1205 = C: room: NV_PLACEBYPAGE_PAGE20
C1156 C1183 = C: room: NV_PLACEBYPAGE_PAGE11
C1157 C1186 = C: room: NV_PLACEBYPAGE_PAGE19
C1172 C1185 C1207 = C: room: NV_PLACEBYPAGE_PAGE18
C1223 C1224 C7401-C7408 C8202 C8203 C8205-C8216 = C: room: 1.0VSUS
C1225 = C: room: NV_PLACEBYPAGE_PAGE22
C1301 C1304 C1309 = C: room: NV_PLACEBYPAGE_PAGE47
C1306 C1307 = C: room: NV_PLACEBYPAGE_PAGE12
C1314 = C: room: NV_PLACEBYPAGE_PAGE23
C1401 C1402 = C: room: NV_PLACEBYPAGE_PAGE52
C3702 C3703 C8800-C8804 C8806-C8827 C8839 = C: room: CHG
C5121-C5124 C5169-C5172 C6713 C6714 C9100 C9101 C9103 C9105-C9125 C9133-C9136 = C: room: LOAD_SW
C5803 = C: room: ACC
C6002-C6005 C8300-C8328 = C: room: DDR
C8100-C8123 C8132 = C: room: SYS
C8400-C8402 C8404 = C: room: 1.5VS
C8601-C8616 = C: room: 1V8_VGA
C8701-C8741 C8752-C8776 C8781-C8788 = C: room: +NVVDD
C8900-C8904 C8906-C8910 C8912 C8915 C8916 C8925-C8929 = C: room: +FBVDDQ
C9200 = C: room: CTL
C9400-C9403 C9405-C9412 C9414-C9416 = C: room: VCCIO
C9500-C9515 = C: room: 2.5V
C9600-C9614 = C: room: PEX_VDD
C9701-C9714 C9716-C9726 = C: room: NVVDDS
C75122 C75123 C75126 C75160 C75161 CE1225 CE1801-CE1804 CE5502 CE5503 CE6703 = CAP
CE8000 CE8001 CE8004 CE8007 = CAP_SHARE: room: COR
CE8017 CE8018 CE8020-CE8026 = CAP: room: COR
CE8100 CE8101 = cap: room: SYS
CE8301 = CAP_SHARE: room: DDR
CE8700-CE8711 = CAP_SHARE: room: +NVVDD
CE8716-CE8719 = cap: room: +NVVDD
CE8900-CE8903 = cap: room: +FBVDDQ
CE9701-CE9704 = CAP_SHARE: room: NVVDDS
CN1 CN3-CN7 = C_ARRAYs
CN2 = C_ARRAYs: room: NV_PLACEBYPAGE_PAGE22
CON1 = FPC_CON_8P_2HOLD_MOLEX
CON1201 = USB_24P_10HD_ACON
CON1600 CON1601 CON1700 CON1701 = DDR4_260P_4HD_FOX
CON2800 = BATT_HOLDER_2HOLD_SUYIN
CON3100 = FPC_CON_26P_2HOLD
CON3104 CON3110 = WTOB_CON_14P_2HOLD
CON3400 = LAN_8P_2HOLD
CON3600 CON3700 CON5000 CON5001 = ZIF_CON_4P_6905
CON4400 CON4402 = FPC_CON_12P_2HOLD_KEC
CON4500 = WTOB_CON_40P_6HOLD_STAR
CON4601 = DISP_CON_20P_4HOLD_MOLEX
CON4800 = HDMI_CON_19P_4HOLD_STD
CON5002 = ZH_CON_1X3P_2HOLD
CON5100 = BTOB_20P_6HOLD_FOX
CON5102 = NGFF_67P_4HOLD_ARG
CON5103 CON5104 = MINI_PCI_67P_4HOLD_LOT
CON5300 = MINI_PCI_67P_4HD_LOTES
CON5500 CON5501 = USB_CON_9P_4HOLD_SNG
CON5602 = FPC_CON_28P_2HOLD
CON6000 = WTOB_10P_2HOLD_HR
CON6001 = WTOB_10P_4H
CON6002 = TACT_SWITCH_4P_2HOLD
CON6003 = TP_SWITCH_4P_FOXCONN
CON6004 = WtoB_CON_2P_2HOLD
CON6700 = FPC_45P_2HOLD
CON6701 = ZIF_CON_5P_6702
D1201-D1208 = AZ2025_01H_AMAZING
D1209 D3101 D3102 D3400 D5501-D5506 D6002 D6003 D6701-D6703 = VPORT_0603
D1301 D5303 D5308 = DIODE
D2301 D2401 D2402 D3601 D4503 D5301 D5302 = SCHOTTKY_DIODE
D2801 D5000 D5002 D7401-D7403 D7405 D7406 = SCHOTTKY_BAT54C
D3600 = TVUFB0201AC0
D4502 D5004 D5601 = SCHOTTKY_DIODE_3ANODE
D4800 D5001 D5003 = Dual_Diode_3anode
D6005 D6006 = Dual_Diode_Convert_1anode: room: CRT
D7404 D8200 = DIODE: room: 1.0VSUS
D7407 = DIODE: room: NVVDD
D8102 D8103 = Dual_Diode_Convert_1anode: room: SYS
D8300 D8301 = DIODE: room: DDR
D8601 = DIODE: room: 1V8_VGA
D8701 = DIODE: room: +NVVDD
D8800 D8801 = SCHOTTKY_BAT54C: room: CHG
D8804 = DIODE: room: CHG
D8805 = SCHOTTKY_DIODE: room: CHG
D8900 = DIODE: room: +FBVDDQ
D9200 D9202 = SCHOTTKY_DIODE: room: CTL
D9201 = DIODE: room: CTL
D9400 = DIODE: room: VCCIO
D9500 = DIODE: room: 2.5V
D9600 = DIODE: room: PEX_VDD
D9700 = DIODE: room: NVVDDS
H11 H21 H31-H36 H51-H56 H70 H71 H804 H805 = HOLE_PTH
H60-H66 H68 H69 = SCREWHOLE_SMT
H800 H803 H6901-H6903 = HOLE_NPTH
IU202 IU203 U5501 = APL3518ABI_TRG
JP1001 JP1601 JP1701 JP2602 JP8301 JP8302 JP8305-JP8307 = 3MMO_S: room: DDR
JP1201 JP9500 = 3MMO_S: room: 2.5V
JP2601 JP8100-JP8102 JP8106-JP8112 = 3MMO_S: room: SYS
JP5601 JP9300-JP9303 = 3MMO_S: room: CTL
JP8050-JP8061 = SHORT_PIN_RECTANGLE: room: COR
JP8103-JP8105 = SHORT_PIN_RECTANGLE: room: SYS
JP8200 = SHORT_PIN_RECTANGLE: room: 1.0VSUS
JP8202 = 3MMO_S: room: 1.0VSUS
JP8300 JP8303 JP8304 = SHORT_PIN_RECTANGLE: room: DDR
JP8400 = 3MMO_S: room: 1.5VS
JP8601 JP8603 = SHORT_PIN_RECTANGLE: room: 1V8_VGA
JP8602 = 3MMO_S: room: 1V8_VGA
JP8701-JP8708 = SHORT_PIN_RECTANGLE: room: +NVVDD
JP8800 JP8803 = 3MMO_S: room: CHG
JP8801 JP8802 JP8804 JP8805 = SHORT_PIN_RECTANGLE: room: CHG
JP9000 = SHORT_PIN_RECTANGLE: room: CTL
JP9400 JP9402 = 3MMO_S: room: VCCIO
JP9401 = SHORT_PIN_RECTANGLE: room: VCCIO
JP9501 JP9502 = SHORT_PIN_RECTANGLE: room: 2.5V
JP9600 = 3MMO_S: room: PEX_VDD
JP9601 JP9602 = SHORT_PIN_RECTANGLE: room: PEX_VDD
JRST5001 R0900 R0901 R0902 R0903 R0904 R1000 R1002 R1003 R1006-R1008 R1011 R1012 R1164 R1301 R1304 R1401-R1406 R1408 R1409 R1411 R1501-R1507 R1511-R1517 R1519 R2333-R2335 R2378 R2464 R2601 R2607 R2608 R2611 R2616 R2617 R2619 R2801 R2802 R3025 R3029-R3031 R3038-R3040 R3170 R3307 R3404 R3629-R3631 R4525 R4601 R4602 R4604 R4606 R4611 R4623-R4627 R5000 R5003 R5007 R5008 R5021 R5300 R5308 R6005 R6009 R6737 R6738 R6740 R7216-R7218 R7227 R7228 R7230 = r
L1101 L1106 L3300 = INDUCTOR
L1201 L1202 L3400-L3403 L4500-L4505 L5301 L5500-L5505 = Common_Choke_12_43_WE
L2601-L2603 L3301 L3302 L3600 L3601 L3606 L3701-L3704 L5300 L5302 L6001-L6003 L6700 L6701 L7100 L7201 L7202 L7205 L7401-L7404 = BEAD
L4800-L4803 = COMMON_CHOKE_14_23_PAN
L8000-L8005 = INDUCTOR: room: COR
L8100 L8101 = INDUCTOR: room: SYS
L8200 = INDUCTOR: room: 1.0VSUS
L8300 = INDUCTOR: room: DDR
L8601 = INDUCTOR: room: 1V8_VGA
L8701-L8704 = INDUCTOR: room: +NVVDD
L8800 = INDUCTOR: room: CHG
L8900 L8901 = INDUCTOR: room: +FBVDDQ
L9400 = INDUCTOR: room: VCCIO
L9500 = INDUCTOR: room: 2.5V
L9600 = INDUCTOR: room: PEX_VDD
L9701 L9702 = INDUCTOR: room: NVVDDS
LLED800-LLED803 = LED
LQ800-LQ802 = 2N7002K
LQ803 Q3101 Q3102 Q3601 Q4601 Q5002 Q7206 U2301 U2302 U5701-U5704 U7001 U7402-U7410 U7413 U7417 = UM6K1NG1DTN
LR800-LR804 R0300 R0302 R0504 R0505 R0506 R0507 R0508 R0510 R0511 R0600 R0700 R0701 R0702 R0703 R0704 R0705 R0706 R0707 R0708 R0709 R0717 R0723 R0724 R0725 R0727 R0728 R0729 R0730 R0731 R0733 R0734 R0738 R0739 R0740 R0741 R0742 R0743 R0744 R0745 R0746 R0747 R0751 R0752 R0753 R0754 R0755 R0756 R1004 R1005 R1009 R1010 R1014-R1016 R1101-R1104 R1109 R1110 R1112-R1122 R1125 R1127 R1128 R1133 R1135-R1137 R1155 R1167 R1168 R1201 R1203 R1205-R1210 R1212-R1218 R1221 R1228 R1230 R1234 R1238 R1243-R1248 R1302 R1303 R1305-R1310 R1323-R1333 R1407 R1414-R1417 R1508-R1510 R1518 R1600-R1610 R1612-R1615 R1617-R1619 R1700 R1701 R1704-R1710 R1712-R1717 R1719 R2000 R2100 R2102-R2108 R2110-R2121 R2141 R2145 R2146 R2148 R2157 R2165 R2201-R2211 R2227 R2228 R2235 R2243-R2251 R2255-R2265 R2300-R2311 R2314-R2321 R2323-R2332 R2347-R2350 R2357 R2358 R2360 R2363-R2365 R2371 R2375 R2376 R2381 R2382 R2401 R2402 R2405-R2417 R2420-R2437 R2442 R2444 R2446-R2452 R2454 R2458-R2460 R2463 R2465 R2466 R2469 R2472-R2479 R2481-R2484 R2486 R2487 R2489-R2491 R2493-R2496 R2498 R2512 R2516 R2522-R2526 R2529 R2602 R2610 R2803 R2804 R2810-R2812 R3001 R3003-R3007 R3010-R3013 R3017 R3019 R3021-R3024 R3026-R3028 R3034-R3036 R3041-R3045 R3053 R3061-R3064 R3070-R3075 R3077 R3079-R3081 R3092 R3098 R3099 R3101-R3117 R3124 R3137 R3140-R3148 R3156-R3160 R3167-R3169 R3172 R3301 R3306 R3400-R3403 R3600 R3603 R3604 R3606-R3608 R3610 R3611 R3613 R3620-R3624 R3632 R3700 R3704 R3707 R3708 R3711-R3714 R4403-R4406 R4409-R4412 R4414-R4418 R4422-R4425 R4427 R4428 R4501 R4505 R4517 R4518 R4523 R4524 R4526 R4587 R4592 R4593 R4595-R4597 R4605 R4607-R4610 R4629 R4801 R4806 R4807 R5004-R5006 R5009-R5019 R5022 R5115 R5131 R5200 R5201 R5206-R5211 R5301 R5302 R5305-R5307 R5309-R5314 R5319 R5341 R5349 R5354-R5356 R5501 R5601-R5603 R5701-R5705 R5707 R5709 R5710 R5712-R5715 R5717-R5723 R5727-R5745 R5801-R5811 R6001 R6002 R6006-R6008 R6101-R6104 R6113-R6124 R7001 R7004-R7007 R7009 R7100-R7107 R7112-R7119 R7201 R7204 R7205 R7208 R7210-R7214 R7221 R7225 R7226 R7229 R7321 R7322 R7400-R7432 R7435-R7440 R7442-R7445 R7449-R7451 R7453-R7463 R7466-R7470 R7475 R7477 R7478 R7482-R7491 R7493-R7504 R7506 R7511-R7513 R7609-R7613 R7709-R7713 R7809-R7813 R7909-R7913 R30101-R30109 R74100-R74105 R74107-R74110 = R
Q0702 Q1201 Q1202 Q2301 Q2801 Q3602 Q5301-Q5304 Q5701-Q5715 Q6001 Q6701 Q7204 Q7205 Q7401 Q7402 Q7405 Q7407 = N_MOS_SOT23
Q2601 = P_MOS_SOT23
Q2602 = XP4401
Q3107 Q4501 Q9105 Q9107 = N_MOS_SOT23: room: LOAD_SW
Q5001 = NPN_SOT23
Q5300 Q7202 Q7203 Q7406 = P_MOS_AP2325
Q7600 Q7700 Q7800 Q7900 = NB_N_MOS_SOT23_ONSEMI
Q8001 Q8002 = SI7840DP: room: COR
Q8101-Q8104 = SI7840DP: room: SYS
Q8106 = UM6K1NG1DTN: room: SYS
Q8300 Q8301 = SI7840DP: room: DDR
Q8701-Q8716 = SI7840DP: room: +NVVDD
Q8800-Q8802 = AON6428L: room: CHG
Q8803 Q8804 = N_MOS_SO8_IR: room: CHG
Q8805 Q8806 Q8810 = N_MOS_SOT23: room: CHG
Q8807 = UM6K1NG1DTN: room: CHG
Q8901-Q8904 = SI7840DP: room: +FBVDDQ
Q9102-Q9104 Q9106 = NPN_PNP_SOT353: room: LOAD_SW
Q9200 = UM6K1NG1DTN: room: CTL
Q9701-Q9706 = SI7840DP: room: NVVDDS
R1013 = R: room: NV_PLACEBYPAGE_PAGE42
R1105-R1107 R1111 R1126 R1129 R1134 R1138 R1139 R1142 = R: room: NV_PLACEBYPAGE_PAGE4
R1108 = R: room: NV_PLACEBYPAGE_PAGE8
R1123 R1124 R1130 R1131 = R: room: NV_PLACEBYPAGE_PAGE14
R1132 = R: room: NV_PLACEBYPAGE_PAGE7
R1140 R1141 R1169 R1242 = R: room: NV_PLACEBYPAGE_PAGE9
R1143-R1146 R1231 = R: room: NV_PLACEBYPAGE_PAGE22
R1154 = R: room: NV_PLACEBYPAGE_PAGE17
R1159 = r: room: NV_PLACEBYPAGE_PAGE17
R1160 = r: room: NV_PLACEBYPAGE_PAGE11
R1161 R1166 = R: room: NV_PLACEBYPAGE_PAGE18
R1165 = R: room: NV_PLACEBYPAGE_PAGE19
R1170 R1172 R1233 R1239 = R: room: NV_PLACEBYPAGE_PAGE21
R1171 = R: room: NV_PLACEBYPAGE_PAGE10
R1222 R1227 R1229 R1232 R1235 R1236 R1240 R1241 = R: room: NV_PLACEBYPAGE_PAGE47
R1223 R1226 R1313 = R: room: NV_PLACEBYPAGE_PAGE23
R1224 R1225 = R: room: NV_PLACEBYPAGE_PAGE24
R1311 R1312 = R: room: NV_PLACEBYPAGE_PAGE27
R1319-R1322 = R: room: NV_PLACEBYPAGE_PAGE48
R2312 R2313 R2379 R2380 R8100-R8111 = R: room: SYS
R2497 = R: room: SB_
R3065 R3066 R6745 R6746 R9100 R9101 R9104-R9108 R9110-R9113 = R: room: LOAD_SW
R5001 R5002 = R: room: VGP
R5020 R8000 R8006-R8008 R8012 R8014 R8015 R8019-R8021 R8023-R8025 R8027-R8038 R8040 R8041 R8043-R8047 R8049-R8067 R8070-R8073 R8075 R8079-R8081 R8083 R8085 R8087 R8089 R8091-R8094 R8096 R8098 R8099 R80100-R80103 R80112 R80125 R80130 R80135 R80140 R80145 R80147-R80150 = R: room: COR
R7448 R8200-R8203 R8205-R8208 = R: room: 1.0VSUS
R7505 R8800-R8817 R8834 R8835 R8837 R8838 = R: room: CHG
R8026 R8039 R8082 R8084 R8088 = THERMISTOR: room: COR
R8300-R8308 = R: room: DDR
R8401-R8403 = R: room: 1.5VS
R8601-R8607 = R: room: 1V8_VGA
R8700 R8703-R8724 R8727-R8734 R8737 R8738 R8740-R8757 R8762-R8767 = R: room: +NVVDD
R8701 R8702 = r: room: +NVVDD
R8739 = THERMISTOR: room: +NVVDD
R8900-R8905 R8907 R8909-R8912 R8917 = R: room: +FBVDDQ
R9200 R9202-R9208 R9214-R9216 = R: room: CTL
R9400 R9401 R9403-R9408 = R: room: VCCIO
R9500-R9506 = R: room: 2.5V
R9600-R9606 = R: room: PEX_VDD
R9700 R9701 R9703-R9707 R9709 R9710 R9712-R9714 R9716-R9725 R9727-R9729 R9731 R9733 R9734 R9736 = R: room: NVVDDS
R9702 R9715 R9732 = R_4P: room: NVVDDS
RN1201 RN1202 RN3400-RN3403 RN4500-RN4505 RN4800-RN4803 RN5301 RN5500-RN5505 = 2R4PS
SP2601 SR8100-SR8104 = SHORT_PIN_SR: room: SYS
SR0701 SR0702 SR0703 SR1101-SR1105 SR1204 SR1205 SR2101 SR2201-SR2215 SR2301-SR2305 SR2401-SR2410 SR2501-SR2520 SR3002-SR3012 SR3015-SR3026 SR3102 SR3103 SR3105 SR3106 SR3108 SR3301-SR3304 SR3603 SR3701-SR3703 SR4403-SR4410 SR4505 SR4506 SR5001 SR5101-SR5105 SR5108 SR5201-SR5203 SR5301 SR5302 SR5701-SR5707 SR7001 SR7207 SR7208 SR7401-SR7416 SR7418 = SHORT_PIN_SR
SR1001 SR1002 SR1201-SR1203 SR1206 SR1301 SR1501 SR1601 SR1602 SR1701 SR1702 SR2001 SR2601-SR2607 SR2701 SR2702 SR3001 SR3013 SR3014 SR3101 SR3104 SR3107 SR3109 SR3110 SR3305 SR3601 SR3602 SR3604-SR3607 SR4401 SR4402 SR4501-SR4504 SR4507 SR4601 SR5106 SR5107 SR5109 SR6001 SR6002 SR6201 SR6202 SR6701-SR6703 SR7002 SR7101 SR7102 SR7201-SR7206 SR7209-SR7211 SR7417 SR7501-SR7504 = SHORT_PIN_SR_S
SR8000 SR8001 = SHORT_PIN_SR: room: COR
SR8002-SR8019 = SHORT_PIN_L: room: COR
SR8200 = SHORT_PIN_SR: room: 1.0VSUS
SR8201 = SHORT_PIN_L: room: 1.0VSUS
SR8300 SR8301 = SHORT_PIN_SR: room: DDR
SR8302 SR8303 = SHORT_PIN_L: room: DDR
SR8400 = SHORT_PIN_SR: room: 1.5VS
SR8701-SR8704 SR8706 = SHORT_PIN_SR: room: +NVVDD
SR8707 SR8708 = SHORT_PIN_L: room: +NVVDD
SR8801 SR8802 SR8804 SR8805 SR8807 SR8809-SR8814 = SHORT_PIN_L: room: CHG
SR8803 SR8806 = SHORT_PIN_SR: room: CHG
SR8900-SR8904 SR8906 SR8908-SR8911 = SHORT_PIN_SR: room: +FBVDDQ
SR8912-SR8914 = SHORT_PIN_L: room: +FBVDDQ
SR9101 SR9103-SR9105 = SHORT_PIN_SR: room: LOAD_SW
SR9204 SR9206 = SHORT_PIN_SR: room: CTL
SR9207-SR9210 = SHORT_PIN_L: room: CTL
SR9400 = SHORT_PIN_SR: room: VCCIO
SR9401 = SHORT_PIN_L: room: VCCIO
SR9500 = SHORT_PIN_L: room: 2.5V
SR9700 SR9703 SR9705-SR9709 = SHORT_PIN_SR: room: NVVDDS
SR9710-SR9713 = SHORT_PIN_L: room: NVVDDS
T0301 T0700 T0701 T0702 T0703 T0704 T0706 T0707 T0708 T0709 T0710 T0714 T0717 T0719 T0722 T0724 T0729 T0730 T0732 T0734 T0745 T1000-T1003 T1105-T1112 T1205-T1210 T1600-T1603 T1700-T1703 T2201-T2205 T2400-T2411 T2500-T2503 T4401 T5102 T5104 T5201 T5301-T5310 T5801 T5802 T9713 = test_point
T1101-T1104 T3300-T3303 T3602 T5103 T5105 T7501 T8050-T8055 = test_point: room: COR
T4504-T4510 T8900-T8902 T8904-T8908 = test_point: room: +FBVDDQ
T6001 T6002 T8100-T8127 T8400 = test_point: room: SYS
T7401 T7402 T7406-T7410 T8300-T8313 = test_point: room: DDR
T8200-T8205 = test_point: room: 1.0VSUS
T8601-T8613 = test_point: room: 1V8_VGA
T8700 T8702 = test_point: room: +NVVDD
T8715 T9700-T9709 T9712 = test_point: room: NVVDDS
T8800-T8811 T8813 T9607 = test_point: room: CHG
T9100 T9102 T9104-T9108 T9110 T9111 T9113-T9116 = test_point: room: LOAD_SW
T9200 T9202-T9213 T9300-T9303 = test_point: room: CTL
T9400-T9404 = test_point: room: VCCIO
T9500-T9505 = test_point: room: 2.5V
T9600-T9603 = test_point: room: PEX_VDD
U0300 = CL8066202194730
U0701 U0702 = SN74LVC1G07DCKR
U0703 U2401-U2403 = NC7SZ08M5
U1101 = DSL6340_INTE
U1102 U1104 U1105 = SN74LVC1G17DRLR
U1103 U7401 = W25Q64BVSSIG
U1201 = TPS65982ABZQZR
U1202 = TPS2544RTER_2VIA
U1207 U1208 U5500 U5502 U6701 = IP4292CZ10_TBR
U1301 = SN65DP159RSBR_9V
U1302 = M5938CTB1U
U1401 = PS8330BQFN48GTR
U1501 = PS8527BTQFN20GTR2_A1_2V
U2000 = SKYLAKE_837P_INTEL
U2404 = SN74LVC1G32: room: SB_
U3002 = IT8987E_AX
U3101 = W25Q32FVSSIG
U3102 = TLC59116IPWR
U3103 = G5244T11U
U3300 = AR8161_BL3A_RL_9V
U3401 = NS692406
U3600 = ALC255_CG_9V
U3700 = ALC1001_VB_CGT_7V
U4501 = AZ1015_04SR7F
U4502 = G524D1T11U
U4601 = PI3DPX1203ZHEX_12VIA
U4602 = AP2151WG
U4801 = AP2331W
U5000 = G781_1
U5001 U5002 U5004 = APL5606AKI_TRG
U5003 = G709T1UF
U5200 = TPS2543RTER_TI
U5800 = BMA222
U6200 = NPCT650AAAWX
U6901 U6902 = Ant_pad_rd9
U7000 = N17E_G1
U7002 U7003 U7411 U7412 U7414-U7416 = SN74LVC1G32
U7600 U7601 U7700 U7701 U7800 U7801 U7900 U7901 = MT58K256M32JA_100_A
U8000 = ISL95829HRTZ_T_5VIA: room: COR
U8001-U8004 U8006 = SIC631CD_T1_GE3_7V: room: COR
U8005 = ISL6208BCRZ_1VIA: room: COR
U8100 = TPS51225RUKR_2V: room: SYS
U8200 = NB685GQ_Z: room: 1.0VSUS
U8300 = RT8231AGQW_4VIA: room: DDR
U8400 = G916T1UF: room: 1.5VS
U8601 = NB671GQ_Z: room: 1V8_VGA
U8700 = NCP81274MNTXG_5VIA: room: +NVVDD
U8702-U8705 = NCP5901MNTBG: room: +NVVDD
U8800 = BQ24780RUYR_4VIA: room: CHG
U8900 = RT8816AGQW_5VIA: room: +FBVDDQ
U9100 U9102 = G5016KD1U: room: LOAD_SW
U9101 = TPS22966DPU: room: LOAD_SW
U9200 U9201 = NC7SZ08M5: room: CTL
U9400 = NB685GQ_Z: room: VCCIO
U9500 = NB671GQ_Z: room: 2.5V
U9600 = NB671GQ_Z: room: PEX_VDD
U9700 = RT8816AGQW_5VIA: room: NVVDDS
U9702 = HPA01113AIRGVR: room: NVVDDS
X1101 X7200 Y2501 Y3300 = CRYSTAL_SMD_24GND
XDP4400 = AXK6F60335
Y2500 = CRYSTAL_SMD_23GND

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1MM_OPEN_5MIL_M1M2
  custom 0.254x0.254 smd: 1(0.036,-0.472) 2(0.043,0.533)
2MM_OPEN_5MIL_M1M2
  custom 0.508x0.508 smd: 1(0,-0.699) 2(0,0.699)
3MM_OPEN_5MIL_M1M2
  custom 0.572x0.572 smd: 1(0,0.5) 2(0,-1.8)
A_XTAL_4P_130X102_PER
  rect 1.499x1.194 smd: 1(-1.06,-0.8) 2(1.06,-0.8) 3(1.06,0.8) 4(-1.06,0.8)
ANT_CLIP_1P_102X107_EMI
  custom 0.358x0.358 smd: 1(0,0)
BTOB_60P_20_F_SAM
  round 1.016 hole 1.016 unplated: (-10.06,0) (10.066,0)
  rect 0.279x2.286 smd: 1(-7.25,-5.53) 2(-7.25,0.198) 3(-6.75,-5.53) 4(-6.75,0.198) 5(-6.25,-5.53) 6(-6.25,0.198) 7(-5.75,-5.53) 8(-5.75,0.198) 9(-5.25,-5.53) 10(-5.25,0.198) 11(-4.75,-5.53) 12(-4.75,0.198) 13(-4.25,-5.53) 14(-4.25,0.198) 15(-3.75,-5.53) 16(-3.75,0.198) 17(-3.25,-5.53) 18(-3.25,0.198) 19(-2.75,-5.53) 20(-2.75,0.198) 21(-2.25,-5.53) 22(-2.25,0.198) 23(-1.75,-5.53) 24(-1.75,0.198) 25(-1.25,-5.53) 26(-1.25,0.198) 27(-0.75,-5.53) 28(-0.75,0.198) 29(-0.25,-5.53) 30(-0.25,0.198) 31(0.25,-5.53) 32(0.25,0.198) 33(0.75,-5.53) 34(0.75,0.198) 35(1.25,-5.53) 36(1.25,0.198) 37(1.75,-5.53) 38(1.75,0.198) 39(2.25,-5.53) 40(2.25,0.198) 41(2.75,-5.53) 42(2.75,0.198) 43(3.25,-5.53) 44(3.25,0.198) 45(3.75,-5.53) 46(3.75,0.198) 47(4.25,-5.53) 48(4.25,0.198) 49(4.75,-5.53) 50(4.75,0.198) 51(5.25,-5.53) 52(5.25,0.198) 53(5.75,-5.53) 54(5.75,0.198) 55(6.25,-5.53) 56(6.25,0.198) 57(6.75,-5.53) 58(6.75,0.198) 59(7.25,-5.53) 60(7.25,0.198)
HOLE_C102D102N
  round 2.591 hole 2.591 unplated: (0,0)
HOLE_O122X102DO122X102N
  oval 3.099x2.591 hole 3.099x2.591 unplated: (0,0)
HOLE_O134X102DO134X102N
  oval 3.404x2.591 hole 3.404x2.591 unplated: (0,0)
NB_H_RT335X315B315D118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_H_RT335X350CBD118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_H_RTD118_P2_S
  round 3.505 hole 2.997: 1(0,0)
NB_NUT_C256D146_H134_LF2
  round 6.502 hole 3.708: 1(0,0)
NB_NUT_CT256B256D130_LF2
  round 6.502 hole 3.302: 1(0,0)
NB_NUT_CT256B256D146_LF2
  round 6.502 hole 3.708: 1(0,0)
NB_NUT_CTB256D146_H91_LF2
  round 6.502 hole 3.708: 1(0,0)
NB_OPEN2_5MIL_PT
  custom 0.181x0.181 smd: 1(0,-0.508) 2(0,0.508)
NB_PWR_FB_SHORT_PT
  rect 0.229x0.635 smd: 1(-0.203,0) 2(0.203,0)
NB_R0402_SHORT_5MIL_SMALL
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
NB_R0402_SHORT_20MIL_SMALL
  rect 0.457x0.508 smd: 1(-0.419,0) 2(0.419,0)
NB_R0603_SHORT_32MIL_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_TPC26T_68
  round 0.66 smd: 1(0,0)
NB_TPC28T_68
  round 0.711 smd: 1(0,0)
unnamed#2
  round 4.064 hole 4.064 unplated: (0,0)
unnamed#3
  round 1.016 smd: 1(0,0)
VX_2R4P1234_CHOKE_4P_COLAY
  rect 0.508x0.559 smd: 1(-0.4,-0.775) 2(-0.4,0.775) 3(0.4,-0.775) 4(0.4,0.775)
VX_2R4P_CHOKE1243_4P_CO_H40
  rect 0.508x0.559 smd: 1(-0.4,0.775) 2(-0.4,-0.775) 3(0.4,-0.775) 4(0.4,0.775)
VX_BATHOLDER_2P_2HOLD
  round 1.016 hole 1.016 unplated: (0,-8)
  round 1.245 hole 1.245 unplated: (0,8)
  rect 2.007x3.988 smd: 1(14.5,0) 2(-15.8,0)
VX_BGA_96P_20_236X236_TI
  round 0.254 smd: A1(-2.5,-2.5) A2(-2.5,-2) A3(-2.5,-1.5) A4(-2.5,-1) A5(-2.5,-0.5) A6(-2.5,0) A7(-2.5,0.5) A8(-2.5,1) A9(-2.5,1.5) A10(-2.5,2) A11(-2.5,2.5) B1(-2,-2.5) B2(-2,-2) B3(-2,-1.5) B4(-2,-1) B5(-2,-0.5) B6(-2,0) B7(-2,0.5) B8(-2,1) B9(-2,1.5) B10(-2,2) B11(-2,2.5) C1(-1.5,-2.5) C2(-1.5,-2) C10(-1.5,2) C11(-1.5,2.5) D1(-1,-2.5) D2(-1,-2) D5(-1,-0.5) D6(-1,0) D7(-1,0.5) D8(-1,1) D10(-1,2) D11(-1,2.5) E1(-0.5,-2.5) E2(-0.5,-2) E4(-0.5,-1) E5(-0.5,-0.5) E6(-0.5,0) E7(-0.5,0.5) E8(-0.5,1) E10(-0.5,2) E11(-0.5,2.5) F1(0,-2.5) F2(0,-2) F4(0,-1) F5(0,-0.5) F6(0,0) F7(0,0.5) F8(0,1) F10(0,2) F11(0,2.5) G1(0.5,-2.5) G2(0.5,-2) G4(0.5,-1) G5(0.5,-0.5) G6(0.5,0) G7(0.5,0.5) G8(0.5,1) G10(0.5,2) G11(0.5,2.5) H1(1,-2.5) H2(1,-2) H4(1,-1) H5(1,-0.5) H6(1,0) H7(1,0.5) H8(1,1) H10(1,2) H11(1,2.5) J1(1.5,-2.5) J2(1.5,-2) J10(1.5,2) J11(1.5,2.5) K1(2,-2.5) K2(2,-2) K3(2,-1.5) K4(2,-1) K5(2,-0.5) K6(2,0) K7(2,0.5) K8(2,1) K9(2,1.5) K10(2,2) K11(2,2.5) L1(2.5,-2.5) L2(2.5,-2) L3(2.5,-1.5) L4(2.5,-1) L5(2.5,-0.5) L6(2.5,0) L7(2.5,0.5) L8(2.5,1) L9(2.5,1.5) L10(2.5,2) L11(2.5,2.5)
VX_BGA_190P_26_555X398
  round 0.305 smd: A1(-5.85,-4.225) A2(-5.85,-3.575) A3(-5.85,-2.925) A4(-5.85,-2.275) A5(-5.85,-1.625) A10(-5.85,1.625) A11(-5.85,2.275) A12(-5.85,2.925) A13(-5.85,3.575) A14(-5.85,4.225) B1(-5.2,-4.225) B2(-5.2,-3.575) B3(-5.2,-2.925) B4(-5.2,-2.275) B5(-5.2,-1.625) B10(-5.2,1.625) B11(-5.2,2.275) B12(-5.2,2.925) B13(-5.2,3.575) B14(-5.2,4.225) C1(-4.55,-4.225) C2(-4.55,-3.575) C3(-4.55,-2.925) C4(-4.55,-2.275) C5(-4.55,-1.625) C10(-4.55,1.625) C11(-4.55,2.275) C12(-4.55,2.925) C13(-4.55,3.575) C14(-4.55,4.225) D1(-3.9,-4.225) D2(-3.9,-3.575) D3(-3.9,-2.925) D4(-3.9,-2.275) D5(-3.9,-1.625) D10(-3.9,1.625) D11(-3.9,2.275) D12(-3.9,2.925) D13(-3.9,3.575) D14(-3.9,4.225) E1(-3.25,-4.225) E2(-3.25,-3.575) E3(-3.25,-2.925) E4(-3.25,-2.275) E5(-3.25,-1.625) E10(-3.25,1.625) E11(-3.25,2.275) E12(-3.25,2.925) E13(-3.25,3.575) E14(-3.25,4.225) F1(-2.6,-4.225) F2(-2.6,-3.575) F3(-2.6,-2.925) F4(-2.6,-2.275) F5(-2.6,-1.625) F10(-2.6,1.625) F11(-2.6,2.275) F12(-2.6,2.925) F13(-2.6,3.575) F14(-2.6,4.225) G1(-1.95,-4.225) G2(-1.95,-3.575) G3(-1.95,-2.925) G4(-1.95,-2.275) G5(-1.95,-1.625) G10(-1.95,1.625) G11(-1.95,2.275) G12(-1.95,2.925) G13(-1.95,3.575) G14(-1.95,4.225) H1(-1.3,-4.225) H2(-1.3,-3.575) H3(-1.3,-2.925) H4(-1.3,-2.275) H5(-1.3,-1.625) H10(-1.3,1.625) H11(-1.3,2.275) H12(-1.3,2.925) H13(-1.3,3.575) H14(-1.3,4.225) J1(-0.65,-4.225) J2(-0.65,-3.575) J3(-0.65,-2.925) J4(-0.65,-2.275) J5(-0.65,-1.625) J10(-0.65,1.625) J11(-0.65,2.275) J12(-0.65,2.925) J13(-0.65,3.575) J14(-0.65,4.225) K1(0,-4.225) K2(0,-3.575) K3(0,-2.925) K4(0,-2.275) K5(0,-1.625) K10(0,1.625) K11(0,2.275) K12(0,2.925) K13(0,3.575) K14(0,4.225) L1(0.65,-4.225) L2(0.65,-3.575) L3(0.65,-2.925) L4(0.65,-2.275) L5(0.65,-1.625) L10(0.65,1.625) L11(0.65,2.275) L12(0.65,2.925) L13(0.65,3.575) L14(0.65,4.225) M1(1.3,-4.225) M2(1.3,-3.575) M3(1.3,-2.925) M4(1.3,-2.275) M5(1.3,-1.625) M10(1.3,1.625) M11(1.3,2.275) M12(1.3,2.925) M13(1.3,3.575) M14(1.3,4.225) N1(1.95,-4.225) N2(1.95,-3.575) N3(1.95,-2.925) N4(1.95,-2.275) N5(1.95,-1.625) N10(1.95,1.625) N11(1.95,2.275) N12(1.95,2.925) N13(1.95,3.575) N14(1.95,4.225) P1(2.6,-4.225) P2(2.6,-3.575) P3(2.6,-2.925) P4(2.6,-2.275) P5(2.6,-1.625) P10(2.6,1.625) P11(2.6,2.275) P12(2.6,2.925) P13(2.6,3.575) P14(2.6,4.225) R1(3.25,-4.225) R2(3.25,-3.575) R3(3.25,-2.925) R4(3.25,-2.275) R5(3.25,-1.625) R10(3.25,1.625) R11(3.25,2.275) R12(3.25,2.925) R13(3.25,3.575) R14(3.25,4.225) T1(3.9,-4.225) T2(3.9,-3.575) T3(3.9,-2.925) T4(3.9,-2.275) T5(3.9,-1.625) T10(3.9,1.625) T11(3.9,2.275) T12(3.9,2.925) T13(3.9,3.575) T14(3.9,4.225) U1(4.55,-4.225) U2(4.55,-3.575) U3(4.55,-2.925) U4(4.55,-2.275) U5(4.55,-1.625) U10(4.55,1.625) U11(4.55,2.275) U12(4.55,2.925) U13(4.55,3.575) U14(4.55,4.225) V1(5.2,-4.225) V2(5.2,-3.575) V3(5.2,-2.925) V4(5.2,-2.275) V5(5.2,-1.625) V10(5.2,1.625) V11(5.2,2.275) V12(5.2,2.925) V13(5.2,3.575) V14(5.2,4.225) W1(5.85,-4.225) W2(5.85,-3.575) W3(5.85,-2.925) W4(5.85,-2.275) W5(5.85,-1.625) W10(5.85,1.625) W11(5.85,2.275) W12(5.85,2.925) W13(5.85,3.575) W14(5.85,4.225)
VX_BGA_337P_425X425
  round 0.254 smd: A1(5.06,-5.06) A23(-5.06,-5.06) AA2(4.6,4.14) AA22(-4.6,4.14) AB2(4.6,4.6) AB3(4.14,4.6) AB4(3.68,4.6) AB5(3.22,4.6) AB6(2.76,4.6) AB7(2.3,4.6) AB8(1.84,4.6) AB9(1.38,4.6) AB10(0.92,4.6) AB11(0.46,4.6) AB12(0,4.6) AB13(-0.46,4.6) AB14(-0.92,4.6) AB15(-1.38,4.6) AB16(-1.84,4.6) AB17(-2.3,4.6) AB18(-2.76,4.6) AB19(-3.22,4.6) AB20(-3.68,4.6) AB21(-4.14,4.6) AB22(-4.6,4.6) AC1(5.06,5.06) AC23(-5.06,5.06) B2(4.6,-4.6) B3(4.14,-4.6) B4(3.68,-4.6) B5(3.22,-4.6) B6(2.76,-4.6) B7(2.3,-4.6) B8(1.84,-4.6) B9(1.38,-4.6) B10(0.92,-4.6) B11(0.46,-4.6) B12(0,-4.6) B13(-0.46,-4.6) B14(-0.92,-4.6) B15(-1.38,-4.6) B16(-1.84,-4.6) B17(-2.3,-4.6) B18(-2.76,-4.6) B19(-3.22,-4.6) B20(-3.68,-4.6) B21(-4.14,-4.6) B22(-4.6,-4.6) C2(4.6,-4.14) C22(-4.6,-4.14) D2(4.6,-3.68) D4(3.9,-3.9) D5(3.25,-3.9) D6(2.6,-3.9) D8(1.95,-3.9) D9(1.3,-3.9) D11(0.65,-3.9) D12(0,-3.9) D13(-0.65,-3.9) D15(-1.3,-3.9) D16(-1.95,-3.9) D18(-2.6,-3.9) D19(-3.25,-3.9) D20(-3.9,-3.9) D22(-4.6,-3.68) E2(4.6,-3.22) E4(3.9,-3.25) E5(3.25,-3.25) E6(2.6,-3.25) E8(1.95,-3.25) E9(1.3,-3.25) E11(0.65,-3.25) E12(0,-3.25) E13(-0.65,-3.25) E15(-1.3,-3.25) E16(-1.95,-3.25) E18(-2.6,-3.25) E19(-3.25,-3.25) E20(-3.9,-3.25) E22(-4.6,-3.22) F2(4.6,-2.76) F4(3.9,-2.6) F5(3.25,-2.6) F6(2.6,-2.6) F8(1.95,-2.6) F9(1.3,-2.6) F11(0.65,-2.6) F12(0,-2.6) F13(-0.65,-2.6) F15(-1.3,-2.6) F16(-1.95,-2.6) F18(-2.6,-2.6) F19(-3.25,-2.6) F20(-3.9,-2.6) F22(-4.6,-2.76) G2(4.6,-2.3) G22(-4.6,-2.3) H2(4.6,-1.84) H4(3.9,-1.95) H5(3.25,-1.95) H6(2.6,-1.95) H8(1.95,-1.95) H9(1.3,-1.95) H11(0.65,-1.95) H12(0,-1.95) H13(-0.65,-1.95) H15(-1.3,-1.95) H16(-1.95,-1.95) H18(-2.6,-1.95) H19(-3.25,-1.95) H20(-3.9,-1.95) H22(-4.6,-1.84) J2(4.6,-1.38) J4(3.9,-1.3) J5(3.25,-1.3) J6(2.6,-1.3) J8(1.95,-1.3) J9(1.3,-1.3) J11(0.65,-1.3) J12(0,-1.3) J13(-0.65,-1.3) J15(-1.3,-1.3) J16(-1.95,-1.3) J18(-2.6,-1.3) J19(-3.25,-1.3) J20(-3.9,-1.3) J22(-4.6,-1.38) K2(4.6,-0.92) K22(-4.6,-0.92) L2(4.6,-0.46) L4(3.9,-0.65) L5(3.25,-0.65) L6(2.6,-0.65) L8(1.95,-0.65) L9(1.3,-0.65) L11(0.65,-0.65) L12(0,-0.65) L13(-0.65,-0.65) L15(-1.3,-0.65) L16(-1.95,-0.65) L18(-2.6,-0.65) L19(-3.25,-0.65) L20(-3.9,-0.65) L22(-4.6,-0.46) M2(4.6,0) M4(3.9,0) M5(3.25,0) M6(2.6,0) M8(1.95,0) M9(1.3,0) M11(0.65,0) M12(0,0) M13(-0.65,0) M15(-1.3,0) M16(-1.95,0) M18(-2.6,0) M19(-3.25,0) M20(-3.9,0) M22(-4.6,0) N2(4.6,0.46) N4(3.9,0.65) N5(3.25,0.65) N6(2.6,0.65) N8(1.95,0.65) N9(1.3,0.65) N11(0.65,0.65) N12(0,0.65) N13(-0.65,0.65) N15(-1.3,0.65) N16(-1.95,0.65) N18(-2.6,0.65) N19(-3.25,0.65) N20(-3.9,0.65) N22(-4.6,0.46) P2(4.6,0.92) P22(-4.6,0.92) R2(4.6,1.38) R4(3.9,1.3) R5(3.25,1.3) R6(2.6,1.3) R8(1.95,1.3) R9(1.3,1.3) R11(0.65,1.3) R12(0,1.3) R13(-0.65,1.3) R15(-1.3,1.3) R16(-1.95,1.3) R18(-2.6,1.3) R19(-3.25,1.3) R20(-3.9,1.3) R22(-4.6,1.38) T2(4.6,1.84) T4(3.9,1.95) T5(3.25,1.95) T6(2.6,1.95) T8(1.95,1.95) T9(1.3,1.95) T11(0.65,1.95) T12(0,1.95) T13(-0.65,1.95) T15(-1.3,1.95) T16(-1.95,1.95) T18(-2.6,1.95) T19(-3.25,1.95) T20(-3.9,1.95) T22(-4.6,1.84) U2(4.6,2.3) U22(-4.6,2.3) V2(4.6,2.76) V4(3.9,2.6) V5(3.25,2.6) V6(2.6,2.6) V8(1.95,2.6) V9(1.3,2.6) V11(0.65,2.6) V12(0,2.6) V13(-0.65,2.6) V15(-1.3,2.6) V16(-1.95,2.6) V18(-2.6,2.6) V19(-3.25,2.6) V20(-3.9,2.6) V22(-4.6,2.76) W2(4.6,3.22) W4(3.9,3.25) W5(3.25,3.25) W6(2.6,3.25) W8(1.95,3.25) W9(1.3,3.25) W11(0.65,3.25) W12(0,3.25) W13(-0.65,3.25) W15(-1.3,3.25) W16(-1.95,3.25) W18(-2.6,3.25) W19(-3.25,3.25) W20(-3.9,3.25) W22(-4.6,3.22) Y2(4.6,3.68) Y4(3.9,3.9) Y5(3.25,3.9) Y6(2.6,3.9) Y8(1.95,3.9) Y9(1.3,3.9) Y11(0.65,3.9) Y12(0,3.9) Y13(-0.65,3.9) Y15(-1.3,3.9) Y16(-1.95,3.9) Y18(-2.6,3.9) Y19(-3.25,3.9) Y20(-3.9,3.9) Y22(-4.6,3.68)
  oval 0.178x0.33 smd: A2(4.6,-5.06) A3(4.14,-5.06) A4(3.68,-5.06) A5(3.22,-5.06) A6(2.76,-5.06) A7(2.3,-5.06) A8(1.84,-5.06) A9(1.38,-5.06) A10(0.92,-5.06) A11(0.46,-5.06) A12(0,-5.06) A13(-0.46,-5.06) A14(-0.92,-5.06) A15(-1.38,-5.06) A16(-1.84,-5.06) A17(-2.3,-5.06) A18(-2.76,-5.06) A19(-3.22,-5.06) A20(-3.68,-5.06) A21(-4.14,-5.06) A22(-4.6,-5.06) AC2(4.6,5.06) AC3(4.14,5.06) AC4(3.68,5.06) AC5(3.22,5.06) AC6(2.76,5.06) AC7(2.3,5.06) AC8(1.84,5.06) AC9(1.38,5.06) AC10(0.92,5.06) AC11(0.46,5.06) AC12(0,5.06) AC13(-0.46,5.06) AC14(-0.92,5.06) AC15(-1.38,5.06) AC16(-1.84,5.06) AC17(-2.3,5.06) AC18(-2.76,5.06) AC19(-3.22,5.06) AC20(-3.68,5.06) AC21(-4.14,5.06) AC22(-4.6,5.06)
  oval 0.33x0.178 smd: AA1(5.06,4.14) AA23(-5.06,4.14) AB1(5.06,4.6) AB23(-5.06,4.6) B1(5.06,-4.6) B23(-5.06,-4.6) C1(5.06,-4.14) C23(-5.06,-4.14) D1(5.06,-3.68) D23(-5.06,-3.68) E1(5.06,-3.22) E23(-5.06,-3.22) F1(5.06,-2.76) F23(-5.06,-2.76) G1(5.06,-2.3) G23(-5.06,-2.3) H1(5.06,-1.84) H23(-5.06,-1.84) J1(5.06,-1.38) J23(-5.06,-1.38) K1(5.06,-0.92) K23(-5.06,-0.92) L1(5.06,-0.46) L23(-5.06,-0.46) M1(5.06,0) M23(-5.06,0) N1(5.06,0.46) N23(-5.06,0.46) P1(5.06,0.92) P23(-5.06,0.92) R1(5.06,1.38) R23(-5.06,1.38) T1(5.06,1.84) T23(-5.06,1.84) U1(5.06,2.3) U23(-5.06,2.3) V1(5.06,2.76) V23(-5.06,2.76) W1(5.06,3.22) W23(-5.06,3.22) Y1(5.06,3.68) Y23(-5.06,3.68)
VX_BGA_837P_906X906_INT
  round 0.305 smd: A2(10.814,10.46) A3(10.814,9.959) A4(10.814,9.459) A42(10.814,-9.459) A43(10.814,-9.959) A44(10.814,-10.46) AA17(0.775,3.099) AA18(0.775,2.324) AA20(0.775,1.549) AA21(0.775,0.775) AA23(0.775,0) AA25(0.775,-0.775) AA26(0.775,-1.549) AA28(0.775,-2.324) AA29(0.775,-3.099) AB7(0.667,8.175) AB8(0.667,7.413) AB10(0.667,6.651) AB11(0.667,5.889) AB13(0.667,5.127) AB14(0.667,4.365) AB15(0.667,3.807) AB31(0.667,-3.807) AB32(0.667,-4.365) AB33(0.667,-5.127) AB35(0.667,-5.889) AB36(0.667,-6.651) AB38(0.667,-7.413) AB39(0.667,-8.175) AC17(0,3.099) AC18(0,2.324) AC20(0,1.549) AC21(0,0.775) AC23(0,0) AC25(0,-0.775) AC26(0,-1.549) AC28(0,-2.324) AC29(0,-3.099) AD7(-0.667,8.175) AD8(-0.667,7.413) AD10(-0.667,6.651) AD11(-0.667,5.889) AD13(-0.667,5.127) AD14(-0.667,4.365) AD15(-0.667,3.807) AD31(-0.667,-3.807) AD32(-0.667,-4.365) AD33(-0.667,-5.127) AD35(-0.667,-5.889) AD36(-0.667,-6.651) AD38(-0.667,-7.413) AD39(-0.667,-8.175) AE17(-0.775,3.099) AE18(-0.775,2.324) AE20(-0.775,1.549) AE21(-0.775,0.775) AE23(-0.775,0) AE25(-0.775,-0.775) AE26(-0.775,-1.549) AE28(-0.775,-2.324) AE29(-0.775,-3.099) AF17(-1.549,3.099) AF18(-1.549,2.324) AF20(-1.549,1.549) AF21(-1.549,0.775) AF23(-1.549,0) AF25(-1.549,-0.775) AF26(-1.549,-1.549) AF28(-1.549,-2.324) AF29(-1.549,-3.099) AG7(-1.772,8.175) AG8(-1.772,7.413) AG10(-1.772,6.651) AG11(-1.772,5.889) AG13(-1.772,5.127) AG14(-1.772,4.365) AG15(-1.772,3.807) AG31(-1.772,-3.807) AG32(-1.772,-4.365) AG33(-1.772,-5.127) AG35(-1.772,-5.889) AG36(-1.772,-6.651) AG38(-1.772,-7.413) AG39(-1.772,-8.175) AH17(-2.324,3.099) AH18(-2.324,2.324) AH20(-2.324,1.549) AH21(-2.324,0.775) AH23(-2.324,0) AH25(-2.324,-0.775) AH26(-2.324,-1.549) AH28(-2.324,-2.324) AH29(-2.324,-3.099) AJ7(-2.953,8.074) AJ8(-2.953,7.312) AJ10(-2.953,6.55) AJ11(-2.953,5.788) AJ13(-2.953,5.026) AJ14(-2.953,4.315) AJ15(-2.953,3.807) AJ17(-3.099,3.099) AJ18(-3.099,2.324) AJ20(-3.099,1.549) AJ21(-3.099,0.775) AJ23(-3.099,0) AJ25(-3.099,-0.775) AJ26(-3.099,-1.549) AJ28(-3.099,-2.324) AJ29(-3.099,-3.099) AJ31(-2.953,-3.807) AJ32(-2.953,-4.365) AJ33(-2.953,-5.127) AJ35(-2.953,-5.889) AJ36(-2.953,-6.651) AJ38(-2.953,-7.413) AJ39(-2.953,-8.175) AL7(-4.071,8.074) AL8(-4.071,7.312) AL10(-4.071,6.55) AL11(-4.071,5.788) AL13(-4.071,5.026) AL17(-3.807,2.953) AL19(-3.807,1.772) AL22(-3.807,0.667) AL24(-3.807,-0.667) AL27(-3.807,-1.772) AL29(-3.807,-2.953) AL32(-4.096,-4.34) AL33(-4.096,-5.102) AL35(-4.096,-5.864) AL36(-4.096,-6.626) AL38(-4.096,-7.388) AL39(-4.096,-8.15) AM15(-4.34,4.096) AM17(-4.365,2.953) AM19(-4.365,1.772) AM22(-4.365,0.667) AM24(-4.365,-0.667) AM27(-4.365,-1.772) AM29(-4.315,-2.953) AN7(-5.036,8.023) AN8(-4.985,7.261) AN10(-4.985,6.499) AN11(-5.026,5.753) AN15(-5.102,4.096) AN17(-5.127,2.953) AN19(-5.127,1.772) AN22(-5.127,0.667) AN24(-5.127,-0.667) AN27(-5.127,-1.772) AN29(-5.026,-2.953) AN31(-5.026,-4.071) AN36(-5.087,-6.47) AN38(-5.087,-7.232) AN39(-5.087,-7.994) AP11(-5.551,6.04) AR7(-6.037,7.999) AR9(-6.077,7.084) AR15(-5.864,4.096) AR17(-5.889,2.953) AR19(-5.889,1.772) AR22(-5.889,0.667) AR24(-5.889,-0.667) AR27(-5.889,-1.772) AR29(-5.788,-2.953) AR31(-5.788,-4.071) AR33(-5.753,-5.026) AR34(-6.04,-5.551) AR38(-6.068,-7.396) AR39(-6.068,-8.158) AT9(-6.713,6.938) AT10(-6.663,6.311) AT13(-6.47,5.087) AT15(-6.626,4.096) AT17(-6.651,2.953) AT19(-6.651,1.772) AT22(-6.651,0.667) AT24(-6.651,-0.667) AT27(-6.651,-1.772) AT29(-6.55,-2.953) AT31(-6.55,-4.071) AT33(-6.499,-4.985) AT36(-6.311,-6.663) AU7(-6.994,7.936) AU35(-7.084,-6.077) AU36(-6.938,-6.713) AU39(-7.141,-7.991) AV6(-7.645,8.237) AV11(-7.396,6.068) AV13(-7.232,5.087) AV15(-7.388,4.096) AV17(-7.413,2.953) AV19(-7.413,1.772) AV22(-7.413,0.667) AV24(-7.413,-0.667) AV27(-7.413,-1.772) AV29(-7.312,-2.953) AV31(-7.312,-4.071) AV33(-7.261,-4.985) AW9(-7.991,7.141) AW11(-8.158,6.068) AW13(-7.994,5.087) AW15(-8.15,4.096) AW17(-8.175,2.953) AW19(-8.175,1.772) AW22(-8.175,0.667) AW24(-8.175,-0.667) AW27(-8.175,-1.772) AW29(-8.074,-2.953) AW31(-8.074,-4.071) AW33(-8.023,-5.036) AW35(-7.999,-6.037) AW37(-7.936,-6.994) AY5(-8.585,8.764) AY38(-8.237,-7.645) B1(10.46,10.814) B2(10.33,10.33) B3(10.326,9.824) B43(10.304,-9.8) B44(10.33,-10.33) B45(10.46,-10.814) BA40(-8.764,-8.585) BB1(-9.459,10.814) BB45(-9.459,-10.814) BC1(-9.959,10.814) BC2(-9.824,10.326) BC44(-9.8,-10.304) BC45(-9.959,-10.814) BD1(-10.46,10.814) BD2(-10.33,10.33) BD3(-10.304,9.8) BD43(-10.326,-9.824) BD44(-10.33,-10.33) BD45(-10.46,-10.814) BE2(-10.814,10.46) BE3(-10.814,9.959) BE4(-10.814,9.459) BE42(-10.814,-9.459) BE43(-10.814,-9.959) BE44(-10.814,-10.46) C1(9.959,10.814) C2(9.8,10.304) C42(9.86,-9.288) C44(9.824,-10.326) C45(9.959,-10.814) D1(9.459,10.814) D45(9.459,-10.814) F8(8.237,7.645) G9(7.936,6.994) G11(7.999,6.037) G13(8.023,5.036) G15(8.074,4.071) G17(8.074,2.953) G19(8.175,1.772) G22(8.175,0.667) G24(8.175,-0.667) G27(8.175,-1.772) G29(8.175,-2.953) G31(8.15,-4.096) G33(7.994,-5.087) G35(8.158,-6.068) G37(7.991,-7.141) H13(7.261,4.985) H15(7.312,4.071) H17(7.312,2.953) H19(7.413,1.772) H22(7.413,0.667) H24(7.413,-0.667) H27(7.413,-1.772) H29(7.413,-2.953) H31(7.388,-4.096) H33(7.232,-5.087) H35(7.396,-6.068) J7(7.141,7.991) J10(6.938,6.713) J11(7.084,6.077) J39(6.994,-7.936) K10(6.311,6.663) K13(6.499,4.985) K15(6.55,4.071) K17(6.55,2.953) K19(6.651,1.772) K22(6.651,0.667) K24(6.651,-0.667) K27(6.651,-1.772) K29(6.651,-2.953) K31(6.626,-4.096) K33(6.47,-5.087) K36(6.663,-6.311) K37(6.713,-6.938) L7(6.068,8.158) L8(6.068,7.396) L12(6.04,5.551) L13(5.753,5.026) L15(5.788,4.071) L17(5.788,2.953) L19(5.889,1.772) L22(5.889,0.667) L24(5.889,-0.667) L27(5.889,-1.772) L29(5.889,-2.953) L31(5.864,-4.096) L37(6.077,-7.084) L39(6.037,-7.999) M35(5.551,-6.04) N7(5.087,7.994) N8(5.087,7.232) N10(5.087,6.47) N15(5.026,4.071) N17(5.026,2.953) N19(5.127,1.772) N22(5.127,0.667) N24(5.127,-0.667) N27(5.127,-1.772) N29(5.127,-2.953) N31(5.102,-4.096) N35(5.026,-5.753) N36(4.985,-6.499) N38(4.985,-7.261) N39(5.036,-8.023) P17(4.315,2.953) P19(4.365,1.772) P22(4.365,0.667) P24(4.365,-0.667) P27(4.365,-1.772) P29(4.365,-2.953) P31(4.34,-4.096) R7(4.096,8.15) R8(4.096,7.388) R10(4.096,6.626) R11(4.096,5.864) R13(4.096,5.102) R14(4.096,4.34) R17(3.807,2.953) R19(3.807,1.772) R22(3.807,0.667) R24(3.807,-0.667) R27(3.807,-1.772) R29(3.807,-2.953) R33(4.071,-5.026) R35(4.071,-5.788) R36(4.071,-6.55) R38(4.071,-7.312) R39(4.071,-8.074) U7(2.953,8.175) U8(2.953,7.413) U10(2.953,6.651) U11(2.953,5.889) U13(2.953,5.127) U14(2.953,4.365) U15(2.953,3.807) U17(3.099,3.099) U18(3.099,2.324) U20(3.099,1.549) U21(3.099,0.775) U23(3.099,0) U25(3.099,-0.775) U26(3.099,-1.549) U28(3.099,-2.324) U29(3.099,-3.099) U31(2.953,-3.807) U32(2.953,-4.315) U33(2.953,-5.026) U35(2.953,-5.788) U36(2.953,-6.55) U38(2.953,-7.312) U39(2.953,-8.074) V17(2.324,3.099) V18(2.324,2.324) V20(2.324,1.549) V21(2.324,0.775) V23(2.324,0) V25(2.324,-0.775) V26(2.324,-1.549) V28(2.324,-2.324) V29(2.324,-3.099) W7(1.772,8.175) W8(1.772,7.413) W10(1.772,6.651) W11(1.772,5.889) W13(1.772,5.127) W14(1.772,4.365) W15(1.772,3.807) W31(1.772,-3.807) W32(1.772,-4.365) W33(1.772,-5.127) W35(1.772,-5.889) W36(1.772,-6.651) W38(1.772,-7.413) W39(1.772,-8.175) Y17(1.549,3.099) Y18(1.549,2.324) Y20(1.549,1.549) Y21(1.549,0.775) Y23(1.549,0) Y25(1.549,-0.775) Y26(1.549,-1.549) Y28(1.549,-2.324) Y29(1.549,-3.099)
  round 0.279 smd: A5(10.814,8.959) A41(10.814,-8.959) BA1(-8.959,10.814) BA45(-8.959,-10.814) BE5(-10.814,8.959) BE41(-10.814,-8.959) E1(8.959,10.814) E45(8.959,-10.814)
  round 0.254 smd: A6(10.814,8.458) A25(10.814,-1.225) A40(10.814,-8.458) AB3(0.609,9.888) AB4(0.482,9.403) AB5(0.667,8.937) AB41(0.667,-8.937) AB42(0.509,-9.421) AC3(0.096,9.727) AD3(-0.484,9.929) AD4(-0.509,9.421) AD5(-0.667,8.937) AD41(-0.667,-8.937) AD42(-0.482,-9.403) AF3(-1.664,9.888) AF5(-1.721,8.885) AF41(-1.721,-8.887) AG3(-2.178,9.727) AG4(-1.791,9.403) AG42(-1.764,-9.421) AJ4(-2.783,9.421) AJ5(-2.953,8.836) AJ41(-2.953,-8.937) AJ42(-2.756,-9.403) AL3(-3.937,9.888) AL4(-4.064,9.403) AL5(-4.071,8.836) AL41(-4.096,-8.887) AL42(-4.037,-9.421) AM3(-4.451,9.727) AN3(-5.03,9.929) AN4(-5.056,9.421) AN5(-5.163,8.785) AN41(-5.087,-8.756) AN42(-5.029,-9.403) AR5(-6.182,8.886) AR41(-6.068,-8.92) AT4(-6.338,9.403) AT42(-6.311,-9.421) AU41(-7.09,-9.038) AU43(-6.915,-9.727) AV3(-7.355,9.929) AV4(-7.321,9.229) AV43(-7.391,-9.888) AW4(-8.204,9.434) AW42(-7.816,-9.24) AY1(-8.458,10.814) AY45(-8.458,-10.814) B6(10.296,8.45) B10(10.235,6.724) B25(10.306,-1.225) B40(10.355,-8.701) BA4(-9.12,9.602) BA5(-9.095,8.767) BA9(-9.038,7.09) BA11(-8.92,6.068) BA13(-8.756,5.087) BA15(-8.887,4.096) BA17(-8.937,2.953) BA20(-8.887,1.721) BA22(-8.937,0.667) BA24(-8.937,-0.667) BA26(-8.885,-1.721) BA29(-8.836,-2.953) BA31(-8.836,-4.071) BA33(-8.785,-5.163) BA35(-8.886,-6.182) BA41(-8.767,-9.095) BB3(-9.344,10.162) BB7(-9.24,7.816) BB10(-9.421,6.311) BB13(-9.403,5.029) BB15(-9.421,4.037) BB17(-9.403,2.756) BB19(-9.421,1.764) BB22(-9.403,0.482) BB24(-9.421,-0.509) BB27(-9.403,-1.791) BB29(-9.421,-2.783) BB31(-9.403,-4.064) BB33(-9.421,-5.056) BB36(-9.403,-6.338) BB38(-9.229,-7.321) BB39(-9.434,-8.204) BB41(-9.602,-9.12) BB43(-9.288,-9.86) BC4(-9.86,9.288) BC9(-9.727,6.915) BC42(-10.162,-9.344) BE6(-10.814,8.458) BE40(-10.814,-8.458) C8(9.929,7.355) C10(9.727,6.724) C11(9.888,6.211) C14(9.727,4.451) C15(9.888,3.937) C17(9.929,2.757) C19(9.727,2.178) C20(9.888,1.664) C23(9.727,-0.096) C24(9.888,-0.609) C27(9.929,-1.789) C28(9.727,-2.369) C29(9.888,-2.883) C31(9.929,-4.063) C32(9.727,-4.642) C33(9.888,-5.156) C36(9.929,-6.336) C37(9.727,-6.915) C38(9.888,-7.391) D3(9.288,9.86) D5(9.602,9.12) D7(9.434,8.204) D8(9.229,7.321) D10(9.403,6.338) D13(9.421,5.056) D15(9.403,4.064) D17(9.421,2.783) D19(9.403,1.791) D22(9.421,0.509) D24(9.403,-0.482) D27(9.421,-1.764) D29(9.403,-2.756) D31(9.421,-4.037) D33(9.403,-5.029) D36(9.421,-6.311) D39(9.24,-7.816) D43(9.344,-10.162) E5(8.767,9.095) E6(8.764,8.585) E11(8.886,6.182) E13(8.785,5.163) E15(8.836,4.071) E17(8.836,2.953) E20(8.885,1.721) E22(8.937,0.667) E24(8.937,-0.667) E26(8.887,-1.721) E29(8.937,-2.953) E31(8.887,-4.096) E33(8.756,-5.087) E35(8.92,-6.068) E37(9.038,-7.09) E41(9.095,-8.767) E42(9.12,-9.602) F1(8.458,10.814) F41(8.585,-8.764) F44(8.45,-10.296) F45(8.458,-10.814) G4(7.816,9.24) G42(8.204,-9.434) H2(7.391,10.396) H3(7.391,9.888) H40(7.645,-8.237) H42(7.321,-9.229) H43(7.355,-9.929) J2(6.915,10.235) J3(6.915,9.727) J5(7.09,9.038) K2(6.432,10.428) K3(6.336,9.929) K4(6.311,9.421) K42(6.338,-9.403) K43(6.724,-9.727) L5(6.068,8.92) L41(6.182,-8.886) L43(6.211,-9.888) N3(5.156,9.888) N4(5.029,9.403) N5(5.087,8.756) N41(5.163,-8.785) N42(5.056,-9.421) P3(4.642,9.727) R4(4.037,9.421) R5(4.096,8.887) R41(4.071,-8.836) R42(4.064,-9.403) U3(2.883,9.888) U4(2.756,9.403) U5(2.953,8.937) U41(2.953,-8.836) U42(2.783,-9.421) V3(2.369,9.727) W3(1.789,9.929) W4(1.764,9.421) W42(1.791,-9.403) Y5(1.721,8.887) Y41(1.721,-8.885)
  custom 0.051x0.051 smd: A7(10.814,7.893) A9(10.814,6.852) A12(10.814,5.595) A14(10.814,4.553) A16(10.814,3.321) A18(10.814,2.28) A21(10.814,1.048) A23(10.814,0.007) A28(10.814,-2.267) A30(10.814,-3.499) A32(10.814,-4.54) A35(10.814,-5.772) A37(10.814,-6.839) A39(10.814,-7.893) AA1(1.225,10.814) AA2(1.225,10.306) AA44(1.048,-10.306) AA45(1.048,-10.814) AB2(0.609,10.396) AB43(0.484,-9.929) AB44(0.388,-10.428) AC1(-0.007,10.814) AC2(0.096,10.235) AC44(-0.096,-10.235) AC45(0.007,-10.814) AD2(-0.388,10.428) AD43(-0.609,-9.888) AD44(-0.609,-10.396) AE1(-1.048,10.814) AE2(-1.048,10.306) AE44(-1.225,-10.306) AE45(-1.225,-10.814) AF2(-1.664,10.396) AG2(-2.178,10.235) AG43(-1.789,-9.929) AG44(-1.886,-10.428) AH1(-2.28,10.814) AH2(-2.661,10.428) AH44(-2.369,-10.235) AH45(-2.267,-10.814) AJ3(-2.757,9.929) AJ43(-2.883,-9.888) AJ44(-2.883,-10.396) AK1(-3.321,10.814) AK2(-3.321,10.306) AK44(-3.499,-10.306) AK45(-3.499,-10.814) AL2(-3.937,10.396) AL43(-4.063,-9.929) AL44(-4.159,-10.428) AM1(-4.553,10.814) AM2(-4.451,10.235) AM44(-4.642,-10.235) AM45(-4.54,-10.814) AN2(-4.934,10.428) AN43(-5.156,-9.888) AN44(-5.156,-10.396) AP1(-5.595,10.814) AP2(-5.595,10.306) AR2(-6.211,10.396) AR3(-6.211,9.888) AR44(-5.772,-10.306) AR45(-5.772,-10.814) AT2(-6.724,10.235) AT43(-6.336,-9.929) AT44(-6.432,-10.428) AU1(-6.852,10.814) AU44(-6.915,-10.235) AU45(-6.839,-10.814) AV2(-7.258,10.428) AV44(-7.391,-10.396) AW1(-7.893,10.814) AW2(-7.944,10.306) AW44(-7.944,-10.306) AW45(-7.893,-10.814) AY44(-8.701,-10.355) B7(10.306,7.944) B8(10.428,7.258) B11(10.396,6.211) B12(10.306,5.595) B13(10.428,4.934) B14(10.235,4.451) B15(10.396,3.937) B16(10.306,3.321) B18(10.428,2.661) B19(10.235,2.178) B20(10.396,1.664) B21(10.306,1.048) B22(10.428,0.388) B23(10.235,-0.096) B24(10.396,-0.609) B27(10.428,-1.886) B29(10.396,-2.883) B30(10.306,-3.499) B31(10.428,-4.159) B32(10.235,-4.642) B33(10.396,-5.156) B35(10.306,-5.772) B36(10.428,-6.432) B37(10.235,-6.915) B38(10.396,-7.391) B39(10.306,-7.944) BC8(-9.888,7.391) BC10(-9.929,6.336) BC13(-9.888,5.156) BC15(-9.929,4.063) BC17(-9.888,2.883) BC19(-9.929,1.789) BC22(-9.888,0.609) BC24(-9.929,-0.484) BC26(-9.888,-1.664) BC29(-9.929,-2.757) BC31(-9.888,-3.937) BC33(-9.929,-5.03) BC35(-9.888,-6.211) BC38(-9.929,-7.355) BD6(-10.355,8.701) BD7(-10.306,7.944) BD8(-10.396,7.391) BD9(-10.235,6.915) BD10(-10.428,6.432) BD11(-10.306,5.772) BD13(-10.396,5.156) BD14(-10.235,4.642) BD15(-10.428,4.159) BD16(-10.306,3.499) BD17(-10.396,2.883) BD18(-10.235,2.369) BD19(-10.428,1.886) BD21(-10.306,1.225) BD22(-10.396,0.609) BD23(-10.235,0.096) BD24(-10.428,-0.388) BD25(-10.306,-1.048) BD26(-10.396,-1.664) BD27(-10.235,-2.178) BD28(-10.428,-2.661) BD30(-10.306,-3.321) BD31(-10.396,-3.937) BD32(-10.235,-4.451) BD33(-10.428,-4.934) BD34(-10.306,-5.595) BD35(-10.396,-6.211) BD36(-10.235,-6.724) BD38(-10.428,-7.258) BD39(-10.306,-7.944) BE7(-10.814,7.893) BE9(-10.814,6.839) BE11(-10.814,5.772) BE14(-10.814,4.54) BE16(-10.814,3.499) BE18(-10.814,2.267) BE21(-10.814,1.225) BE23(-10.814,-0.007) BE25(-10.814,-1.048) BE28(-10.814,-2.28) BE30(-10.814,-3.321) BE32(-10.814,-4.553) BE34(-10.814,-5.595) BE37(-10.814,-6.852) BE39(-10.814,-7.893) C13(9.929,5.03) C22(9.929,0.484) F2(8.701,10.355) G1(7.893,10.814) G2(7.944,10.306) G44(7.944,-10.306) G45(7.893,-10.814) H44(7.258,-10.428) J1(6.839,10.814) J45(6.852,-10.814) K44(6.724,-10.235) L1(5.772,10.814) L2(5.772,10.306) L44(6.211,-10.396) M44(5.595,-10.306) M45(5.595,-10.814) N2(5.156,10.396) N43(5.03,-9.929) N44(4.934,-10.428) P1(4.54,10.814) P2(4.642,10.235) P44(4.451,-10.235) P45(4.553,-10.814) R2(4.159,10.428) R3(4.063,9.929) R43(3.937,-9.888) R44(3.937,-10.396) T1(3.499,10.814) T2(3.499,10.306) T44(3.321,-10.306) T45(3.321,-10.814) U2(2.883,10.396) U43(2.757,-9.929) V1(2.267,10.814) V2(2.369,10.235) V44(2.661,-10.428) V45(2.28,-10.814) W2(1.886,10.428) W44(2.178,-10.235) Y43(1.664,-9.888) Y44(1.664,-10.396)
  round 0.368 smd: AA4(1.225,9.326) AA42(1.048,-9.324) AE4(-1.048,9.324) AE42(-1.225,-9.326) AK4(-3.321,9.324) AK42(-3.499,-9.326) AP4(-5.595,9.324) AR42(-5.772,-9.326) AY2(-8.45,10.296) BB11(-9.326,5.772) BB16(-9.326,3.499) BB21(-9.326,1.225) BB25(-9.324,-1.048) BB30(-9.324,-3.321) BB34(-9.324,-5.595) BD40(-10.296,-8.45) C4(10.162,9.344) D12(9.324,5.595) D16(9.324,3.321) D21(9.324,1.048) D25(9.326,-1.225) D30(9.326,-3.499) D35(9.326,-5.772) L4(5.772,9.326) M42(5.595,-9.324) T4(3.499,9.326) T42(3.321,-9.324)
  custom 0.057x0.057 smd: AC43(-0.096,-9.727) AH43(-2.369,-9.727) AM43(-4.642,-9.727) AT3(-6.724,9.727) B28(10.235,-2.369) BC14(-9.727,4.642) BC18(-9.727,2.369) BC23(-9.727,0.096) BC27(-9.727,-2.178) BC32(-9.727,-4.451) BC36(-9.727,-6.724) P43(4.451,-9.727) W43(2.178,-9.727)
