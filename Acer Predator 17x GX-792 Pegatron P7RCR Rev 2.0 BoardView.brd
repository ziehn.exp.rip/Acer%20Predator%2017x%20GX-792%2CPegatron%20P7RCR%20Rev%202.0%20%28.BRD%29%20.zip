# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CHA_DQS7: length 75.3
  TOP w0.146: v2(104.5,59.42) 105.16,59.42 105.54,59.8 105.54,61.04 104.87,61.71 CON1600.242
  IN1 w0.127: v3(108.97,101.33) 108.97,101.84 109.21,102.08 114.01,102.08 118.74,97.35 118.74,89.18 117.35,87.79 117.35,77.13 116.64,76.42 116.64,73.52 112.27,69.14 112.27,67.9 106.17,61.81 105.07,61.81 103.64,60.37 103.64,59.98 103.88,59.74 104.18,59.74 v2(104.5,59.42)
  BOTTOM w0.076: U0300.M3 107.8,104.68 107.66,104.54 107.6,104.54 107.27,104.2 107.27,102.24 108.18,101.33 v3(108.97,101.33)
  BOTTOM w0.146: CON1601.242 102.88,57.62 102.62,57.87 102.62,58.17 102.69,58.23 103.61,58.23 103.89,58.52 103.89,58.88 103.24,59.53 103.24,59.68 103.61,60.05 103.81,60.05 104.13,59.73 104.13,59.51 104.22,59.42 v2(104.5,59.42)
M_CHA_DQS7#: length 75.2
  TOP w0.146: v2(104.49,60.05) 104.73,60.05 104.81,59.97 104.81,59.74 104.88,59.67 105.06,59.67 105.3,59.9 105.3,60.94 104.63,61.61 104.63,63.52 104.37,63.77 CON1600.240
  IN1 w0.127: v2(104.49,60.05) 104.28,60.05 104.19,59.96 103.97,59.96 103.86,60.07 103.86,60.28 105.16,61.58 106.26,61.58 112.5,67.81 112.5,69.05 116.87,73.42 116.87,76.33 117.58,77.04 117.58,87.69 118.97,89.09 118.97,97.44 114.11,102.31 109.11,102.31 v3(108.53,101.72)
  BOTTOM w0.076: v3(108.53,101.72) 108.53,101.56 108.48,101.51 108.26,101.51 107.45,102.32 107.45,104.13 107.68,104.36 108.21,104.36 U0300.L3
  BOTTOM w0.146: CON1601.240 102.38,58.27 102.59,58.48 103.51,58.48 103.64,58.62 103.64,58.78 102.99,59.43 102.99,59.78 103.51,60.3 103.91,60.3 104.16,60.05 v2(104.49,60.05)
M_CHA_MAA0: length 72.8
  TOP w0.229: CON1600.144 78.37,63.9 77.95,63.47 77.95,58.31 v2(77.52,57.87)
  IN1 w0.076: v3(94.63,101.64) 95,101.27 95,100.16 94.77,99.92 94.77,99.63
  IN1 w0.159: 94.77,99.63 94.77,97.5 96.23,96.03 96.23,91.99 95.39,91.14 95.39,87.86 80.16,72.64 80.16,72.41 79.16,71.4 79.16,69.63 79.84,68.95 79.84,64.8 80.05,64.59 80.05,62.88 80.03,62.86 80.03,60.72 79.69,60.38 79.69,57.9 79.35,57.56 77.83,57.56 v2(77.52,57.87)
  BOTTOM w0.076: U0300.AH3 95.09,104.55 94.98,104.55 94.71,104.27 94.71,103.1 94.9,102.91 94.9,101.72 94.82,101.64 v3(94.63,101.64)
  BOTTOM w0.229: v2(77.52,57.87) 78.37,57.02 78.37,55.85 78.22,55.7 77.34,55.7 77.11,55.94 77.11,57.47 76.82,57.76 76.5,57.76 76.38,57.64 CON1601.144
M_CHA_MAA1: length 63.5
  TOP w0.229: CON1600.133 75.63,56.6 75.63,57.49 75.18,57.94 75.18,60.44 v2(74.7,60.92)
  IN1 w0.159: v3(89.75,105.69) 90.15,105.29 90.15,103.87 90.85,103.17 90.85,97.62 89.85,96.62 89.85,91.24 72.73,74.12 72.73,64.1 74.22,62.6 74.22,61.39 v2(74.7,60.92)
  BOTTOM w0.076: U0300.AP4 90.1,105.34 v3(89.75,105.69)
  BOTTOM w0.229: CON1601.133 73.63,63.64 74.04,63.22 74.04,62.87 73.63,62.46 73.63,61.99 v2(74.7,60.92)
M_CHA_MAA2: length 68.3
  TOP w0.229: CON1600.132 75.37,63.71 75.58,63.5 75.58,63.17 75.47,63.05 74.97,63.05 74.81,62.9 74.81,62.52 74.99,62.34 75.4,62.34 75.58,62.17 75.58,61.3 75.41,61.14 75.25,61.14 v2(74.69,61.71)
  IN1 w0.159: v3(91.34,104.37) 91.23,104.47 90.9,104.47 90.78,104.36 90.78,103.94 91.41,103.31 91.41,96.94 91.2,96.72 90.49,96.72 90.25,96.48 90.25,96.23 90.42,96.06 91.18,96.06 91.33,95.91 91.33,95.59 91.17,95.43 90.41,95.43 90.25,95.27 90.25,94.94 90.79,94.39 90.79,94.15 90.25,93.61 90.25,90.93 73.23,73.92 73.23,65.76 73.39,65.6 73.62,65.6 73.78,65.44 73.78,65.12 73.62,64.97 73.39,64.97 73.23,64.81 73.23,64.31 74.73,62.81 74.73,61.75 v2(74.69,61.71)
  BOTTOM w0.076: v3(91.34,104.37) 91.34,104.94 U0300.AN4
  BOTTOM w0.229: v2(74.69,61.71) 74.7,61.71 75.18,61.23 75.18,59.69 73.38,57.89 CON1601.132
M_CHA_MAA3: length 66.3
  TOP w0.229: v2(74.71,60.18) 74.71,59.3 74.52,59.12 74.04,59.12 73.83,58.9 73.83,58.35 74.48,57.69 74.96,57.69 75.12,57.53 CON1600.131
  IN1 w0.159: v2(74.71,60.18) 73.72,61.16 73.72,62.39 72.22,63.89 72.22,74.33 89.35,91.45 89.35,97.09 90.56,98.3 90.56,102.93 89.85,103.64 89.85,104.61 89.34,105.11 89.34,105.86 89.75,106.27 v3(89.75,106.27)
  BOTTOM w0.076: v3(89.75,106.27) 90.04,105.99 U0300.AP5
  BOTTOM w0.229: CON1601.131 73.13,61.76 v2(74.71,60.18)
M_CHA_MAA4: length 67.1
  TOP w0.229: v2(73.59,59.42) 74.05,59.87 74.05,61.81 74.37,62.14 CON1600.128
  IN1 w0.159: v2(73.59,59.42) 74.05,59.88 74.05,60.12 73.22,60.96 73.22,62.18 71.72,63.68 71.72,67.4 71.56,67.56 71.09,67.56 70.93,67.72 70.93,68.04 71.09,68.19 71.56,68.19 71.72,68.35 71.72,74.54 89.01,91.83 89.01,97.37 v2(89.13,97.49)
  BOTTOM w0.076: 90.19,99.89 90.19,100.2 90.85,100.86 90.85,102.73 90.58,103 90.58,103.66 U0300.AP2
  BOTTOM w0.222: 90.19,99.89 89.92,99.63
  BOTTOM w0.229: v2(73.59,59.42) 73.59,58.57 73.46,58.44 72.92,58.44 72.72,58.64 72.72,58.92 72.51,59.13 72.2,59.13 71.82,58.75 71.82,58.07 72.38,57.52 CON1601.128 ; 89.92,99.63 89.45,99.63 88.84,99.01 88.84,97.79 v2(89.13,97.49)
M_CHA_MAA5: length 64.4
  TOP w0.229: v2(73.46,60.05) 73.46,62.04 73.82,62.39 73.82,63.65 73.87,63.71 CON1600.126
  IN1 w0.159: v3(90.15,100.77) 90.15,99.43 88.7,97.98 88.7,92.23 71.22,74.75 71.22,70.65 70.43,69.86 70.43,66.03 71.22,65.24 71.22,63.47 72.72,61.97 72.72,60.1 72.49,59.87 72.49,59.7 72.7,59.49 72.9,59.49 v2(73.46,60.05)
  BOTTOM w0.076: v3(90.15,100.77) 90.62,101.23 90.62,102.63 90.2,103.05 U0300.AP1
  BOTTOM w0.229: CON1601.126 71.88,57.55 71.49,57.94 71.49,58.88 72.66,60.05 v2(73.46,60.05)
M_CHA_MAA6: length 68.7
  TOP w0.229: v2(70.87,61.09) 71.01,61.09 72.21,59.9 72.21,59.5 74.12,57.58 CON1600.127
  IN1 w0.159: v3(90.15,101.33) 89.83,101.33 89.74,101.23 89.74,99.74 86.87,96.87 86.87,92.53 68.56,74.21 68.56,70.62 68.4,70.46 68.16,70.46 68,70.3 68,69.98 68.16,69.83 68.4,69.83 68.56,69.67 68.56,69.35 68.4,69.19 68.16,69.19 68,69.03 68,68.71 68.16,68.56 68.4,68.56 68.56,68.4 68.56,68.08 68.4,67.92 68.16,67.92 68,67.76 68,67.44 68.16,67.29 68.4,67.29 68.56,67.13 68.56,66.81 68.4,66.65 68.16,66.65 68,66.49 68,66.17 68.16,66.02 68.4,66.02 68.56,65.86 68.56,65.3 69.72,64.14 69.72,62.72 70.87,61.56 v2(70.87,61.09)
  BOTTOM w0.076: v3(90.15,101.33) 89.68,101.79 89.68,104.27 89.99,104.58 90.09,104.58 U0300.AP3
  BOTTOM w0.229: CON1601.127 72.13,63.86 70.9,62.63 70.9,62.2 71.22,61.88 71.63,61.88 71.79,61.72 71.79,61.25 71.63,61.09 v2(70.87,61.09)
M_CHA_MAA7: length 69.8
  TOP w0.229: v2(72.28,61.72) 72.03,61.46 71.82,61.46 71.59,61.7 71.59,62.68 72.09,63.18 72.34,63.18 72.74,62.78 73.08,62.78 73.3,62.99 73.3,63.43 72.87,63.85 CON1600.122
  IN1 w0.159: v2(87.46,94.29) 87.46,96.76 87.63,96.93 87.98,96.93 88.18,96.73 88.18,92.42 70.72,74.96 70.72,70.86 69.93,70.07 69.93,65.82 70.72,65.03 70.72,63.19 72.19,61.72 v2(72.28,61.72)
  BOTTOM w0.076: U0300.AN1 91.08,103.25 91.08,100.32 90.7,99.94 90.7,99.69
  BOTTOM w0.089: 90.7,99.69 90.7,99.63
  BOTTOM w0.229: 90.7,99.63 90.7,98.21 87.46,94.98 v2(87.46,94.29) ; CON1601.122 70.88,58.74 72.77,60.63 72.77,61.26 72.31,61.72 v2(72.28,61.72)
M_CHA_MAA8: length 68.3
  TOP w0.229: CON1600.125 73.62,57.47 71.63,59.46 71.63,59.95 71.12,60.46 v2(70.87,60.46)
  IN1 w0.159: v3(90.11,101.99) 89.38,101.99 89.29,101.9 89.29,99.94 86.34,96.99 86.34,92.71 67.5,73.86 67.5,73.35 67.66,73.19 67.9,73.19 68.06,73.03 68.06,72.71 67.9,72.55 67.66,72.55 67.5,72.39 67.5,72.08 67.66,71.92 67.9,71.92 68.06,71.76 68.06,71.44 67.9,71.28 67.66,71.28 67.5,71.12 67.5,65.65 69.21,63.93 69.21,62.51 70.11,61.62 70.11,60.97 70.62,60.46 v2(70.87,60.46)
  BOTTOM w0.076: v3(90.11,101.99) 89.88,102.22 89.88,104.17 90.07,104.35 90.6,104.35 U0300.AN3
  BOTTOM w0.229: v2(70.87,60.46) 70.59,60.46 70.38,60.68 70.38,62.69 71.63,63.93 CON1601.125
M_CHA_MAA9: length 66.6
  TOP w0.229: CON1600.121 72.62,57.89 70.11,60.4 70.11,60.61 v2(69.41,61.31)
  IN1 w0.159: v2(69.41,61.31) 69.41,61.61 68.71,62.3 68.71,63.73 67,65.44 67,74.07 85.88,92.96 85.88,97.22 88.96,100.3 88.96,101.92 89.45,102.41 89.45,104.45 v3(88.89,105.01)
  BOTTOM w0.076: U0300.AT4 88.57,105.34 v3(88.89,105.01)
  BOTTOM w0.229: v2(69.41,61.31) 69.76,60.96 69.95,60.96 70.02,61.03 70.02,61.93 69.91,62.04 69.47,62.04 69.27,62.23 69.27,62.58 70.63,63.93 CON1601.121
M_CHA_MAA10: length 66.4
  TOP w0.229: CON1600.146 80.87,63.96 79.31,62.39 79.31,60.35 80.08,59.57 v2(80.12,59.57)
  IN1 w0.076: 95.26,99.84 95.37,99.94 95.37,103.34 v3(96.39,104.37)
  IN1 w0.159: 95.26,99.84 95.26,97.77 96.73,96.3 96.73,91.4 96.39,91.06 96.39,87.45 85.89,76.94 85.89,76.3 81.67,72.08 81.31,72.08 80.84,71.6 80.84,65.22 81.06,65 81.06,62.51 81.04,62.48 81.04,60.23 80.38,59.57 v2(80.12,59.57)
  BOTTOM w0.076: v3(96.39,104.37) 95.83,104.37 95.5,104.04 U0300.AH2
  BOTTOM w0.229: CON1601.146 78.88,57.4 77.72,58.55 77.72,59.13 77.93,59.34 79.89,59.34 v2(80.12,59.57)
M_CHA_MAA11: length 68.4
  TOP w0.229: v2(72.28,60.92) 71.91,60.92 71.26,61.56 71.26,62.82 72.37,63.93 CON1600.120
  IN1 w0.159: v2(87.46,93.63) 87.51,93.58 87.51,92.45 70.22,75.16 70.22,73.79 70.06,73.63 69.22,73.63 69.06,73.47 69.06,73.15 69.22,73 70.06,73 70.22,72.84 70.22,72.52 70.06,72.36 69.22,72.36 69.06,72.2 69.06,71.88 69.22,71.73 70.06,71.73 70.22,71.57 70.22,71.17 70.1,71.05 69.37,71.05 69.2,70.87 69.2,70.51 69.43,70.27 69.43,65.61 70.22,64.82 70.22,62.98 v2(72.28,60.92)
  BOTTOM w0.076: 91.27,99.63 91.27,103.71 U0300.AN2
  BOTTOM w0.229: v2(72.28,60.92) 72.28,60.9 70.38,58.99 CON1601.120 ; v2(87.46,93.63) 87.9,93.63 91.27,97 91.27,99.63
M_CHA_MAA12: length 68.2
  TOP w0.229: v2(69.42,59.82) 69.15,59.55 69.15,59.33 69.31,59.17 70.69,59.17 72.12,57.74 CON1600.119
  IN1 w0.159: v2(69.42,59.82) 68.95,59.82 67.13,61.65 67.13,63.07 65.31,64.89 65.31,74.63 85.1,94.42 85.1,97.44 87.24,99.59 87.24,102.55 86.76,103.03 86.76,104.48 v3(87.28,105)
  BOTTOM w0.076: v3(87.28,105) 87.35,105 U0300.AU4
  BOTTOM w0.229: v2(69.42,59.82) 68.94,60.31 68.94,62.75 70.13,63.93 CON1601.119
M_CHA_MAA13: length 70.9
  TOP w0.229: v2(82,60.48) 82.33,60.82 82.33,61.24 83.87,62.78 CON1600.158
  IN1 w0.159: v2(82,60.48) 82.13,60.61 82.13,61.18 82.56,61.62 82.56,65.63 82.36,65.83 82.36,70.58 84.96,73.19 85.48,73.19 91.72,79.42 91.72,79.63 91.33,80.02 91.33,80.26 91.69,80.62 91.91,80.62 92.3,80.23 92.53,80.23 92.75,80.45 92.75,80.68 92.36,81.07 92.36,81.29 92.59,81.51 92.81,81.51 93.2,81.13 93.43,81.13 93.65,81.35 93.65,81.58 93.26,81.96 93.26,82.19 93.49,82.41 93.71,82.41 94.1,82.02 94.32,82.02 94.55,82.25 94.55,82.47 94.16,82.86 94.16,83.09 94.38,83.31 94.61,83.31 95,82.92 95.22,82.92 95.45,83.15 95.45,83.37 95.06,83.76 95.06,83.98 95.28,84.21 95.51,84.21 95.9,83.82 96.12,83.82 96.34,84.05 96.34,84.27 95.96,84.66 95.96,84.88 96.82,85.74 97.74,85.74 97.98,85.99 97.98,91.14 97.73,91.4 97.73,96.36 96.07,98.01 96.07,100.94 96.57,101.45 v3(96.87,101.45)
  BOTTOM w0.076: v3(96.87,101.45) 97.03,101.45 97.15,101.57 97.15,101.83 97.43,102.11 97.43,104.37 U0300.AE3
  BOTTOM w0.229: v2(82,60.48) 82,60.56 82.16,60.72 82.43,60.72 82.59,60.56 82.59,59.86 82.34,59.6 82.34,58.09 81.88,57.62 CON1601.158
M_CHA_MAA14: length 70.7
  TOP w0.229: v2(81.97,61.88) 81.95,61.88 81.53,61.46 81.53,60.12 82.12,59.53 CON1600.151
  IN1 w0.076: 95.82,102.87 95.82,103.04 96.96,104.18 96.96,105.4 96.73,105.64 v3(96.39,105.64)
  IN1 w0.159: 95.82,102.87 95.82,97.91 97.48,96.26 97.48,86.49 97.23,86.24 96.61,86.24 90.61,80.25 90.61,80.03 91,79.64 91,79.41 90.78,79.19 90.55,79.19 90.17,79.58 89.94,79.58 89.72,79.35 89.72,79.13 90.11,78.74 90.11,78.52 89.88,78.29 89.66,78.29 89.27,78.68 89.04,78.68 88.82,78.46 88.82,78.23 88.96,78.09 89.21,77.84 89.21,77.62 88.98,77.39 88.76,77.39 88.37,77.78 88.15,77.78 87.92,77.56 87.92,77.33 88.31,76.94 88.31,76.72 88.08,76.5 87.86,76.5 87.47,76.88 87.25,76.88 86.97,76.6 86.97,76.45 87.26,76.16 87.26,75.73 86.28,74.75 85.76,74.75 85.46,74.45 85.46,73.93 85.22,73.69 84.75,73.69 81.84,70.78 81.84,65.64 82.06,65.42 82.06,61.97 v2(81.97,61.88)
  BOTTOM w0.076: v3(96.39,105.64) 96.09,105.34 U0300.AG4
  BOTTOM w0.229: CON1601.151 80.13,63.8 80.38,63.55 80.38,63.17 80.38,63.17 80.52,63.03 81.29,63.03 81.46,62.86 81.46,62.51 81.35,62.4 80.92,62.4 80.78,62.27 80.78,62.06 81.29,61.55 81.62,61.55 81.95,61.88 v2(81.97,61.88)
M_CHA_MAA15: length 72.5
  TOP w0.229: v2(81.18,58.45) 81.46,58.73 81.46,59.49 81.2,59.76 81.2,62.1 81.59,62.49 82.43,62.49 83.37,63.44 CON1600.156
  IN1 w0.159: v2(96.84,98.94) 96.4,98.94 96.32,98.86 96.32,98.11 97.97,96.46 97.97,91.65 98.48,91.14 98.48,85.47 97.84,84.83 97.62,84.83 97.21,85.24 97.02,85.24 96.75,84.97 96.75,84.84 97.17,84.42 97.17,84.16 92.74,79.73 92.4,79.73 92.22,79.55 92.22,79.21 85.69,72.68 85.23,72.68 84.88,72.34 84.88,71.87 84.42,71.41 83.89,71.41 82.86,70.37 82.86,69.35 83.06,69.14 83.06,68.71 82.86,68.51 82.86,66.04 83.06,65.83 83.06,61.41 82.63,60.98 82.63,59.83 82.35,59.55 82.35,59.2 81.86,58.71 81.44,58.71 v2(81.18,58.45)
  BOTTOM w0.076: 98.63,100.02 98.63,103.24 U0300.AD1
  BOTTOM w0.229: CON1601.156 81.37,57.59 82.01,58.23 82.01,59.67 81.88,59.8 81.57,59.8 81.44,59.67 81.44,58.71 v2(81.18,58.45) ; 98.63,100.02 98.63,99.14 98.43,98.94 98.13,98.94 97.9,99.17 97.9,99.6 97.72,99.78 97.44,99.78 97.29,99.63 97.29,99.12 97.11,98.94 v2(96.84,98.94)
M_CHA_MAA16: length 67.2
  TOP w0.229: CON1600.152 82.37,63.74 80.87,62.24 80.87,58.95 v2(80.63,58.71)
  IN1 w0.076: 95.58,102.9 95.58,103.03 96.76,104.21 96.76,104.66 96.41,105.01 v3(96.39,105.01)
  IN1 w0.159: 95.58,102.9 95.58,97.81 96.98,96.41 96.98,87.32 86.39,76.74 86.39,76.09 81.34,71.04 81.34,65.43 81.56,65.21 81.56,62.34 81.54,62.32 81.54,59.64 80.63,58.73 v2(80.63,58.71)
  BOTTOM w0.076: v3(96.39,105.01) 95.56,105.01 U0300.AH4
  BOTTOM w0.229: CON1601.152 80.37,57.53 79.86,58.05 79.21,58.05 78.98,58.28 78.98,58.48 79.13,58.63 80.55,58.63 v2(80.63,58.71)
M_CHA_ODT0: length 74.3
  TOP w0.184: CON1600.155 83.12,58.08 v2(83.09,58.12)
  IN1 w0.076: v3(98.88,104.35) 98.63,104.11 98.63,103.83 98.22,103.42 98.22,100.6 98.36,100.46
  IN1 w0.127: 98.36,100.46 98.36,100.29 99.58,99.07 99.85,99.07 102.89,96.03 102.89,91.81 102.34,91.27 102.34,82.97 93.68,74.3 93.41,74.3 91.51,72.41 90.87,72.41 90.56,72.1 90.56,71.57 87.36,68.37 87.36,65.71 86.91,65.26 86.91,61.75 87.68,60.97 87.68,58.79 88.21,58.26 89.18,58.26 91.05,56.39 91.05,55.87 90.65,55.47 88.1,55.47 87.46,54.84 84.79,54.84 84.55,55.07 83.18,55.07 82.49,55.75 82.49,57.52 v2(83.09,58.12)
  BOTTOM w0.076: v3(98.88,104.35) 98.82,104.35 98.49,104.69 U0300.AD3
M_CHA_ODT1: length 74.1
  TOP w0.184: v2(85.58,60.56) 85.96,60.18 85.96,59.44 84.62,58.11 CON1600.161
  IN1 w0.076: 97.69,99.63 97.63,99.68 97.63,99.83 97.36,100.1 97.36,101.95 97.21,102.11 v3(96.86,102.11)
  IN1 w0.127: 97.69,99.63 101.67,95.65 101.67,92.65 100.56,91.53 100.56,84.61 88.68,72.74 88.68,72.63 88.8,72.5 88.8,72.27 88.67,72.13 88.56,72.13 88.4,72.3 88.24,72.3 87.53,71.59 87.53,71.41 87.65,71.29 87.65,71.11 87.52,70.98 87.34,70.98 87.22,71.1 87.05,71.1 85.94,70 85.94,69.82 86.06,69.7 86.06,69.52 85.94,69.4 85.76,69.4 85.64,69.52 85.46,69.52 85.14,69.2 85.14,60.33 85.08,60.28 85.08,59.75 86.32,58.52 86.32,57.54 86.53,57.32 87.31,57.32 87.46,57.18 87.46,56.92 87.36,56.83 86.46,56.83 86.32,56.68 86.32,56.35 86.46,56.2 87.6,56.2 87.89,56.48 87.89,57.36 86.82,58.43 86.82,58.63 85.95,59.5 85.95,60.4 85.79,60.56 v2(85.58,60.56)
  BOTTOM w0.076: v3(96.86,102.11) 97.25,102.49 97.25,104.84 U0300.AE4
M_CHA_ODT2: length 75.2
  IN1 w0.076: v3(96.82,100.87) 97.14,100.87 97.2,100.81 97.2,100.03 97.45,99.78 97.45,99.63
  IN1 w0.127: v2(84.08,60.03) 84.08,59.12 83.85,58.89 83.85,58.63 84.06,58.42 84.67,58.42 84.81,58.28 84.81,58.03 84.69,57.91 84.06,57.91 83.94,57.78 83.94,57.53 84.06,57.4 85.21,57.4 85.35,57.26 85.35,57 85.24,56.89 84.06,56.89 83.94,56.77 83.94,56.31 84.18,56.06 85.16,56.06 85.29,56.2 85.77,56.2 85.88,56.31 85.88,57.45 85.39,57.94 85.39,58.62 84.65,59.35 84.65,60.62 84.71,60.68 84.71,69.38 100.12,84.79 100.12,91.41 101.45,92.74 101.45,95.51 97.45,99.52 97.45,99.63
  BOTTOM w0.076: U0300.AE1 97.95,103.18 97.95,101.6 97.22,100.87 v3(96.82,100.87)
  BOTTOM w0.184: CON1601.155 81.13,63.65 83.99,60.78 84.36,60.78 84.74,60.39 84.74,59.84 84.48,59.58 84.19,59.58 84.08,59.69 v2(84.08,60.03)
M_CHA_ODT3: length 77.9
  IN1 w0.076: 98.17,100.18 98.17,100.39 98.06,100.5 98.06,103.49 98.47,103.9 98.47,104.92 98.55,105 v3(98.89,105)
  IN1 w0.127: 98.17,100.18 99.67,98.67 99.94,98.67 102.67,95.94 102.67,91.9 101.91,91.14 101.91,84.07 101.5,83.65 101.5,83.44 101.77,83.16 101.77,83.01 101.5,82.74 101.32,82.74 101.05,83.02 100.87,83.02 100.69,82.84 100.69,82.66 100.97,82.38 100.97,82.2 100.79,82.02 100.61,82.02 100.33,82.3 100.15,82.3 99.97,82.12 99.97,81.94 100.25,81.66 100.25,81.48 100.07,81.31 99.89,81.31 99.61,81.58 99.43,81.58 99.25,81.4 99.25,81.22 99.53,80.95 99.53,80.77 99.35,80.59 99.17,80.59 98.89,80.86 98.71,80.86 98.53,80.68 98.53,80.51 98.81,80.23 98.81,80.05 98.63,79.87 98.45,79.87 98.17,80.15 97.99,80.15 97.81,79.97 97.81,79.79 98.09,79.51 98.09,79.33 97.91,79.15 97.73,79.15 97.45,79.43 97.27,79.43 97.09,79.25 97.09,79.07 97.37,78.79 97.37,78.61 97.19,78.43 97.01,78.43 96.73,78.71 96.55,78.71 96.37,78.53 96.37,78.35 96.65,78.07 96.65,77.89 96.47,77.71 96.29,77.71 96.01,77.99 95.83,77.99 95.66,77.81 95.66,77.63 95.93,77.35 95.93,77.17 95.75,76.99 95.57,76.99 95.3,77.27 95.12,77.27 94.94,77.09 94.94,76.91 95.21,76.63 95.21,76.45 95.04,76.27 94.86,76.27 94.58,76.55 94.4,76.55 94.22,76.37 94.22,76.19 94.5,75.91 94.5,75.73 94.32,75.55 94.14,75.55 93.86,75.83 93.68,75.83 93.5,75.65 93.5,75.47 93.78,75.2 93.78,75.02 93.6,74.84 93.43,74.84 93.15,75.12 92.96,75.12 92.76,74.91 92.76,74.75 92.9,74.61 92.9,74.43 92.72,74.25 92.54,74.25 92.4,74.39 92.24,74.39 92.01,74.16 92.01,73.98 92.15,73.84 92.15,73.66 91.97,73.48 91.79,73.48 91.65,73.62 91.47,73.62 91.28,73.44 91.28,73.3 91.46,73.12 91.46,72.97 91.34,72.84 90.69,72.84 90.13,72.28 90.13,71.75 86.93,68.55 86.93,65.89 86.47,65.43 86.47,61.57 87.25,60.79 87.25,60.58 87.18,60.51 v2(86.8,60.51)
  BOTTOM w0.076: v3(98.89,105) 98.89,105.16 98.71,105.34 U0300.AD4
  BOTTOM w0.184: v2(86.8,60.51) 86.8,61.05 86.21,61.64 84.29,61.64 83.76,62.17 83.76,62.33 84.35,62.93 84.35,63.09 84.14,63.3 83.98,63.3 83.37,62.69 83.27,62.69 82.63,63.33 CON1601.161
M_CHA_PAR: length 70.6
  TOP w0.229: v2(78.75,63.21) 78.45,63.21 78.28,63.04 78.28,57.92 78.12,57.76 CON1600.143
  IN1 w0.076: v3(94.63,100.98) 94.32,100.98 94.25,100.91 94.25,99.98
  IN1 w0.159: 94.25,99.98 94.25,97.23 94.87,96.61 94.87,95.85 95.02,95.7 95.45,95.7 95.61,95.53 95.61,95.21 95.46,95.06 95.02,95.06 94.87,94.9 94.87,94.41 95,94.28 95.4,94.28 95.55,94.13 95.55,93.81 95.38,93.65 94.44,93.65 94.16,93.37 94.16,92.99 94.31,92.85 95.13,92.85 95.3,92.68 95.3,92.29 95.17,92.16 94.51,92.16 94.38,92.03 94.38,88.28 79.16,73.06 79.16,72.82 78.16,71.82 78.16,65.07 79.05,64.17 79.05,63.51 v2(78.75,63.21)
  BOTTOM w0.076: U0300.AG3 95.83,104.82 95.65,104.82 95.57,104.75 95.57,104.44 95.48,104.35 95.1,104.35 94.91,104.17 94.91,103.15 95.37,102.69 95.37,100.5 95.3,100.43 95.19,100.43 v3(94.63,100.98)
  BOTTOM w0.229: CON1601.143 76.13,63.89 76.31,63.71 76.66,63.71 76.97,64.02 76.97,65.5 77.1,65.63 77.46,65.63 77.7,65.39 77.7,63.96 77.96,63.71 78.26,63.71 v2(78.75,63.21)
M_CHB_ACT#: length 87
  TOP w0.229: v2(65.31,48.62) 65.31,49.79 65.59,50.07 69.25,50.07 70.87,51.7 CON1700.114
  IN4 w0.076: v3(89.1,108.92) 89.41,108.6 89.41,107.48 88.47,106.54 88.47,103.9
  IN4 w0.159: v2(65.31,48.62) 64.61,49.32 64.61,49.83 64.27,50.18 64.27,62.7 63.94,63.03 63.94,77.49 82.91,96.46 82.91,97.09 86.37,100.54 86.37,101.8 88.47,103.9
  BOTTOM w0.076: v3(89.1,108.92) 88.9,108.92 U0300.AT9
  BOTTOM w0.229: v2(65.31,48.62) 65.97,47.96 67.11,47.96 68.88,46.2 CON1701.114
M_CHB_ALERT#: length 82.3
  TOP w0.229: CON1700.116 71.37,50.98 70.14,49.74 69.68,49.74 68.83,48.89 v2(68.83,48.43)
  IN4 w0.076: 89.02,102 89.02,102.25 89.84,103.08 89.84,104.8 90.16,105.12 90.16,107.04 90.32,107.2 90.32,107.77 89.95,108.15 v3(89.95,108.25)
  IN4 w0.159: 89.02,102 89.02,100.6 84.16,95.74 84.16,95.17 65.74,76.75 65.74,70.93 66.2,70.46 66.2,50.79 67.3,49.69 67.3,49.1 67.96,48.43 v2(68.83,48.43)
  BOTTOM w0.076: U0300.AR8 89.79,108.25 v3(89.95,108.25)
  BOTTOM w0.229: CON1701.116 69.38,47.28 68.83,47.82 v2(68.83,48.43)
M_CHB_BA0: length 87.5
  TOP w0.229: CON1700.150 81.87,51.85 80.88,50.86 v2(80.88,48.14)
  IN4 w0.076: 95.85,99.7 95.85,104.03 95.81,104.08 95.81,107.77 95.44,108.14 v3(95.44,108.27)
  IN4 w0.159: 95.85,99.7 95.79,99.64 95.79,96.65 96.87,95.57 96.87,89.7 96.52,89.35 96.29,89.35 95.84,89.81 95.61,89.81 95.39,89.58 95.39,89.36 95.84,88.9 95.84,88.68 95.62,88.45 95.4,88.45 94.94,88.91 94.72,88.91 94.49,88.68 94.49,88.46 94.95,88 94.95,87.78 94.72,87.55 94.5,87.55 94.04,88.01 93.82,88.01 93.59,87.78 93.59,87.56 94.05,87.1 94.05,86.88 93.82,86.66 93.6,86.66 93.14,87.11 92.92,87.11 92.69,86.89 92.69,86.66 93.15,86.21 93.15,85.98 92.93,85.76 92.7,85.76 92.25,86.21 92.02,86.21 91.8,85.99 91.8,85.76 92.25,85.31 92.25,85.08 92.03,84.86 91.8,84.86 91.35,85.32 91.12,85.32 90.9,85.09 90.9,84.87 91.35,84.41 91.35,84.19 83.35,76.18 83.35,69.11 82.35,68.11 82.35,62.28 82.63,62 82.63,57.72 80.75,55.84 80.75,50.81 81.03,50.53 81.03,48.95 80.88,48.8 v2(80.88,48.14)
  BOTTOM w0.076: v3(95.44,108.27) 95.3,108.27 U0300.AH8
  BOTTOM w0.229: CON1701.150 79.88,46.05 79.43,46.49 79.43,46.92 79.86,47.35 80.47,47.35 80.88,47.76 v2(80.88,48.14)
M_CHB_BA1: length 86.4
  TOP w0.229: v2(79.59,49.2) 79.59,46.59 80.62,45.56 CON1700.145
  IN4 w0.076: 95.37,103.29 95.36,103.31 95.36,104.3 95.47,104.41 95.47,106.82 95.07,107.22 95.07,108.55 v3(95.44,108.92)
  IN4 w0.159: v2(79.59,49.2) 79.86,49.2 80.02,49.36 80.02,50.11 79.74,50.39 79.74,56.26 81.63,58.14 81.63,59.4 81.06,59.96 81.06,61.3 80.98,61.37 80.98,62.24 81.35,62.61 81.35,68.53 81.97,69.14 81.97,71.36 82.35,71.74 82.35,77.96 83.35,78.96 83.58,78.96 83.92,78.62 84.15,78.62 84.37,78.84 84.37,79.07 84.03,79.41 84.03,79.64 84.25,79.86 84.47,79.86 84.82,79.52 85.05,79.52 85.27,79.74 85.27,79.96 84.92,80.31 84.92,80.54 85.15,80.76 85.37,80.76 85.72,80.41 85.94,80.41 86.17,80.64 86.17,80.86 85.82,81.21 85.82,81.43 86.05,81.66 86.27,81.66 86.62,81.31 86.84,81.31 87.07,81.54 87.07,81.59 87.07,81.76 86.72,82.11 86.72,82.33 86.94,82.56 87.17,82.56 87.52,82.21 87.74,82.21 87.97,82.43 87.97,82.66 87.62,83.01 87.62,83.23 87.84,83.46 88.07,83.46 88.41,83.11 88.64,83.11 88.86,83.33 88.86,83.56 88.52,83.9 88.52,84.13 95.87,91.48 95.87,95.71 95.29,96.3 95.29,99.85 95.37,99.94 95.37,103.29
  BOTTOM w0.076: U0300.AH9 95.3,108.92 v3(95.44,108.92)
  BOTTOM w0.229: v2(79.59,49.2) 79.56,49.2 79.07,49.69 79.07,50.45 78.89,50.63 78.13,50.63 77.91,50.85 77.91,51.33 78.08,51.49 78.5,51.49 78.63,51.62 CON1701.145
M_CHB_BG0: length 84.7
  TOP w0.229: v2(66.66,48.93) 66.66,48.85 68.29,47.21 69.6,47.21 71.12,45.69 CON1700.115
  IN4 w0.076: v3(89.95,108.92) 89.58,108.55 89.58,107.01 89.22,106.65 89.22,105.47 89.26,105.43 89.26,103.58 88.99,103.31 88.69,103.31 88.45,103.06
  IN4 w0.159: v2(66.66,48.93) 66.55,48.82 65.93,48.82 65.12,49.64 65.12,50.04 64.77,50.39 64.77,62.91 64.44,63.24 64.44,77.29 87.48,100.33 87.48,102.1 88.45,103.06
  BOTTOM w0.076: U0300.AR9 89.82,108.92 v3(89.95,108.92)
  BOTTOM w0.229: CON1701.115 69.13,51.4 v2(66.66,48.93)
M_CHB_BG1: length 84.9
  TOP w0.229: CON1700.113 70.62,45.53 69.51,46.64 68.06,46.64 67.03,47.67 66.5,47.67 65.98,48.18 v2(65.98,49.51)
  IN4 w0.076: 88.69,101.58 88.73,101.62 88.73,102.22 89.68,103.17 89.68,105.24 89.38,105.54 89.38,106.53 89.95,107.09 v3(89.95,107.62)
  IN4 w0.159: 88.69,101.58 88.69,100.83 64.94,77.08 64.94,69.57 65.31,69.21 65.31,68.89 64.94,68.53 64.94,68.25 65.31,67.89 65.31,67.62 64.94,67.26 64.94,67.02 65.2,66.76 65.2,66.49 64.94,66.23 64.94,66.01 65.1,65.85 65.25,65.85 65.41,65.69 65.41,65.37 65.25,65.21 65.1,65.21 64.94,65.05 64.94,64.74 65.1,64.58 65.25,64.58 65.41,64.42 65.41,64.1 65.25,63.94 65.1,63.94 64.94,63.78 64.94,63.44 65.41,62.98 65.41,62.67 65.27,62.53 65.27,62.24 65.41,62.11 65.41,61.78 65.27,61.64 65.27,61.23 65.41,61.09 65.41,60.75 65.27,60.61 65.27,60.23 65.41,60.09 65.41,59.69 65.27,59.55 65.27,59.08 65.41,58.95 65.41,58.54 65.27,58.4 65.27,50.6 65.98,49.89 v2(65.98,49.51)
  BOTTOM w0.076: U0300.AR7 89.82,107.62 v3(89.95,107.62)
  BOTTOM w0.229: v2(65.98,49.51) 66.45,49.51 68.63,51.69 CON1701.113
M_CHB_CKE0: length 81.9
  TOP w0.184: v2(64.01,47.81) 65.11,47.81 66.09,46.82 66.65,46.82 67.75,45.72 69.4,45.72 69.62,45.5 CON1700.109
  IN4 w0.076: v3(89.04,108.29) 89.04,108.16 88.57,107.69
  IN4 w0.127: v2(64.01,47.81) 64.01,47.45 63.8,47.24 63.46,47.24 63.27,47.42 63.27,49.34 62.73,49.89 62.73,55.47 62.07,56.13 62.07,65.25 62.59,65.77 62.59,77.86 85.52,100.78 85.52,102.68 87.72,104.88 87.72,106.63 88.57,107.48 88.57,107.69
  BOTTOM w0.076: U0300.AT8 88.92,108.29 v3(89.04,108.29)
M_CHB_CKE1: length 82.3
  TOP w0.184: v2(62.74,49.13) 63.72,50.1 64.43,50.1 65.24,50.91 69.07,50.91 69.87,51.71 CON1700.110
  IN4 w0.076: 87.67,106.95 87.67,107.06 88.68,108.07 88.68,109.21 v3(89.04,109.57)
  IN4 w0.127: 87.67,106.95 85.17,104.45 85.17,100.74 82.93,98.5 82.62,98.5 62.16,78.04 62.16,65.95 61.64,65.43 61.64,55.95 62.3,55.29 62.3,49.58 v2(62.74,49.13)
  BOTTOM w0.076: U0300.AT10 88.71,109.25 v3(89.04,109.57)
M_CHB_CKE2: length 82.5
  IN4 w0.127: v2(63.8,49.55) 63.16,50.18 63.16,55.64 62.5,56.3 62.5,58.69 62.63,58.82 63.04,58.82 63.16,58.94 63.16,59.2 63.04,59.32 62.63,59.32 62.5,59.45 62.5,59.7 62.63,59.83 63.04,59.83 63.16,59.96 63.16,60.21 63.04,60.34 62.63,60.34 62.5,60.47 62.5,60.72 62.63,60.85 63.04,60.85 63.16,60.97 63.16,61.23 63.04,61.36 62.63,61.36 62.5,61.48 62.5,61.74 62.63,61.86 63.04,61.86 63.16,61.99 63.16,62.24 63.04,62.37 62.63,62.37 62.5,62.5 62.5,62.75 62.63,62.88 63.04,62.88 63.16,63.01 63.16,63.26 63.04,63.39 62.63,63.39 62.5,63.51 62.5,63.77 62.63,63.9 63.04,63.9 63.16,64.02 63.16,64.28 63.04,64.4 62.63,64.4 62.5,64.53 62.5,64.78 62.63,64.91 63.04,64.91 63.16,65.04 63.16,77.82 85.86,100.51 85.86,102.55 88.21,104.9 88.21,106.79 v3(89.04,107.62)
  BOTTOM w0.076: v3(89.04,107.62) 88.9,107.62 U0300.AT7
  BOTTOM w0.184: CON1701.109 67.63,51.51 66.52,50.4 64.65,50.4 v2(63.8,49.55)
M_CHB_CKE3: length 81.8
  IN4 w0.076: 87.71,107.39 88.51,108.19 88.51,109.7 v3(89.04,110.22)
  IN4 w0.127: v2(62.71,48.44) 61.87,49.28 61.87,53.25 61.21,53.91 61.21,65.61 61.73,66.13 61.73,78.21 84.89,101.38 84.89,104.57 87.71,107.39
  BOTTOM w0.076: v3(89.04,110.22) 88.9,110.22 U0300.AT11
  BOTTOM w0.184: v2(62.71,48.44) 64.03,47.12 66.19,47.12 67.88,45.43 CON1701.110
M_CHB_CLK0: length 80
  TOP w0.108: v2(76.86,46.78) 76.7,46.61 76.3,46.61 76.07,46.38 76.07,45.94 76.62,45.38 CON1700.137
  IN4 w0.076: 92.53,99.63 92.53,99.64 92.52,99.66 92.52,105.09 92.85,105.42 92.85,106.51 92.33,107.02 92.33,108.6 92.25,108.68 92.25,108.76 92.41,108.92 v3(92.69,108.92)
  IN4 w0.102: v2(76.86,46.78) 76.47,46.38 76.27,46.38 75.86,45.97 75.48,45.97 75.42,46.03 75.42,48.29 75.02,48.68 75.02,49.77 73.28,51.52 73.28,53.83 73.15,53.96 73.15,58 74.25,59.1 74.25,62.13 73.38,63 73.38,76.1 89.77,92.48 89.77,94.04 89.96,94.23 92.12,94.23 92.58,94.69 92.58,99.47 92.53,99.51 92.53,99.63
  BOTTOM w0.102: v3(92.69,108.92) 92.56,108.92 U0300.AM9
M_CHB_CLK0#: length 80
  TOP w0.108: v2(76.86,46.14) 76.61,46.39 76.39,46.39 76.29,46.29 76.29,46.03 76.69,45.63 76.87,45.63 77.12,45.38 CON1700.139
  IN4 w0.076: 92.29,99.63 92.29,99.64 92.36,99.71 92.36,105.16 92.68,105.49 92.68,106.44 92.17,106.96 92.17,108.53 v3(91.78,108.92)
  IN4 w0.102: 92.29,99.63 92.29,99.41 92.34,99.37 92.34,94.79 92.02,94.47 89.86,94.47 89.53,94.14 89.53,92.58 73.14,76.2 73.14,62.9 74.01,62.03 74.01,59.2 72.9,58.1 72.9,53.86 73.03,53.73 73.03,51.42 74.78,49.67 74.78,48.58 75.18,48.19 75.18,45.93 75.38,45.73 75.96,45.73 76.37,46.14 v2(76.86,46.14)
  BOTTOM w0.102: U0300.AN9 91.58,108.6 91.78,108.8 v3(91.78,108.92)
M_CHB_CLK1: length 81.7
  TOP w0.108: v2(75.7,49.29) 76.11,49.7 77.47,49.7 77.58,49.81 77.58,51.02 76.87,51.73 CON1700.138
  IN4 w0.076: 92.79,99.63 92.79,99.64 92.71,99.73 92.71,105.01 93.22,105.52 93.22,107.48 92.92,107.78 92.83,107.78 v3(92.7,107.65)
  IN4 w0.102: 92.79,99.63 92.79,94.59 92.12,93.92 90.73,93.92 90.3,93.5 90.3,92.3 73.89,75.88 73.89,75.54 74.43,74.99 74.43,74.57 74.33,74.47 74.13,74.47 73.89,74.23 73.89,73.62 74.13,73.38 74.33,73.38 74.44,73.27 74.44,72.87 74.33,72.77 74.13,72.77 73.89,72.52 73.89,71.92 74.13,71.67 74.33,71.67 74.44,71.57 74.44,71.17 74.33,71.07 74.13,71.07 73.89,70.82 73.89,70.22 74.13,69.97 74.33,69.97 74.44,69.87 74.44,69.47 74.33,69.36 74.13,69.36 73.89,69.12 73.89,68.51 74.13,68.27 74.33,68.27 74.43,68.17 74.43,65.86 74.33,65.76 74.13,65.76 73.89,65.52 73.89,64.91 74.13,64.67 74.33,64.67 74.43,64.56 74.43,64.16 74.33,64.06 74.12,64.06 73.89,63.82 73.89,63.21 74.14,62.96 74.69,62.96 75.11,62.54 75.11,59.84 75.01,59.74 75.01,58.44 74.77,58.2 74.07,58.2 73.65,57.79 73.65,55.83 74.49,54.99 74.49,54.56 74.07,54.15 74.07,53.59 74.47,53.2 74.47,52.76 74.3,52.6 74.09,52.6 73.78,52.3 73.78,51.73 75.91,49.6 75.91,49.5 v2(75.7,49.29)
  BOTTOM w0.076: v3(92.7,107.65) 92.59,107.65 U0300.AM7
M_CHB_CLK1#: length 81.7
  TOP w0.108: CON1700.140 77.37,51.54 77.81,51.11 77.81,49.71 77.56,49.47 76.5,49.47 v2(76.31,49.29)
  IN4 w0.076: 93.03,99.63 93.03,99.64 92.87,99.8 92.87,104.94 93.38,105.45 93.38,107.56 v3(92.71,108.23)
  IN4 w0.102: v2(76.31,49.29) 76.16,49.44 76.16,49.7 74.02,51.83 74.02,52.2 74.19,52.36 74.4,52.36 74.71,52.66 74.71,53.3 74.31,53.69 74.31,54.05 74.73,54.46 74.73,55.09 73.89,55.93 73.89,57.69 74.17,57.96 74.87,57.96 75.25,58.34 75.25,59.64 75.36,59.74 75.36,62.64 74.79,63.2 74.24,63.2 74.13,63.31 74.13,63.72 74.22,63.81 74.43,63.81 74.67,64.06 74.67,64.66 74.43,64.91 74.23,64.91 74.13,65.01 74.13,65.42 74.23,65.52 74.43,65.52 74.67,65.76 74.67,68.27 74.43,68.51 74.23,68.51 74.13,68.61 74.13,69.02 74.23,69.12 74.43,69.12 74.68,69.37 74.68,69.97 74.43,70.21 74.23,70.21 74.13,70.32 74.13,70.72 74.23,70.82 74.43,70.82 74.68,71.07 74.68,71.67 74.43,71.92 74.23,71.92 74.13,72.02 74.13,72.42 74.23,72.53 74.43,72.53 74.68,72.77 74.68,73.37 74.43,73.62 74.23,73.62 74.13,73.72 74.13,74.13 74.23,74.23 74.43,74.23 74.67,74.47 74.67,75.09 74.13,75.64 74.13,75.78 90.54,92.2 90.54,93.4 90.83,93.68 92.22,93.68 93.03,94.49 93.03,99.63
  BOTTOM w0.076: v3(92.71,108.23) 92.33,108.23 92.24,108.14 U0300.AM8
M_CHB_CLK2: length 81.3
  IN4 w0.076: 93.33,103.09 93.21,103.2 93.21,104.79 93.76,105.33 93.76,107.68 93.24,108.2 93.24,109.81 93.03,110.02 92.9,110.02 v3(92.69,110.22)
  IN4 w0.102: v2(75.94,50.79) 76.21,51.06 76.21,51.78 75.48,52.51 75.48,55.4 74.64,56.24 74.64,56.64 76,57.99 76,58.73 76.35,59.08 76.35,60.7 76.1,60.94 76.1,62.95 75.42,63.63 75.42,65.79 75.52,65.89 76,65.89 76.24,66.13 76.24,66.74 76,66.98 75.52,66.98 75.42,67.09 75.42,67.49 75.52,67.59 76,67.59 76.24,67.84 76.24,68.44 76,68.69 75.52,68.69 75.42,68.79 75.42,69.19 75.52,69.3 76,69.3 76.24,69.54 76.24,70.14 76,70.39 75.52,70.39 75.42,70.49 75.42,70.9 75.52,71 76,71 76.24,71.24 76.24,71.85 76,72.09 75.52,72.09 75.42,72.19 75.42,72.6 75.52,72.7 76,72.7 76.24,72.94 76.24,73.55 76,73.79 75.52,73.79 75.42,73.89 75.42,74.3 75.52,74.4 76,74.4 76.24,74.64 76.24,75.25 76,75.49 75.52,75.49 75.42,75.59 75.42,76.02 91.4,91.99 91.4,92.22 93.48,94.31 93.48,99.83 93.33,99.98 93.33,103.09
  BOTTOM w0.076: v3(92.69,110.22) 92.56,110.22 U0300.AM11
  BOTTOM w0.108: CON1701.137 74.63,51.79 74.45,51.62 74.45,51 74.91,50.55 75.43,50.55 75.67,50.79 v2(75.94,50.79)
M_CHB_CLK2#: length 81.3
  IN4 w0.076: 93.08,103.08 93.08,103.1 93.05,103.13 93.05,104.86 93.59,105.4 93.59,107.61 93.07,108.13 93.07,109.74 92.96,109.85 92.42,109.85 92.35,109.79 92.35,109.55 92.42,109.48 v3(92.69,109.48)
  IN4 w0.102: 93.08,103.08 93.08,99.88 93.24,99.73 93.24,94.41 91.15,92.32 91.15,92.09 75.18,76.12 75.18,75.49 75.42,75.25 75.9,75.25 76,75.15 76,74.74 75.9,74.64 75.42,74.64 75.18,74.4 75.18,73.79 75.42,73.55 75.9,73.55 76,73.45 76,73.04 75.9,72.94 75.42,72.94 75.18,72.7 75.18,72.09 75.42,71.85 75.9,71.85 76,71.75 76,71.34 75.9,71.24 75.42,71.24 75.18,71 75.18,70.39 75.42,70.15 75.9,70.15 76,70.04 76,69.64 75.9,69.54 75.42,69.54 75.18,69.29 75.18,68.69 75.42,68.44 75.9,68.44 76,68.34 76,67.94 75.9,67.83 75.42,67.83 75.18,67.59 75.18,66.99 75.42,66.74 75.9,66.74 76,66.64 76,66.23 75.9,66.13 75.42,66.13 75.18,65.89 75.18,63.53 75.86,62.85 75.86,60.84 76.1,60.6 76.1,59.18 75.76,58.83 75.76,58.09 74.4,56.74 74.4,56.14 75.24,55.3 75.24,52.41 75.95,51.7 75.95,51.54 v2(75.8,51.39)
  BOTTOM w0.076: v3(92.69,109.48) 92.56,109.61 92.36,109.61 92.24,109.48 U0300.AM10
  BOTTOM w0.108: v2(75.8,51.39) 75.62,51.21 75.62,51.06 75.33,50.77 75,50.77 74.68,51.1 74.68,51.51 75.13,51.96 CON1701.139
M_CHB_CLK3: length 82.7
  IN4 w0.076: 93.69,103.63 93.69,103.65 93.66,103.68 93.66,104.06 93.54,104.18 93.54,104.6 94.14,105.2 94.14,108.85 94.2,108.91 v3(94.55,108.91)
  IN4 w0.102: 93.69,103.63 93.69,103.43 93.77,103.35 93.77,100.17 94.01,99.93 94.01,94.2 93.31,93.5 93.31,93.08 92.23,92 92.23,91.77 77.06,76.59 77.06,76.11 77.22,75.95 78.06,75.95 78.3,75.71 78.3,75.1 78.06,74.86 77.28,74.86 77.18,74.76 77.18,74.35 77.29,74.25 78.06,74.25 78.3,74 78.3,73.05 77.06,71.81 77.06,71.34 77.54,70.87 77.54,69.7 77.3,69.46 77.1,69.46 76.99,69.35 76.99,68.96 77.1,68.85 77.3,68.85 77.54,68.6 77.54,64.76 77.3,64.52 76.26,64.52 76.17,64.43 76.17,64.03 76.29,63.91 77.19,63.91 77.55,63.54 77.55,58.48 75.74,56.67 75.74,56.42 76.56,55.6 76.56,52.49 76.96,52.09 76.96,48.37 v2(76.4,47.81)
  BOTTOM w0.076: U0300.AJ10 94.07,109.03 94.18,108.91 v3(94.55,108.91)
  BOTTOM w0.108: CON1701.138 74.88,45.68 76.9,47.71 76.9,48.05 76.81,48.14 76.72,48.14 v2(76.4,47.81)
M_CHB_CLK3#: length 82.7
  IN4 w0.076: 93.45,103.63 93.45,103.65 93.49,103.68 93.49,103.99 93.38,104.11 93.38,104.67 93.98,105.27 93.98,108.99 v3(94.55,109.56)
  IN4 w0.102: v2(76.36,48.42) 76.64,48.42 76.71,48.5 76.71,51.99 76.32,52.39 76.32,55.5 75.5,56.32 75.5,56.77 77.31,58.58 77.31,63.44 77.09,63.67 76.19,63.67 75.93,63.93 75.93,64.53 76.16,64.76 77.2,64.76 77.3,64.86 77.3,68.5 77.2,68.61 77,68.61 76.74,68.86 76.74,69.45 77,69.7 77.2,69.7 77.3,69.8 77.3,70.77 76.82,71.24 76.82,71.91 78.06,73.15 78.06,73.9 77.96,74.01 77.19,74.01 76.94,74.25 76.94,74.86 77.18,75.1 77.96,75.1 78.06,75.2 78.06,75.61 77.96,75.71 77.12,75.71 76.82,76.01 76.82,76.69 91.99,91.87 91.99,92.1 93.07,93.18 93.07,93.6 93.77,94.3 93.77,99.83 93.53,100.07 93.53,103.25 93.45,103.33 93.45,103.63
  BOTTOM w0.076: U0300.AJ11 94.4,109.56 v3(94.55,109.56)
  BOTTOM w0.108: CON1701.140 75.38,45.87 77.12,47.61 77.12,48.14 76.84,48.42 v2(76.36,48.42)
M_CHB_CS#0: length 77.9
  TOP w0.184: CON1700.149 81.62,46.13 81.15,46.6 v2(80.88,46.6)
  IN4 w0.076: v3(97.25,109.58) 97.8,109.03 97.8,107.47 97.85,107.42 97.85,103.83 98.19,103.49 98.19,99.63
  IN4 w0.127: 98.19,99.63 98.19,97.93 100.53,95.59 100.53,88.2 97.8,85.47 97.8,84.29 94.58,81.06 94.58,80.02 89.12,74.57 89.12,69.54 88.69,69.11 88.69,65.83 88.11,65.25 88.11,62.97 88.56,62.51 88.56,58.5 86.13,56.06 86.13,55.21 85.68,54.76 85.68,54.08 85.27,53.67 85.27,49.04 83.97,47.73 83.97,47.06 82.95,46.04 81.43,46.04 v2(80.88,46.6)
  BOTTOM w0.076: U0300.AF11 97.12,109.58 v3(97.25,109.58)
M_CHB_CS#1: length 80.8
  TOP w0.184: v2(85.71,50.48) 85.43,50.48 84.79,49.84 84.79,48.81 84.51,48.53 84.51,47.32 83.62,46.43 CON1700.157
  IN4 w0.076: v3(98.17,107.62) 98.17,106.78 98.01,106.62 98.01,103.9 98.38,103.53 98.38,99.65 98.41,99.63
  IN4 w0.127: 98.41,99.63 98.41,98.02 100.96,95.47 100.96,88.02 98.23,85.29 98.23,84.94 99.08,84.09 99.08,83.91 98.9,83.73 98.72,83.73 98.38,84.08 98.2,84.08 98.02,83.9 98.02,83.72 98.36,83.37 98.36,83.2 98.18,83.02 98,83.02 97.66,83.36 97.48,83.36 97.3,83.18 97.3,83 97.64,82.66 97.64,82.48 97.47,82.3 97.29,82.3 96.94,82.64 96.76,82.64 96.58,82.46 96.58,82.28 96.93,81.94 96.93,81.76 96.75,81.58 96.57,81.58 96.22,81.92 96.04,81.92 95.86,81.74 95.86,81.56 96.21,81.22 96.21,81.04 96.03,80.86 95.85,80.86 95.51,81.2 95.33,81.2 95.01,80.89 95.01,79.84 89.56,74.39 89.56,69.36 89.12,68.93 89.12,65.65 88.7,65.24 88.7,64.98 88.82,64.86 89.04,64.86 89.19,65.01 89.43,65.01 89.71,64.73 89.71,64.48 89.58,64.35 88.71,64.35 88.54,64.18 88.54,63.15 89,62.69 89,58.32 86.56,55.88 86.56,55.03 86.11,54.59 86.11,53.9 85.71,53.49 v2(85.71,50.48)
  BOTTOM w0.076: v3(98.17,107.62) 98.05,107.62 U0300.AE7
M_CHB_CS#2: length 82.2
  IN4 w0.076: 97.98,99.63 97.98,103.43 97.65,103.76 97.65,107.19 97.64,107.2 97.64,108.53 v3(97.25,108.92)
  IN4 w0.127: v2(83.42,48.4) 84.03,48.4 84.84,49.22 84.84,53.85 85.25,54.26 85.25,55.79 87.67,58.22 87.67,65.43 88.26,66.01 88.26,69.29 88.69,69.72 88.69,74.74 90.47,76.52 90.47,76.7 90.12,77.04 90.12,77.22 90.3,77.4 90.48,77.4 90.83,77.06 91.01,77.06 91.19,77.24 91.19,77.42 90.84,77.76 90.84,77.94 91.02,78.12 91.2,78.12 91.55,77.78 91.72,77.78 91.9,77.96 91.9,78.14 91.56,78.48 91.56,78.66 91.74,78.84 91.92,78.84 92.26,78.5 92.44,78.5 92.62,78.68 92.62,78.86 92.28,79.2 92.28,79.38 92.46,79.56 92.64,79.56 92.98,79.22 93.16,79.22 93.34,79.39 93.34,79.57 93,79.92 93,80.1 93.18,80.28 93.36,80.28 93.69,79.94 93.88,79.94 94.15,80.21 94.15,80.4 93.84,80.71 93.84,80.93 97.37,84.47 97.37,85.65 100.1,88.38 100.1,95.6 97.98,97.72 97.98,99.63
  BOTTOM w0.076: v3(97.25,108.92) 97.13,108.92 U0300.AF10
  BOTTOM w0.184: CON1701.149 79.63,51.25 81.57,49.31 81.97,49.31 82.88,48.4 v2(83.42,48.4)
M_CHB_CS#3: length 83.9
  IN4 w0.076: v3(98.18,109.57) 98.55,109.2 98.55,108.76 98.87,108.44 98.87,106.77 98.51,106.41 98.51,104.19 98.88,103.82 98.88,99.92 99.07,99.73
  IN4 w0.127: v2(84.98,47.52) 85.31,47.19 85.63,47.19 85.75,47.31 85.75,48.02 87,49.27 87,52.95 87.85,53.81 87.85,55.34 91.18,58.67 91.18,61.25 90.98,61.46 90.98,63.57 91.13,63.73 91.13,67.83 91.46,68.16 91.46,73.73 93,75.27 93,75.39 92.79,75.6 92.79,75.79 93.2,76.19 93.38,76.19 93.56,76.01 93.74,76.01 93.92,76.19 93.92,76.37 93.74,76.55 93.74,76.73 93.92,76.91 94.1,76.91 94.28,76.73 94.46,76.73 94.64,76.91 94.64,77.09 94.45,77.27 94.45,77.45 94.63,77.63 94.81,77.63 95,77.45 95.18,77.45 95.36,77.63 95.36,77.81 95.17,77.99 95.17,78.17 95.35,78.35 95.53,78.35 95.72,78.17 95.9,78.17 96.08,78.35 96.08,78.53 95.89,78.71 95.89,78.89 96.07,79.07 96.25,79.07 96.44,78.89 96.62,78.89 96.8,79.07 96.8,79.79 102.25,85.25 102.25,95.09 99.07,98.28 99.07,99.73
  BOTTOM w0.076: v3(98.18,109.57) 98.05,109.57 U0300.AE10
  BOTTOM w0.184: CON1701.157 81.63,51.79 82.27,51.14 82.65,51.14 85.45,48.33 85.45,47.78 85.19,47.52 v2(84.98,47.52)
M_CHB_DQ0: length 91.6
  TOP w0.165: v2(42.35,46.16) 42.52,46.16 43.12,45.56 CON1700.3
  IN4 w0.114: v2(69.93,108.95) 69.02,108.95 42.28,82.21 42.28,78.19 39.56,75.47 39.56,68.01 35.12,63.57 35.12,58.2 35.29,58.02 35.29,53.51 38.15,50.65 38.15,48.1 40.08,46.16 40.57,46.16 40.72,46.31 40.72,46.59 40.82,46.69 41.36,46.69 41.89,46.16 v2(42.35,46.16)
  BOTTOM w0.076: U0300.BT11 74.28,109.73 73.15,109.73 72.96,109.53
  BOTTOM w0.165: v2(69.93,108.95) 70.53,108.95 70.99,109.4 72.83,109.4 72.96,109.53 ; CON1701.8 42.38,45.42 41.94,45.85 41.94,46.06 42.05,46.16 v2(42.35,46.16)
M_CHB_DQ1: length 93.1
  TOP w0.165: CON1700.7 44.12,45.98 43.29,46.81 v2(42.38,46.81)
  IN4 w0.114: v2(69.45,108.44) 69,108.44 42.62,82.07 42.62,78.05 39.9,75.33 39.9,67.87 35.46,63.43 35.46,58.34 35.64,58.16 35.64,53.65 38.49,50.8 38.49,48.24 39.19,47.54 41.65,47.54 42.38,46.82 v2(42.38,46.81)
  BOTTOM w0.076: 72.88,108.98 73.44,109.54 74.02,109.54 74.13,109.43 74.62,109.43 U0300.BR11
  BOTTOM w0.165: CON1701.4 41.38,46.63 41.56,46.81 v2(42.38,46.81) ; v2(69.45,108.44) 70.8,108.44 71.34,108.98 72.88,108.98
M_CHB_DQ2: length 95.4
  TOP w0.165: CON1700.21 47.62,45.74 47.3,46.06 46.97,46.06 46.43,46.61 46.43,47.24 45.37,48.29 v2(44.53,48.29)
  IN4 w0.114: v2(44.53,48.29) 44.53,48.92 42.6,50.86 42.6,51.94 41.65,52.88 41.3,52.88 37.6,56.57 37.6,59.18 37.43,59.36 37.43,62.61 41.87,67.06 41.87,74.08 42.21,74.41 42.37,74.41 42.78,74 42.94,74 43.11,74.16 43.11,74.32 42.69,74.74 42.69,74.9 42.85,75.06 43.01,75.06 43.43,74.65 43.59,74.65 43.75,74.81 43.75,74.97 43.34,75.38 43.34,75.55 43.5,75.71 43.66,75.71 44.08,75.29 44.24,75.29 44.4,75.45 44.4,75.62 43.98,76.03 43.98,76.19 44.59,76.8 44.59,81.18 65.27,101.86 65.89,101.86 67.72,103.69 67.72,104.56 70.66,107.5 v3(71.29,107.5)
  BOTTOM w0.076: U0300.BT8 73.37,108.03 73.06,107.72 72.19,107.72 71.97,107.5 v3(71.29,107.5)
  BOTTOM w0.165: CON1701.16 44.38,46.13 44.53,46.29 44.91,46.29 45.12,46.5 45.12,46.97 44.8,47.28 44.22,47.28 44.08,47.43 44.08,47.84 v2(44.53,48.29)
M_CHB_DQ3: length 93.8
  TOP w0.165: CON1700.17 46.62,45.95 46.14,46.44 46.14,46.59 v2(44.96,47.76)
  IN4 w0.114: v3(71.74,107.98) 71.74,107.25 70.62,106.13 70.45,106.13 65.88,101.56 65.45,101.56 44.93,81.04 44.93,74.12 44.54,73.73 44.38,73.73 44.24,73.87 44.08,73.87 43.92,73.71 43.92,73.54 44.06,73.41 44.06,73.25 43.9,73.09 43.73,73.09 43.6,73.22 43.44,73.22 43.27,73.06 43.27,72.9 43.41,72.76 43.41,72.6 43.25,72.44 43.09,72.44 42.95,72.57 42.79,72.57 42.63,72.41 42.63,72.25 42.76,72.12 42.76,71.95 42.21,71.4 42.21,66.91 37.77,62.47 37.77,59.53 37.95,59.35 37.95,57.85 38.4,57.4 38.4,57.24 38.11,56.95 38.11,56.78 38.27,56.62 38.43,56.62 38.72,56.91 38.89,56.91 39.05,56.75 39.05,56.59 38.76,56.3 38.76,56.14 38.92,55.98 39.08,55.98 39.37,56.27 39.53,56.27 39.69,56.1 39.69,55.94 39.4,55.65 39.4,55.49 39.57,55.33 39.73,55.33 40.02,55.62 40.18,55.62 40.74,55.06 40.74,53.92 41.44,53.22 41.8,53.22 42.94,52.08 42.94,51 44.96,48.98 v2(44.96,47.76)
  BOTTOM w0.076: U0300.BR8 74.66,108.26 74.56,108.36 73.82,108.36 73.69,108.23 73.33,108.23 72.99,107.89 71.84,107.89 v3(71.74,107.98)
  BOTTOM w0.165: v2(44.96,47.76) 45.45,47.76 45.57,47.63 45.57,46.18 45.38,45.98 CON1701.20
M_CHB_DQ4: length 93.4
  TOP w0.165: v2(41.05,51.14) 43.11,51.14 43.37,51.4 CON1700.4
  IN4 w0.114: v3(72.4,109.84) 72.07,109.51 71.4,109.51 68.14,106.26 67.84,106.26 43.31,81.72 43.31,77.76 40.59,75.04 40.59,67.59 36.14,63.14 36.14,58.63 36.32,58.45 36.32,55.87 36.98,55.22 36.98,55.06 36.55,54.64 36.55,54.47 36.71,54.31 36.88,54.31 37.3,54.73 37.46,54.73 37.62,54.57 37.62,54.41 37.2,53.99 37.2,53.83 37.36,53.67 37.52,53.67 37.95,54.09 38.11,54.09 38.27,53.93 38.27,53.76 37.85,53.34 37.85,53.18 38.01,53.02 38.17,53.02 38.59,53.44 38.75,53.44 38.92,53.28 38.92,53.12 38.49,52.7 38.49,52.53 38.65,52.37 38.82,52.37 39.24,52.79 39.4,52.79 39.57,52.62 39.57,52.21 40.04,51.75 40.45,51.75 v2(41.05,51.14)
  BOTTOM w0.076: v3(72.4,109.84) 72.46,109.9 73.6,109.9 73.86,110.15 75.37,110.15 U0300.BP11
  BOTTOM w0.165: v2(41.05,51.14) 41.68,51.14 42.07,50.76 42.37,50.76 42.68,51.06 42.68,51.39 42.13,51.94 CON1701.7
M_CHB_DQ5: length 94.4
  TOP w0.165: v2(41.49,50.58) 43.88,50.58 44.37,51.08 CON1700.8
  IN4 w0.108: v3(73.22,110.27) 72.69,110.27
  IN4 w0.114: v2(41.49,50.58) 41.15,50.25 40.29,50.25 37.81,52.73 37.65,52.73 37.43,52.5 37.27,52.5 37.11,52.66 37.11,52.83 37.33,53.05 37.33,53.21 37.17,53.37 37.01,53.37 36.78,53.15 36.62,53.15 36.46,53.31 36.46,53.47 36.68,53.7 36.68,53.86 35.98,54.56 35.98,58.31 35.8,58.48 35.8,63.29 40.25,67.73 40.25,75.19 42.96,77.9 42.96,81.92 67.55,106.51 68.1,106.51 71.86,110.27 72.69,110.27
  BOTTOM w0.076: v3(73.22,110.27) 73.41,110.27 73.45,110.31 75.67,110.31 76.14,109.84 U0300.BN11
  BOTTOM w0.165: v2(41.49,50.58) 41.49,50.07 41.31,49.89 40.63,49.89 40.47,50.05 40.47,51.34 40.74,51.61 40.89,51.61 41.13,51.85 CON1701.3
M_CHB_DQ6: length 93
  TOP w0.165: CON1700.16 46.37,51.84 v2(44.53,49.99)
  IN4 w0.114: v2(44.53,49.99) 43.28,51.25 43.28,52.22 41.62,53.88 41.62,55.3 41.01,55.9 41.01,56.06 41.45,56.49 41.45,56.66 41.28,56.82 41.12,56.82 40.38,56.07 40.21,56.07 40.05,56.24 40.05,56.39 41.07,57.41 41.07,57.57 40.91,57.74 40.75,57.74 40.04,57.03 39.88,57.03 39.02,57.9 39.02,58.06 39.44,58.48 39.44,58.64 39.28,58.8 39.12,58.8 38.7,58.38 38.53,58.38 38.29,58.62 38.29,59.51 38.11,59.69 38.11,62.33 39.28,63.49 41.38,63.49 41.62,63.73 41.62,64.65 42.56,65.59 42.56,71.26 45.28,73.98 45.28,80.89 65.74,101.35 66.13,101.35 70.44,105.66 70.56,105.66 72.83,107.92 v3(72.83,108.27)
  BOTTOM w0.076: v3(72.83,108.27) 73.04,108.48 73.43,108.48 73.53,108.58 75.37,108.58 U0300.BP8
  BOTTOM w0.165: v2(44.53,49.99) 44.81,49.99 45.8,50.98 45.8,51.27 45.63,51.45 CON1701.21
M_CHB_DQ7: length 95.3
  TOP w0.165: v2(44.99,49.54) 44.99,49.21 45.15,49.05 45.39,49.05 45.52,49.19 45.52,50.42 46.73,51.64 47.1,51.64 47.37,51.92 CON1700.20
  IN4 w0.114: v3(73.28,108.85) 73.28,107.88 66.31,100.92 65.89,100.92 45.62,80.65 45.62,73.15 43.7,71.24 43.7,67.99 42.9,67.19 42.9,65.44 41.96,64.5 41.96,62.61 41.68,62.32 38.88,62.32 38.49,61.93 38.49,60.24 39.14,59.59 39.48,59.59 39.6,59.47 39.6,58.98 39.71,58.86 39.94,58.86 40.05,58.98 40.05,59.47 40.17,59.59 41.18,59.59 41.33,59.43 41.33,58.45 41.96,57.82 41.96,54.05 44.34,51.68 44.34,51.13 45.29,50.17 45.29,49.84 v2(44.99,49.54)
  BOTTOM w0.076: U0300.BN8 76.28,108.26 75.81,108.73 73.39,108.73 v3(73.28,108.85)
  BOTTOM w0.165: v2(44.99,49.54) 45.11,49.41 45.11,49 44.99,48.88 44.62,48.88 44.05,49.44 44.05,50.68 44.63,51.25 CON1701.17
M_CHB_DQ8: length 90.1
  TOP w0.165: v2(46.08,49.49) 47.4,49.49 49.37,51.47 CON1700.28
  IN4 w0.114: v2(46.08,49.49) 46.08,50.45 45.52,51.01 45.52,51.55 43.18,53.89 43.18,55.99 42.71,56.46 42.71,58.24 42.49,58.47 42.49,60.02 42.71,60.24 42.71,64.19 44.53,66.01 44.53,69.08 44.64,69.2 45.12,69.2 45.24,69.31 45.24,69.54 45.12,69.66 44.64,69.66 44.53,69.77 44.53,70 44.64,70.11 44.87,70.11 44.98,70.23 44.98,70.46 44.87,70.57 44.64,70.57 44.53,70.68 44.53,71 46.37,72.84 46.37,80.34 74.87,108.84 76.63,108.84 77.31,109.52 v3(77.31,110.23)
  BOTTOM w0.076: v3(77.31,110.23) 77.31,110.3 U0300.BL12
  BOTTOM w0.165: CON1701.25 46.63,51.59 46.78,51.44 47.02,51.44 47.23,51.23 47.23,50.84 46.82,50.43 46.38,50.43 45.85,49.9 45.85,49.72 v2(46.08,49.49)
M_CHB_DQ9: length 88.2
  TOP w0.165: CON1700.24 48.37,51.78 v2(46.55,49.96)
  IN4 w0.076: v3(78.11,110.22) 77.59,109.7 77.59,109.49 76.55,108.45 75.22,108.45 74.17,107.41 74.17,106.18 73.88,105.89 73.09,105.89 72.92,105.71 72.26,105.71 71.86,105.31 71.86,104.46 71.27,103.87 70.64,103.87
  IN4 w0.114: v2(46.55,49.96) 46.55,50.46 45.86,51.15 45.86,51.83 44.61,53.08 44.61,55.05 43.05,56.6 43.05,58.38 42.83,58.61 42.83,59.87 43.05,60.1 43.05,64.05 44.87,65.87 44.87,68.14 46.71,69.98 46.71,70.32 46.6,70.44 46.32,70.44 46.23,70.53 46.23,70.76 46.37,70.89 46.6,70.89 46.71,71.01 46.71,71.24 46.6,71.35 46.06,71.35 45.95,71.47 45.95,71.69 46.06,71.81 46.6,71.81 46.71,71.92 46.71,80.19 70.38,103.87 70.64,103.87
  BOTTOM w0.076: v3(78.11,110.22) 78.02,110.22 U0300.BL11
  BOTTOM w0.165: CON1701.29 47.62,50.68 46.91,49.96 v2(46.55,49.96)
M_CHB_DQ10: length 88.6
  TOP w0.165: v2(47.2,47.46) 47.84,47.46 49.62,45.67 CON1700.29
  IN4 w0.076: 72.03,104.24 72.03,105.24 72.33,105.54 72.98,105.54 73.16,105.72 73.95,105.72 74.63,106.41 74.63,106.61 75.98,107.96 76.61,107.96 v3(77.31,108.66)
  IN4 w0.108: 70.8,103 72.03,104.24
  IN4 w0.114: 70.8,103 70.01,103 47.05,80.05 47.05,69.84 45.21,68 45.21,65.73 43.4,63.91 43.4,59.95 43.17,59.73 43.17,58.75 43.4,58.53 43.4,56.74 44.95,55.19 44.95,53.51 47.07,51.39 47.07,49.01 46.79,48.72 46.14,48.72 46.03,48.61 46.03,47.81 46.38,47.46 v2(47.2,47.46)
  BOTTOM w0.076: v3(77.31,108.66) 77.31,108.59 U0300.BL8
  BOTTOM w0.165: v2(47.2,47.46) 46.9,47.46 46.46,47.02 46.46,45.84 46.38,45.76 CON1701.24
M_CHB_DQ11: length 88.7
  TOP w0.165: CON1700.41 52.62,45.49 50.96,47.15 v2(50.25,47.15)
  IN4 w0.076: 76.7,105.7 76.7,105.76 78.52,107.58 78.52,107.81 v3(78.98,108.27)
  IN4 w0.114: 76.7,105.7 76.7,104.55 73.62,101.47 72.89,101.47 72.05,100.64 71.02,100.64 51.01,80.62 51.01,77.25 49.36,75.6 49.36,66.55 46.82,64.01 46.82,62.75 46.2,62.13 46.2,59.36 46.53,59.04 46.53,58.16 48.33,56.36 48.33,53.12 49.65,51.8 49.65,51.03 50.51,50.17 50.51,47.89 50.4,47.79 49.99,47.79 49.87,47.91 49.87,48.11 49.68,48.29 49.21,48.29 49.1,48.18 49.1,47.26 49.21,47.15 v2(50.25,47.15)
  BOTTOM w0.076: U0300.BJ8 78.85,108.27 v3(78.98,108.27)
  BOTTOM w0.165: CON1701.38 49.88,45.58 49.44,46.02 49.44,47.06 49.54,47.15 v2(50.25,47.15)
M_CHB_DQ12: length 89.5
  TOP w0.165: CON1700.42 52.87,51.6 52.28,51.01 52.28,50.54 51.1,49.36 v2(50.1,49.36)
  IN4 w0.076: 77.1,106.78 77.34,107.02 77.49,107.02 78.17,107.7 78.17,107.93 78.44,108.21 78.44,108.49 78.61,108.66 78.61,109.2 v3(78.98,109.57)
  IN4 w0.114: 77.1,106.78 76.11,105.79 76.11,104.54 73.53,101.96 72.6,101.96 71.95,101.31 70.63,101.31 48.68,79.36 48.68,66.89 46.14,64.35 46.14,63.03 45.52,62.41 45.52,59.2 45.11,58.79 45.11,58.17 45.53,57.75 45.53,57.59 45.27,57.33 45.27,57.17 45.43,57.01 45.6,57.01 45.85,57.26 46.01,57.26 46.18,57.1 46.18,56.94 45.92,56.68 45.92,56.52 46.16,56.28 47,56.28 47.65,55.63 47.65,52.83 48.96,51.52 48.96,50.01 49.61,49.36 v2(50.1,49.36)
  BOTTOM w0.076: U0300.BJ11 78.85,109.57 v3(78.98,109.57)
  BOTTOM w0.165: v2(50.1,49.36) 50.5,49.36 50.62,49.49 50.62,50.17 50.38,50.42 50.38,50.86 50.62,51.1 CON1701.41
M_CHB_DQ13: length 88.2
  TOP w0.165: v2(50.1,50) 51.18,50 51.87,50.69 CON1700.38
  IN4 w0.076: v3(78.98,108.92) 78.98,108.79 78.61,108.42 78.61,108.14 78.35,107.88 78.35,107.65 76.31,105.61 76.31,105.39
  IN4 w0.114: 76.31,105.39 76.31,104.45 73.61,101.75 72.69,101.75 71.87,100.94 70.74,100.94 49.02,79.22 49.02,78.88 49.14,78.76 50.2,78.76 50.31,78.65 50.31,78.42 50.2,78.3 49.14,78.3 49.02,78.19 49.02,77.96 49.14,77.85 50.15,77.85 50.24,77.76 50.24,77.53 50.1,77.39 49.14,77.39 49.02,77.28 49.02,66.75 46.48,64.21 46.48,62.89 45.86,62.27 45.86,59.22 46.18,58.9 46.18,58.02 47.99,56.21 47.99,52.97 49.3,51.66 49.3,50.35 49.66,50 v2(50.1,50)
  BOTTOM w0.076: v3(78.98,108.92) 78.63,108.92 78.52,109.03 U0300.BJ10
  BOTTOM w0.165: CON1701.37 49.62,50.47 v2(50.1,50)
M_CHB_DQ14: length 87.9
  TOP w0.165: v2(46.9,46.82) 47.92,46.82 48.62,46.12 CON1700.25
  IN4 w0.076: v3(77.31,107.86) 77.2,107.75 76.03,107.75 75.25,106.98 75.25,106.82
  IN4 w0.114: 75.25,106.82 75.25,106.18 73.95,104.87 73.53,104.87 71.22,102.56 70.05,102.56 47.4,79.91 47.4,67.42 43.74,63.77 43.74,59.81 43.52,59.59 43.52,58.89 43.74,58.67 43.74,56.89 45.3,55.33 45.3,53.66 47.42,51.54 47.42,48.83 47.61,48.63 47.61,45.91 47.4,45.7 47.02,45.7 46.9,45.83 v2(46.9,46.82)
  BOTTOM w0.076: U0300.BL7 77.63,107.55 v3(77.31,107.86)
  BOTTOM w0.165: v2(46.9,46.82) 47.25,46.82 47.38,46.69 CON1701.28
M_CHB_DQ15: length 87
  TOP w0.165: v2(50.25,46.52) 50.94,46.52 51.62,45.83 CON1700.37
  IN4 w0.076: v3(78.98,107.62) 78.79,107.62 77.59,106.41 77.59,106.15
  IN4 w0.114: 77.59,106.15 77.59,105.15 73.38,100.95 72.91,100.95 72.3,100.34 71.21,100.34 51.35,80.48 51.35,77.11 49.71,75.46 49.71,66.41 47.16,63.87 47.16,58.01 48.68,56.5 48.68,53.55 50.48,51.74 50.48,50.69 50.94,50.22 50.94,45.61 50.76,45.42 49.46,45.42 49.26,45.63 49.26,46.29 49.49,46.52 v2(50.25,46.52)
  BOTTOM w0.076: v3(78.98,107.62) 78.85,107.62 U0300.BJ7
  BOTTOM w0.165: CON1701.42 50.88,45.89 v2(50.25,46.52)
