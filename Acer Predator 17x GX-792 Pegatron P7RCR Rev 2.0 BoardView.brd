# Allegro board Acer Predator 17x GX-792 Pegatron P7RCR Rev 2.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N145218718: length 2.8
  BOTTOM w0.508: U3103.1 276.39,53.32 276.68,53.04 SR3110.1 276.08,52.43 v1(275.7,52.05)
N145218847: length 6.5
  BOTTOM w0.254: v1(277.98,56.5) 278.41,56.07 278.41,55.58 277.97,55.13 R3169.1 276.78,55.13 276.28,55.63 274.76,55.63 274.49,55.9 U3103.4
N145280710: length 4.9
  TOP w0.102: U1101.W19 291.2,37.47 v5(291.5,37.17)
  BOTTOM w0.102: v5(291.5,37.17) 290.84,36.51 290.84,34.91 289.87,33.94 T1105.1
N145280722: length 3
  TOP w0.102: U1101.Y19 290.55,37.49 v5(290.86,37.17)
  BOTTOM w0.102: v5(290.86,37.17) 290.56,37.17 289.41,36.02 T1106.1
N145280742: length 4.1
  TOP w0.102: U1101.AC23 289.39,35.31 288.22,34.14 288.22,32.37 T1107.1
N145280776: length 2.1
  TOP w0.102: U1101.AB23 289.85,35.36 288.96,34.47 T1108.1
N145283752: length 5.1
  TOP w0.121: U1101.A23 299.6,35.6 300.1,35.6 300.76,34.94 302.52,34.94 303.54,33.92 T1109.1
N145283762: length 3.5
  TOP w0.121: U1101.B23 299.37,35.37 300.01,35.37 300.71,34.68 301.74,34.68 T1110.1
N145283804: length 1.5
  TOP w0.102: U1101.E18 297.7,38.16 298.01,37.85 v5(298.01,37.83)
  BOTTOM w0.102: v5(298.01,37.83) 298.83,37.83 T1111.1
N145283824: length 5.1
  TOP w0.102: v5(292.17,38.47) 291.85,38.15 U1101.V18
  BOTTOM w0.102: v5(292.17,38.47) 292.53,38.12 292.53,37.51 292.23,37.22 292.23,35.8 291.8,35.36 291.8,35.17 T1112.1
N145824487: length 4.5
  BOTTOM w0.102: R5017.2 283.22,105.76 283.15,105.82 U5003.1 283.15,107.89 283.34,108.08 v1(284.51,108.08)
N145830127: length 10.3
  TOP w0.254: R1242.2 293.33,68.26 v1(293.66,68.59)
  TOP w0.432: 288.33,67.8 Q1201.1 ; 288.33,67.8 288.84,67.29 290.94,67.29 291.56,67.91 Q1202.1 292.03,68.36 292.13,68.26 R1242.2 ; 288.33,67.8 288.33,67.79 287.85,67.3 285.85,67.3 R1243.2
N146002641:
  vias: v4(102.2,190.03) v4(102.98,189.59)
N148386775: length 13.6
  TOP w0.102: R3632.2 15.27,19.54 15.01,19.8 D3601.2 14.73,20.91 v2(14.2,21.43) ; U3600.4 7.74,25.65 v1(7.58,25.48) 7.22,25.13 v2(7.22,24.75)
  IN3 w0.102: v2(14.2,21.43) 13.33,21.43 12.81,21.95 10.01,21.95 v2(7.22,24.75)
N148484425: length 94.5
  TOP w0.102: v2(115.65,23.27) 120.9,23.27 121.16,23.54 121.16,26.71 121.16,26.88 121.65,27.36 122.15,27.36 122.51,27.01 122.51,26.72 123.11,26.12 130.43,26.12 134.95,30.64 137.56,30.64 138.8,31.88 v1(139.76,31.88) C5008.1 R5020.2 ; v2(86.47,21.06) 86.32,20.91 86.32,15.58 81.13,10.4 81.13,7.09 80.24,6.2 78.97,6.2 78.47,6.71 76.05,6.71 75.16,5.82 75.16,3.28 74.02,2.14 U5004.4
  IN1 w0.102: v2(115.65,23.27) 115.22,22.84 114.41,22.84 112.38,20.81 86.72,20.81 v2(86.47,21.06)
N148484463: length 8.8
  TOP w0.102: R5019.2 78.92,8.11 78.92,7.86 78.62,7.55 v1(78.44,7.55) 77.68,7.55 77.5,7.73 74.28,7.73 72.5,5.95 72.07,5.95
N148858017: length 8.1
  BOTTOM w0.102: U2000.BD7 238.74,67.14 239.13,67.14 239.31,67.31 239.31,68.29 239.92,68.91 239.92,69.51 239.66,69.78 239.66,71.92 v1(240.49,72.75) 240.7,72.96 R2165.1
N149219521: length 11.7
  BOTTOM w0.102: T5304.1 293.48,100.82 293.48,97.47 291.25,95.24 CON5300.15
N149219524: length 13.3
  BOTTOM w0.102: CON5300.19 292.25,95.86 293.73,97.34 293.73,102.34 T5305.1
N150816618: length 40.6
  BOTTOM w0.102: v1(51.03,17.25) 50.4,16.62 49.35,16.62 49.22,16.75 SR5108.2 48.16,16.2 48.16,12.22 46.21,10.27 39.73,10.27 39.48,10.01 38.84,10.01 38.39,10.47 34.83,10.47 34.65,10.65 33,10.65 32.37,10.01 32.37,6.97 32.75,6.59 43.29,6.59 43.5,6.8 CON5104.38
N150945327: length 6.1
  TOP w0.089: v3(112.09,124.63) 113.72,122.99 114.53,122.99 v1(114.84,122.69) 116.14,122.69 116.31,122.51 R0752.2
  BOTTOM w0.102: v3(112.09,124.63) 112.09,124.7 U0300.F30
N150945739: length 6.7
  TOP w0.089: v3(112.74,124.63) 113.49,123.88 113.49,123.62 113.85,123.25 115.33,123.25 115.93,123.86 116.06,123.86 v1(116.62,124.42) 116.8,124.24 R0753.2
  BOTTOM w0.102: v3(112.74,124.63) 112.74,124.7 U0300.E30
N151525704: length 2.8
  TOP w0.102: v1(295.56,47.61) 296.12,47.61 296.17,47.56 R1165.1 296.53,46.74 296.75,46.52 U1101.G1
N151529455: length 3.6
  TOP w0.102: R1166.1 289.01,47.73 v1(289.19,47.56) 289.52,47.23 289.82,47.23 290.77,46.28 U1101.Y1
N151529458: length 6.1
  TOP w0.102: U1101.Y2 290.54,45.58 290.54,46.14 289.66,47.02 288.02,47.02 R1167.1 286.62,48.42 v1(286.32,48.42)
N151530540: length 4.1
  TOP w0.102: v5(290.87,43.02) U1101.Y6
  BOTTOM w0.102: R1168.2 288.68,44.05 v1(288.98,44.36) 289.34,44.36 289.88,43.81 289.88,43.55 290.09,43.34 290.35,43.34 290.35,43.34 290.56,43.34 v5(290.87,43.02)
N151543889: length 4.6
  TOP w0.114: v5(290.87,43.67) 290.87,43.67 U1101.Y5
  BOTTOM w0.102: v5(290.87,43.67) 290.5,44.04 290.5,44.68 v1(290.73,44.91) 290.1,44.91 290.07,44.94 R1171.2
N151543892: length 9.1
  TOP w0.102: v5(293.46,44.34) U1101.R4
  BOTTOM w0.102: R1172.2 288.5,46.39 288.5,46.57 288.74,46.81 288.74,47.26 v1(288.96,47.48) 289.52,47.48 289.73,47.27 290.74,47.27 291.31,46.69 292.74,46.69 293.1,46.34 293.1,44.7 v5(293.46,44.34)
N151761859: length 9.9
  TOP w0.102: Q8807.2 266.17,31.45 266.43,31.2 ; 266.43,31.2 266.17,30.94 Q8807.5 ; 266.43,31.2 268.76,31.2 269.22,30.74 Q8806.3 269.22,29.01 v1(269.45,28.79) 270.64,28.79 R8838.2
N151944858: length 3
  TOP w0.102: v2(40.16,16.69) 40.93,16.69 41.53,16.09 U1501.10
  BOTTOM w0.102: v2(40.16,16.69) 39.96,16.49 R1515.1
N152086876: length 17.5
  BOTTOM w0.102: CON5100.6 17.75,14.85 19.82,16.92 29.88,16.92 30.44,16.36 32.82,16.36 R5131.1
N152092556: length 8.3
  TOP w0.102: C3616.1 9.56,21.67 8.66,20.78 8.66,20.77 8.66,20.76 v1(8.66,19.09)
  TOP w0.203: U3600.7 8.94,26.2 9.58,25.56 9.58,22.99 9.56,22.97 C3616.1
N152509786: length 3.9
  TOP w0.254: R3620.1 13.78,28.49 13.92,28.63 C3607.1 14.46,28.38 v2(15.07,27.77)
  BOTTOM w0.254: v2(15.07,27.77) v1(15.07,26.04)
N152557460: length 3.5
  BOTTOM w0.508: CON6701.1 19.49,85.93 19.16,86.27 17.81,86.27 v4(17,85.45)
  vias: v1(15.91,85.97)
N153744417: length 2.9
  TOP w0.102: R4604.1 299.68,106.18 v1(299.68,106.59) 299.68,106.98 299.18,107.47 U4601.21
N154168272: length 16.2
  TOP w0.102: CON4500.23 111.25,191.69 v2(110.98,191.95)
  IN1 w0.102: v2(117.33,191.24) 117.2,191.37 111.36,191.37 110.98,191.75 v2(110.98,191.95)
  BOTTOM w0.102: v1(116.62,191.24) v2(117.33,191.24) 118.34,192.26 R4595.2
N156034153: length 6.1
  BOTTOM w0.102: R4597.1 SR4506.2 ; R4597.1 112.02,182.63 112.02,182.48 v1(112.45,182.05) ; R4597.1 111.49,183.67 R4526.2 111.03,185.22 110.79,185.47 U4502.4
N156149773: length 3.9
  BOTTOM w0.457: v1(135.4,31.39) 135.64,31.39 136.2,31.95 R5710.2
  BOTTOM w0.508: R5710.2 136.63,30.47 Q5707.3
N156149860: length 3.1
  TOP w0.102: v1(18.27,56.12) R5713.2 19.38,57.02 19.54,57.18 Q5709.3
N156149939: length 4.2
  TOP w0.508: Q5710.3 119.64,7.7 118.73,8.62 R5714.2 v1(117.87,7.43)
N156150699: length 7.4
  TOP w0.102: R6746.2 3.41,52.48 3.51,52.59 C6714.1 3.98,53.23 4.14,53.08 IU203.4 5.6,53.08 6.13,53.6 8.92,53.6 v1(9.28,53.25)
N156150808: length 3.5
  TOP w0.102: C6713.1 R6745.2 ; C6713.1 2.95,57.26 3.43,56.79 IU202.4 ; C6713.1 2.39,58.05 v1(2.17,58.27)
N157253094: length 1.7
  BOTTOM w0.102: T4510.1 112.28,184.23 U4502.3
N157332139: length 5
  BOTTOM w0.508: R5717.2 272.51,99.56 v1(272.7,99.37) 273.89,99.37 274.14,99.13 274.14,98.47 274.35,98.25 Q5711.3
N157332227: length 4.2
  BOTTOM w0.102: R5718.2 v1(280.78,70.06) 280.78,69.32 281.18,68.92 281.18,68.13 281.49,67.82 Q5713.3
N157332809: length 8.6
  BOTTOM w0.102: R6008.1 18.58,64.84 19.71,63.72 R6009.1 19.71,63.08 21.62,61.17 21.62,58.43 v1(21.95,58.1)
N158267574:
  vias: v1(121.32,125.79)
N158267597: length 4.7
  TOP w0.102: U5701.2 204.37,135.69 204.28,135.61 SR5701.2 203.53,135.61 203.35,135.43 203.35,133.99 203.82,133.53 v1(203.82,132.85)
N158267601: length 5
  TOP w0.102: v1(209.2,138.31) R5704.2 207.74,137.79 Q5701.1 206.63,136.61 206.9,136.34 U5701.6
N158267609: length 99.2
  TOP w0.102: Q5702.1 124.12,133.52 125.56,132.09 129.67,132.09 134.63,137.04 134.63,140.67 v2(135.31,141.36) ; U5701.3 205.81,135.04 206.43,134.42 R5707.2 206.43,133.59 v1(205.7,132.85) 204.81,132.85 v2(204.58,133.08)
  IN1 w0.102: v2(204.58,133.08) 202.93,133.08 201.95,134.06 201.95,137.61 196.07,143.49 141.46,143.49 139.33,141.36 v2(135.31,141.36)
N158267622:
  vias: v1(203.77,136.61)
N158267624: length 8.1
  BOTTOM w0.102: Q5703.1 232.1,29.38 231.58,29.9 231.58,30.84 v1(232.14,31.4)
  BOTTOM w0.254: U5702.6 235.66,28.67 235.97,28.99 R5723.2 233.31,29.85 232.83,29.38 Q5703.1
N158267716: length 3.6
  BOTTOM w0.254: R5719.2 231.2,26.17 v1(231.12,26.25) 231.12,27.97 230.66,28.43 Q5703.3
N158446613: length 7.5
  TOP w0.102: Q2601.1 247.09,46.38 v1(247.66,46.95) 247.86,46.95 248.34,46.46 248.9,46.46 249.99,45.37 R2602.1 250.93,45.85 250.44,46.35 Q2602.3
N158446623: length 8.7
  TOP w0.102: Q2602.6 249.14,50.36 ; 249.14,50.36 249.33,50.55 249.66,50.55 249.79,50.43 Q2602.5 249.79,48.65 250.12,48.32 R2610.1 251.36,47.99 250.04,47.99 249.79,47.73 Q2602.2 ; 249.14,50.36 248.8,50.7 v1(248.8,50.91)
N158452428: length 10.5
  TOP w0.102: D2401.2 254.49,68.33 254.01,67.85 v1(252.99,67.85) 252.99,70.19 252.58,70.59 D2402.2 253.1,71.89 v2(253.5,72.3)
  BOTTOM w0.102: U2402.1 253.13,73.05 253.17,73.01 R2493.1 253.83,72.63 v2(253.5,72.3)
N158452468: length 6.8
  BOTTOM w0.102: v1(255.68,73.18) 255.76,73.11 255.76,72.24 254.9,72.24 254.9,72.78 R2494.1 254.34,72.68 254.34,72.52 253.68,71.86 252.71,71.86 251.84,72.73 U2402.2
N159319782: length 6
  TOP w0.102: T7501.1 171.18,111.23 170.57,110.63 170.57,109.76 170.24,109.43 170.24,107 v5(170.7,106.54)
  BOTTOM w0.17: v5(170.7,106.54) 170.66,106.54 U7000.P45
N159319784: length 2.2
  TOP w0.102: R7501.1 v1(170.01,105.49) 169.65,105.49 169.37,105.77 169.37,105.77 169.35,105.8 v5(169.35,105.8)
  BOTTOM w0.102: v5(169.35,105.8) 169.35,105.85 U7000.R44
N159319786: length 7.9
  TOP w0.102: v5(170.67,105.8) 170.01,106.46 170.01,109.89 v1(170.14,110.01) 170.14,110.67 170.64,111.18 170.64,111.97 R7506.1
  BOTTOM w0.102: U7000.P44 170.67,105.83 v5(170.67,105.8)
N159319788: length 9.8
  TOP w0.102: R7500.1 v1(170.68,114.28) 170.41,114.02 170.41,111.26 169.7,110.55 169.7,106.9 169.35,106.55 v5(169.35,106.5)
  BOTTOM w0.17: v5(169.35,106.5) 169.35,106.55 U7000.R45
N159417946: length 17.2
  IN3 w0.254: v2(129.96,72.03) 132.02,72.03 134.32,69.73 v2(135.21,69.73)
  BOTTOM w0.102: v2(135.21,69.73) 135.06,69.88 v1(134.58,69.88)
  BOTTOM w0.254: R7463.2 130.42,72.03 v2(129.96,72.03) ; SR7402.2 134.76,71.67 134.95,71.48 135.9,71.48 136.07,71.3 R7418.2 R7415.2 R7412.2 ; R7412.2 135.31,69.63 v2(135.21,69.73) ; R7412.2 R7401.2 R7422.2 136.94,68.31 138.39,68.31 R7421.2
N159418124: length 24.4
  TOP w0.254: v2(135.24,71.97) 135.95,71.97 v1(136.3,71.61) 135.74,71.05 135.74,68.92 134.32,67.49 134.32,64.27 134.77,63.82 v2(135.11,63.82)
  IN3 w0.254: v2(129.96,72.64) 132.88,72.64 133.56,71.97 v2(135.24,71.97)
  BOTTOM w0.254: R7462.2 130.64,72.64 v2(129.96,72.64) ; R7426.2 SR7401.2 133.56,72.12 133.68,72.23 134.87,72.23 135.13,71.97 v2(135.24,71.97) ; R7431.2 R7428.2 136.75,63.82 v2(135.11,63.82)
N159419345: length 22.2
  BOTTOM w0.254: 133.1,65.29 132.54,65.84 130.79,65.84 130.38,66.25 130.38,67.34 129.42,68.3 129.42,69.61 130.07,70.26 R7400.2
  BOTTOM w0.432: C7400.1 131.04,59.34 R74100.2 R74101.2 132.49,58.96 v1(132.87,58.58)
  BOTTOM w0.508: 132.29,63 U7401.7 ; 132.29,63 132.29,64.47 133.56,65.74 U7401.3 ; 132.29,63 131.44,63 131.02,62.58 U7401.8 131.02,60.61 131.5,60.13 C7400.1
N159432635: length 2.1
  TOP w0.102: Q7203.2 288.23,126.54 288.16,126.47 R7216.2 287.84,127.27 v1(287.69,127.42)
N159432637: length 2.1
  TOP w0.102: v1(287.69,123.79) 287.84,123.64 R7217.2 288.12,122.79 288.19,122.86 Q7202.2
N159432649: length 6
  TOP w0.102: Q7203.3 292.33,127.49 292.67,127.16 v1(292.67,126.17) 292.67,125.1 292.82,124.95 SR7208.2
N159432653: length 2.4
  TOP w0.102: SR7207.2 291.48,123.03 Q7202.3 291.48,124.74 v1(291.44,124.78)
N159618804: length 6.7
  TOP w0.102: 297.36,97.39 298.23,97.39 298.23,98.18 297.78,98.62 Q5300.1 297.28,98.62 295.71,100.18 v1(295.71,101.89)
N159618817: length 10.4
  TOP w0.102: R5301.1 R5302.1 296.78,95.79 295.94,96.63 Q5301.3 Q5302.3 292.11,93.68 v1(291.29,92.87)
N159618827:
  vias: v1(294.54,100.46)
N161419358: length 1
  TOP w0.254: R0900.1 96.54,123.36 v3(96.54,123.6)
N161419500: length 6.9
  TOP w0.089: v3(94.69,123.6) 94.69,123.99 v1(94.49,124.19)
  TOP w0.203: v3(94.69,123.6) 94.81,123.49 R0901.1
  BOTTOM w0.178: v3(94.69,123.6) 94.69,127.85 94.9,128.06 U0300.AH35 U0300.AH36
N161648505: length 5.5
  TOP w0.102: U1401.10 266.02,42.48 266.68,41.82 R1417.1 266.43,41.36 266.22,41.15 266.22,39.75 265.74,39.27 v1(265.74,38.82)
N161804128: length 4.8
  BOTTOM w0.102: v1(136.35,56.55) 137.22,57.41 137.22,58.07 137.34,58.2 SR7414.1 R7467.1 138.23,58.11 138.2,58.08 U7403.5
N161804129: length 4.9
  BOTTOM w0.102: SR7414.2 C7406.1 135.66,59.6 135.36,59.3 L7402.1 134.52,58.82 134.21,58.5 v1(134.21,57.45)
N161804130: length 9.2
  BOTTOM w0.102: 152,69.78 152.13,69.65 153.42,69.65 v1(154.13,70.37) ; 152,69.78 151.54,69.32 151.09,69.32 150.6,68.84 150.6,67.34 R7468.1 149.77,66.51 149.77,65.75 SR7413.1 ; 152,69.78 U7405.2
N161804131: length 3.2
  BOTTOM w0.102: v1(151.26,64.28) 151.09,64.46 SR7413.2 C7404.1 149.82,63.66 149.66,63.83 L7403.1
N161804140: length 5.5
  BOTTOM w0.102: v1(154.69,66.91) 154.24,66.45 152.58,66.45 152.43,66.3 SR7412.1 152.12,66.32 152.12,66.62 R7435.1 152,67.3 U7405.5
N161804142: length 3.5
  BOTTOM w0.102: v1(154.67,64.88) 153.85,64.07 L7404.1 153.61,64.78 C7402.1 SR7412.2
N161804191: length 3.8
  BOTTOM w0.102: v1(136.66,50.93) 137.31,51.58 SR7416.2 136.93,51.92 136.85,52 C7408.1 135.77,52 135.36,52.41 L7401.1
N161804205: length 4.2
  BOTTOM w0.102: v1(147.43,67.93) 147.75,68.24 U7408.6 148.64,67.25 R7455.2 148.93,67.42 149.29,67.79 U7408.5
N161804217: length 8.3
  TOP w0.102: U7407.5 141.84,72.52 R7453.2 ; R7453.2 141.19,72.29 U7407.6 ; R7453.2 141.22,73.14 141.22,73.91 140.84,74.29 140.48,74.29 140.16,73.97 140.16,73.18 140.07,73.09 139.91,73.09 v1(139.44,72.63) 139.44,72.19 139.5,72.13 Q7406.1
N161804239: length 5.9
  TOP w0.102: U7406.5 148.16,65.21 ; 148.16,65.21 147.52,64.57 147.1,64.57 146.87,64.35 146.87,63.71 v1(147.07,63.51) ; 148.16,65.21 R7450.2 149,64.99 148.81,65.18 U7406.6
N161804251: length 2.9
  BOTTOM w0.102: U7404.2 146.13,62.91 146.34,62.7 R7449.2 145.82,62.48 145.82,62.55 145.48,62.89 U7404.3
N162210915: length 0.5
  BOTTOM w0.305: v2(225.55,56.25) 225.88,56.58 U2000.V28
  vias: v1(227.49,55.96)
N162559558: length 4.6
  BOTTOM w0.102: U7409.5 149.59,49.18 R7485.2 ; U7409.6 148.94,49.05 148.77,48.89 R7485.2 ; R7485.2 149.74,47.4 v1(149.92,47.4)
N162559566: length 4.3
  BOTTOM w0.102: U7409.2 149.59,52.69 v1(150.35,53.45) 149.97,53.45 149.92,53.4 R7486.1 R7488.2 C7409.1
N162559590: length 6.3
  BOTTOM w0.102: v1(143.78,50.98) 143.78,51.28 R7490.2 145.07,51.29 146.44,51.29 146.54,51.39 U7410.5 146.54,52.69 146.72,52.87 146.99,52.87 147.19,52.67 U7410.6
N162559628: length 6.5
  TOP w0.102: v1(143.5,57.37) 143.87,57.74 D7403.3 143.87,60.61 R7493.1 143.84,60.94 143.5,61.28 143.5,62.37 143.85,62.72 U7414.2
N162559639: length 7.8
  TOP w0.102: R7494.1 144.56,67.29 144.76,67.09 U7415.2 144.76,64.54 144.38,64.16 144.03,64.16 143.84,63.97 143.03,63.97 142.68,63.61 142.68,63.39 142.56,63.27 D7406.3 142.56,61.78 v1(142.83,61.5)
N162560797: length 6.2
  BOTTOM w0.102: U7412.4 146.3,57.77 146.59,57.48 146.59,56.84 146.24,56.5 U7413.2 145.24,56.5 144.93,56.18 144.93,55.79 144.62,55.48 144.13,55.48 143.57,54.92 v1(143.57,54.64)
N162560813: length 3.4
  BOTTOM w0.102: U7412.1 145,61.06 144.53,61.53 R7497.2 143.89,61.53 143.88,61.51 R7496.2 143.39,61.03 v1(143.81,60.61)
N163464731: length 6.2
  BOTTOM w0.102: v1(276.84,90.56) 277.83,90.56 278.09,90.81 Q5304.3 279,91.09 279.76,91.85 280.85,91.85 281.16,92.16 D5302.2
N163464848: length 9
  BOTTOM w0.102: v1(276.87,88.78) 277.86,89.77 279.89,89.77 280.93,90.81 Q5303.3 282.3,91.68 283.06,92.44 D5301.2
N165544422: length 7.5
  TOP w0.102: R3107.1 R3106.1 Q3102.2 Q3102.5 49.1,125.97 v1(49.89,126.75)
N166665556: length 13.9
  TOP w0.102: v1(144.98,56.34) 144.16,56.34 143.99,56.17 R74110.1 143.49,56.55 R74109.2 142.53,58.07 143.11,58.66 143.11,59.99 143.3,60.18 143.3,62.45 143.53,62.68 143.53,63.65 143.64,63.76 143.93,63.76 144.12,63.95 144.46,63.95 144.96,64.46 144.96,65.51 145.41,65.96 U7415.1
N166670701: length 7
  BOTTOM w0.102: U2302.2 241.28,42.91 241.4,42.8 241.82,42.8 241.93,42.91 U2302.3 241.93,43.79 242.17,44.03 242.88,44.03 R2323.2 243.82,43.72 244.61,42.93 v1(244.61,41.38)
N166730741: length 3
  BOTTOM w0.102: v1(239.43,26.32) 239.43,26.7 238.99,27.13 SR5706.2 238.59,27.5 238.47,27.62 238.47,27.9 238.35,28.02 U5702.2
N166730840: length 4.1
  TOP w0.102: SR5705.2 205.38,134.16 v2(205.75,134.53) ; U5701.5 v2(206.46,135.69)
  IN1 w0.102: v2(205.75,134.53) 205.75,134.98 v2(206.46,135.69)
  BOTTOM w0.102: v1(205.75,133.84) v2(205.75,134.53)
N167209788: length 5
  TOP w0.076: U1201.G2 294.24,55.95 294.24,55.6 293.96,55.32
  TOP w0.102: R1218.2 292.41,52.69 292.5,52.78 292.5,53.18 v1(292.89,53.58) 293.16,53.84 293.36,53.84 293.96,54.45 293.96,55.32
N168273177: length 4
  BOTTOM w0.102: CON5300.32 295.5,100.28 295.74,100.51 v1(295.74,101.89)
  BOTTOM w0.305: CON5300.32 295.5,98.14 v2(295.61,98.03)
N169179480:
  vias: v1(307.09,115.98)
N169179550: length 16.8
  TOP w0.102: v1(302.22,122.94) 302.22,122.33 v2(302.42,122.13) R4610.1
  IN1 w0.102: v2(302.42,122.13) 302.42,121.17 304.43,119.16 311.08,119.16 312.2,120.28 312.2,122.11 CON4601.14
N169508413: length 3.4
  TOP w0.254: U1302.1 277.49,87.04 277.67,87.22 R1305.1 277.17,88.47 SR1301.2
N169508430: length 3.9
  TOP w0.254: D1301.1 278.54,88.88 278.34,89.08 277.91,89.08 277.67,89.33 R1305.2 277.01,89.81 276.63,90.19 v1(276.63,90.79)
N169508447: length 6.8
  TOP w0.102: C1321.1 281.16,86.91 281.75,87.5 D1301.2 ; C1321.1 280.6,86.01 280.52,86.09 U1302.5 ; C1321.1 281.74,85.43 v1(281.74,84.08)
N169891946: length 3.1
  BOTTOM w0.102: v1(150.27,22.92) 150.01,23.18 SR0701.2 148.76,22.87 147.89,22.87 147.7,23.06 U0703.1
N169897673: length 4.4
  TOP w0.102: R5810.2 T5801.1 302.11,137.32 301.75,136.96 U5800.10
N169898604: length 2.1
  TOP w0.102: T5802.1 306.99,137.04 R5809.2 R5811.1
N170005185: length 1.7
  BOTTOM w0.508: v1(199.83,59.14) 199,58.31 R5730.1
N170005191: length 84.1
  IN3 w0.102: v2(197.57,20.38) 200.19,20.38 203.53,23.72 205.53,23.72 206.58,24.77 214.51,24.77 214.84,24.44 221.29,24.44 223.68,22.05 226.7,22.05 229.95,25.31 235.18,25.31 236.56,26.68 v2(236.66,26.68)
  BOTTOM w0.102: U5702.3 237.3,27.37 237.09,27.16 237.09,26.37 R5727.2 236.79,26.55 v2(236.66,26.68) ; v2(197.57,20.38) 196.48,21.47 196.48,29.65 199.27,32.44 199.27,34.7 197.97,36 197.97,37.95 199.78,39.75 199.78,44.33 200.87,45.42 200.87,49.41 200.26,50.02 200.26,51.8 200.83,52.37 Q5704.1 v1(201.05,53.86)
N170005288: length 2.4
  BOTTOM w0.102: v1(234.07,29.14) SR5707.2 234.62,28.11 234.71,28.02 U5702.5
N170416463:
  vias: v1(13.11,63.38) v2(13.85,63.35)
N170576321: length 3.6
  TOP w0.102: R5022.2 128.06,29.45 128.17,29.33 Q5002.1 ; R5022.2 v1(127.67,30.84) ; R5022.2 SR5001.2
N170953750: length 6.1
  TOP w0.102: R1245.2 296.7,72.14 R1246.1 ; v1(296.83,69.48) 297.14,69.78 297.14,71.36 296.96,71.53 R1246.1 ; U1202.12 294.99,71.8 295.36,71.43 C1202.1 296.2,71.03 R1246.1
N170953788: length 4.1
  TOP w0.102: v1(289.44,74.23) 289.74,74.53 290.99,74.53 291.22,74.3 R1209.2 291.88,74.07 292.26,73.69 U1202.6
N170953790: length 6.4
  TOP w0.102: U1202.7 292.36,73.19 292.21,73.03 R1210.2 291.14,72.78 290.96,72.6 290.02,72.6 289.85,72.42 289.85,71.86 289.67,71.69 289.67,71.3 290.13,70.85 v1(290.18,70.85) R1248.2
N170953816: length 4.1
  TOP w0.102: U1202.8 291.66,72.69 R1212.2 291.14,71.89 291.8,71.23 292.31,71.23 v1(292.61,70.92)
N170953891: length 3.5
  TOP w0.102: U1202.16 296.18,74.19 R1208.1 297.14,74.18 297.9,74.18 v1(298.43,73.64)
N170953893: length 1.1
  TOP w0.102: R1207.1 296.25,73.77 296.17,73.69 U1202.15
N170963974: length 14.8
  TOP w0.102: U1202.5 292.78,74.19 v2(291.8,75.17) R1238.2
  BOTTOM w0.102: v2(291.8,75.17) 297.39,75.17 298.05,75.83 304.02,75.83 v1(304.2,75.65)
N170981753: length 3.9
  TOP w0.102: R5737.2 130.08,144.94 130.46,145.32 v1(130.46,146.69) U5703.2
N170981759: length 5.2
  TOP w0.102: v1(121.27,137.27) R5734.1 R5735.1 122.35,139.29 123.09,140.04 Q5705.3
N170981761: length 5
  TOP w0.102: U5703.6 125.49,146.04 R5736.2 124.62,145.73 124.36,145.47 124.36,144.93 v1(124.29,144.85) 124.04,144.61 Q5705.1
N170982263: length 3.4
  TOP w0.102: U5703.5 127.23,146.69 127.36,146.57 127.36,145.78 126.98,145.4 R5741.2 126.55,144.94 126.45,144.84 v1(126.09,144.84)
N170982269: length 7.1
  BOTTOM w0.102: Q5714.3 126.65,87 126.11,87.55 R5738.1 R5739.1 126.11,91.06 126.79,91.74 v1(127.74,91.74)
N170982271: length 69.9
  TOP w0.102: v2(128.99,149.26) 128.99,149.05 128.68,148.75 R5740.2 129.04,148.47 129.67,147.84 129.67,147.58 129.43,147.34 U5703.3
  IN1 w0.102: v2(128.99,149.26) 128.99,148.96 128.17,148.14 127.62,148.14 127.16,147.68 127.16,135.1 127.62,134.65 127.62,131.97 126.3,130.65 126.3,126.06 128.2,124.15 128.2,91.52 v2(129.39,90.33)
  BOTTOM w0.102: Q5714.1 128.73,87.56 128.5,87.79 128.5,89.97 128.86,90.33 v2(129.39,90.33) ; v2(128.99,149.26) 129.29,149.56 v1(129.29,149.84)
N170982673: length 3.5
  BOTTOM w0.102: v1(128.71,164.55) R5745.2 126.3,164.55 125.91,164.93 U5704.2
N170982679:
  vias: v1(130.89,168.59)
N170982681: length 6.8
  BOTTOM w0.102: U5704.6 126.56,167.99 127.01,168.43 R5744.2 127.74,168.46 127.74,169.55 128.3,170.11 v1(129.24,170.11) 130.17,170.11 130.46,169.82 Q5715.1
N171267611: length 4.3
  TOP w0.102: v1(298.23,68.43) 298.23,71.33 298.02,71.53 R1247.1 297.72,71.97 297.75,71.99 R1245.1
N172323921: length 12.9
  BOTTOM w0.102: U2000.AJ44 231.08,48.06 231.31,47.84 231.31,46.17 233.15,44.33 233.15,42.17 231.99,41 231.68,41 231.45,40.77 231.45,39.33 230.86,38.74 230.59,38.74 230.31,38.46 R2324.2
N173419281: length 3.1
  BOTTOM w0.102: U0703.2 147.05,22.63 146.88,22.47 146.59,22.47 146.5,22.37 SR0702.2 146.18,21.95 v1(145.47,21.24)
N173594018: length 26.6
  TOP w0.102: SR4505.2 93.28,188.79 93.63,189.15 v1(93.63,189.97) 95.99,189.97 96.22,190.21 100.17,190.21 101.28,191.32 106.36,191.32 107.4,192.36 112.32,192.36 114.44,190.24 114.44,189.16 114.75,188.86 CON4500.16
N173598546: length 6.8
  BOTTOM w0.102: v1(272.22,69.27) 272.22,69.64 272.96,70.39 273.91,70.39 274.52,69.78 274.52,68.61 274.45,68.55 SR5704.2 274.1,68.19 274.15,68.15 Q5712.1
N173598592: length 2.4
  BOTTOM w0.102: SR5702.2 137.78,34.92 137.52,35.18 v1(137.52,35.52) 137.57,35.57 Q5706.1
N173598635: length 3.2
  TOP w0.102: Q5708.1 21.85,60.83 21.57,60.55 SR5703.2 22.6,59.84 v1(22.61,59.85)
N173602122: length 2.3
  BOTTOM w0.102: v1(128.96,89.8) 128.96,89.33 SR7001.2 129.74,88.89 130.01,89.16 U7002.2
N173612087: length 4.3
  BOTTOM w0.102: SR7416.1 138.82,51.92 139.05,52.15 v1(139.05,52.76) 139.05,52.84 R7461.1 138.18,54.3 138.2,54.32 U7403.2
N1361261240: length 3.3
  TOP w0.102: T3303.1 273,100.44 SR3303.2
N1742655301: length 2.9
  BOTTOM w0.102: v1(253.17,78.04) 253.33,78.2 SR8900.2 253.33,79.98 252.91,80.4 D8900.2

## Copper pours and planes (outline as drawn)
1.0VSUS_BST on TOP (solid shape): 222.85,14.2 222.85,14.01 222.81,13.97 221.97,13.97 221.9,13.9 221.9,13.37 221.36,12.83 220.79,12.83 220.7,12.92 220.7,13.76 221.08,14.13 221.42,14.13 221.5,14.22 222.83,14.22
1.0VSUS_BST_R on TOP (solid shape): 220.07,13.85 220.07,12.79 219.99,12.71 219.28,12.71 219.26,12.73 218.22,12.73 218.01,12.95 218.01,13.73 218.28,14 219.69,14 219.69,14 219.92,14
1.0VSUS_LX on TOP (solid shape): 219.74,18.5 219.74,17.76 219.58,17.61 219.58,15.97 220.08,15.47 221.14,15.47 221.89,14.71 224.01,14.71 224.03,14.69 224.03,14.52 223.99,14.47 221.39,14.47 221.25,14.32 218.04,14.32 217.69,13.98 217.69,12.38 217.51,12.2 214.2,12.2 214.06,12.34 214.06,18.35 214.59,18.88 219.35,18.88
1.0VSUS_RC on TOP (solid shape): 222.12,18.37 222.12,17.64 222.13,17.64 222.13,16.97 221.51,16.35 219.92,16.35 219.85,16.41 219.85,17.56 220.08,17.78 221.29,17.78 221.41,17.9 221.41,18.49 221.51,18.6 221.89,18.6
1.5VS_IN on TOP (solid shape): 225.28,29.32 225.28,28.18 225.53,27.92 225.6,27.92 225.65,27.91 225.71,27.85 225.71,27.59 225.61,27.49 225.15,27.49 224.87,27.77 223.91,27.77 223.63,28.05 222.99,28.05 222.87,28.18 222.87,29.06 223.25,29.45 225.15,29.45
1.8VO_VGA_BST on TOP (solid shape): 120.77,61.34 121.3,61.34 121.31,61.33 121.31,61.13 121.31,61.13 120.18,61.13 118.99,62.32 118.32,62.32 118.1,62.53 118.1,63.36 118.15,63.41 118.71,63.41
1.8VO_VGA_LX on TOP (solid shape): 126.19,65.52 126.19,63.68 124.22,61.72 123.12,61.72 123.02,61.62 123.02,60.18 122.93,60.08 122.21,60.08 122.12,60.17 122.12,62.3 121.64,62.78 119.61,62.78 118.58,63.81 118.21,63.81 117.27,64.75 116.44,64.75 116.23,64.96 116.23,66.95 116.5,67.22 124.48,67.22
1.8VO_VGA_LX on BOTTOM (solid shape): 125.43,62.89 125.43,61.91 125.21,61.68 123.94,61.68 123.39,61.13 122.84,61.13 122.65,61.32 122.65,62.08 123.54,62.97 125.35,62.97
1.8VO_VGA_RC on BOTTOM (solid shape): 126.61,61.73 126.61,60.36 126.52,60.27 123.98,60.27 123.89,60.36 123.89,61.09 123.96,61.17 125.69,61.17 126.35,61.83 126.5,61.83
1V0_VGA_BST on BOTTOM (solid shape): 117.38,147.49 117.38,147.3 117.36,147.28 116.67,147.28 116.66,147.27 116.66,146.94 115.73,146.01 114.65,146.01 114.56,146.1 114.56,146.67 114.66,146.76 115.49,146.76 116.23,147.5 117.37,147.5
1V0_VGA_BST_R on BOTTOM (solid shape): 116.57,145.5 116.57,144.73 116.48,144.64 114.59,144.64 114.54,144.69 114.54,145.43 114.71,145.6 116.48,145.6
1V0_VGA_LX on TOP (solid shape): 122.99,147.07 122.99,146.41 123.13,146.27 123.63,146.27 123.88,146.02 123.88,144.9 123.72,144.73 123.17,144.73 123.08,144.83 123.08,145.49 122.86,145.72 122.11,145.72 122.05,145.79 122.05,147.15 122.1,147.2 122.86,147.2
1V0_VGA_LX on BOTTOM (solid shape): 119.35,148.42 119.35,146.79 119.68,146.46 123.58,146.46 124.57,145.48 124.57,142.35 123.68,141.46 123.68,140.19 123.6,140.12 117.88,140.12 117.36,140.64 117.36,144.77 122.23,144.77 122.24,144.72 122.25,144.66 122.27,144.61 122.3,144.56 122.34,144.52 122.38,144.48 122.43,144.45 122.48,144.43 122.53,144.41 122.58,144.41 122.64,144.41 122.7,144.41 122.75,144.43 122.8,144.45 122.85,144.48 122.89,144.52 122.92,144.56 122.95,144.61 122.97,144.66 122.99,144.72 122.99,144.77 122.99,144.83 122.98,144.88 122.96,144.94 122.94,144.99 122.91,145.03 122.87,145.07 122.82,145.11 122.77,145.13 122.72,145.15 122.67,145.17 122.61,145.17 122.56,145.17 122.5,145.15 122.45,145.13 122.4,145.11 122.36,145.07 122.32,145.03 122.29,144.99 122.26,144.94 122.24,144.88 122.23,144.83 122.23,144.77 117.36,144.77 117.36,145.49 117.62,145.75 117.97,145.75 118.24,146.02 118.24,148.5 118.29,148.55 119.22,148.55
1V0_VGA_RC on TOP (solid shape): 120.78,147.85 120.88,147.64 121.07,147.52 121.07,145.14 120.7,144.77 120.27,144.77 120,145.04 120,147.82 120.13,147.95 120.68,147.95
2.5VO_BST on TOP (solid shape): 92.43,10.05 92.43,9.42 92.43,8.41 91.5,7.49 91.5,6.95 91.48,6.92 91.25,6.92 91.23,6.94 91.23,7.92 91.29,8.02 91.32,8.13 91.58,8.4 91.58,10.12 91.78,10.32 92.16,10.32
3V_BST on TOP (solid shape): 261.04,58.58 261.04,58.02 262.46,56.6 263.25,56.6 263.38,56.47 263.38,56.12 263.28,56.01 261.6,56.01 261.55,56.06 261.55,56.95 260.84,57.67 260.84,58.58 260.86,58.6 261.02,58.6
3V_BST_R on TOP (solid shape): 261.45,55.22 262.4,55.22 262.41,55.2 262.41,54.69 262.36,54.64 260.25,54.64 260.13,54.77 260.13,55.18 260.18,55.23 261.45,55.23
3V_HG on TOP (solid shape): 263.1,57.28 263.1,56.95 262.9,56.75 262.54,56.75 261.22,58.07 261.22,58.6 261.25,58.63 261.75,58.63
3V_HG on TOP (solid shape): 271.38,25.76 271.38,23.86 271.25,23.73 270.24,23.73 270.11,23.86 270.11,25.76 270.24,25.89 271.25,25.89
3V_HG on BOTTOM (solid shape): 271.66,25.71 271.66,24.19 271.59,24.11 271.59,24.11 271.49,24.02 270.38,24.02 270.28,24.11 270.28,25.54 270.61,25.87 271.5,25.87
3V_HG on IN4 (solid shape): 272.2,25.02 271.74,24.57 270.97,24.57 270.8,24.74 270.8,25.71 271.02,25.93 272.2,25.93
3V_LG on TOP (solid shape): 263.95,57.6 263.95,56.89 263.81,56.75 263.48,56.75 263.25,56.98 263.25,57.33 261.83,58.76 261.65,58.76 261.6,58.81 261.6,58.96 261.63,58.99 262.57,58.99
3V_LG on BOTTOM (solid shape): 273.93,16.82 273.93,14.92 273.75,14.75 272.8,14.75 272.65,14.89 272.65,16.77 272.74,16.85 273.9,16.85
3V_LG on IN4 (solid shape): 273.82,17.62 273.82,15.89 273.65,15.72 272.71,15.72 272.51,15.92 272.51,17.65 272.67,17.81 273.62,17.81
3V_LX on TOP (solid shape): 260.64,58.58 260.64,57.61 261.02,57.23 261.02,56.09 260.94,56.01 259.92,56.01 259.37,56.57 259.37,57.03 259.57,57.23 259.92,57.23 260.13,57.03 260.13,56.93 260.15,56.9 260.23,56.9 260.28,56.95 260.28,57.72 260.43,57.87 260.43,58.6 260.61,58.6
3V_LX on BOTTOM (solid shape): 269.62,25.98 269.62,24.01 269.86,23.77 271.16,23.77 271.29,23.64 271.29,21.39 271.05,21.16 271.05,19.88 271.25,19.68 272.02,19.68 272.3,19.41 272.3,14.06 271.97,13.73 263.58,13.73 262.87,14.44 262.87,25.96 263.47,26.56 269.05,26.56
3V_RC on BOTTOM (solid shape): 272.29,21.2 273.15,21.2 273.27,21.08 273.27,20.52 273.19,20.44 272.41,20.44 272.07,20.11 271.65,20.11 271.56,20.19 271.56,21.5 271.64,21.58 271.91,21.58
5V_BST on TOP (solid shape): 261.76,63.17 261.76,62.62 261.04,61.91 261.04,60.81 260.84,60.81 260.84,63.1 260.97,63.23 261.7,63.23
5V_BST_R on TOP (solid shape): 261.85,64.75 261.85,64.37 261.73,64.24 258.76,64.24 258.65,64.35 258.65,64.78 258.76,64.88 261.73,64.88
5V_HG on TOP (solid shape): 262.69,62.44 262.69,61.91 261.52,60.73 261.31,60.73 261.25,60.8 261.25,61.75 262.02,62.53 262.61,62.53
5V_HG on BOTTOM (solid shape): 271.42,70.04 271.42,68.95 271.13,68.66 270.87,68.66 270.15,69.38 269.74,69.38 269.65,69.47 269.65,70.26 269.78,70.39 271.07,70.39
5V_LG on TOP (solid shape): 263,60.9 263,60.5 262.81,60.32 262.45,60.32 262.4,60.37 261.61,60.37 261.59,60.39 261.59,60.55 262.03,60.99 262.03,60.99 262.13,61.08 262.81,61.08
5V_LG on BOTTOM (solid shape): 262.02,67.49 262.39,67.49 262.46,67.42 262.46,66.56 262.39,66.48 261.6,66.48 261.18,66.9 261.18,67.8 261.34,67.96 261.55,67.96
5V_LX on TOP (solid shape): 260.71,63.86 260.71,63.46 260.64,63.38 260.64,60.81 260.43,60.81 260.43,62.11 259.57,62.97 259.57,63.86 259.7,63.99 260.58,63.99
5V_LX on BOTTOM (solid shape): 260.74,64.42 260.74,63.56 260.56,63.38 259.67,63.38 259.47,63.58 259.47,64.6 259.54,64.68 260.48,64.68
5V_LX on BOTTOM (solid shape): outline of 93 points within 261.12,68.16 269.47,83.75
5V_RC on BOTTOM (solid shape): 266.33,69.15 266.33,68.42 266.49,68.25 266.49,67.65 266.3,67.47 265.44,67.47 265.31,67.6 265.31,68.01 265.37,68.07 265.37,69.11 265.43,69.17 266.3,69.17
+0.6VO on TOP (solid shape): 24.92,54.85 24.92,53.19 25.05,53.07 25.68,53.07 26.95,51.8 26.95,51.8 27.01,51.74 27.01,50.67 26.93,50.59 26.59,50.59 24.87,52.31 20.81,52.31 20.43,52.69 20.43,53.96 21.7,55.23 24.54,55.23
+1.0V on TOP (solid shape): 194.38,36.27 194.38,35.69 193.85,35.16 193.85,33.47 193.75,33.36 192.21,33.36 192.11,33.47 192.11,34.83 193.61,36.34 194.32,36.34
+1.0VO on TOP (solid shape): outline of 580 points within 192.06,12.07 212.5,52.74
+1.0VO_VGA on BOTTOM (solid shape): outline of 90 points within 116.69,130.11 125.38,139.38
+1.0VS on TOP (solid shape): 193.95,40.2 193.95,38.71 193.95,38.71 193.95,38.59 194.33,38.21 194.33,37.75 194.29,37.71 193.53,37.71 192.31,38.93 192.31,40.49 192.46,40.65 193.5,40.65
+1.0VS on TOP (solid shape): 109.25,123.69 109.25,123.39 109.15,123.29 108.99,123.19 108.89,123.03 108.86,122.99 108.86,121.44 108.79,121.37 108.27,121.37 108.2,121.44 108.2,122.88 108.67,123.35 108.67,123.58 108.66,123.58 108.66,123.74 108.72,123.79 109.15,123.79
+1.0VS on IN2 (solid shape): 119.64,127.61 119.64,125.79 118.8,124.95 118.01,124.95 117.84,125.13 117.84,127.64 118.04,127.85 119.4,127.85
+1.0VSUS on TOP (solid shape): 219.87,75.11 219.87,74.72 219.54,74.39 219.54,73.39 219.49,73.34 218.73,73.34 218.6,73.46 218.6,75.06 218.75,75.22 219.77,75.22
+1.0VSUS on TOP (solid shape): outline of 1141 points within 207.22,52.48 225.76,60.94
+1.0VSUS on BOTTOM (solid shape): 211.82,50.43 211.82,49.92 211.69,49.79 210.17,49.79 210.17,50.3 210.39,50.53 211.72,50.53
+1.0VSUS on BOTTOM (solid shape): 223.08,62.76 223.17,62.75 223.27,62.76 223.28,62.77 223.52,62.77 223.63,62.66 223.63,62.02 223.6,61.91 223.63,61.8 223.63,61.78 223.69,61.71 223.78,61.62 224.11,61.62 224.16,61.68 224.16,61.77 224.19,61.8 224.19,61.98 224.29,62.08 224.68,62.08 224.78,61.98 224.78,61.09 225.25,60.62 225.25,60.14 225.57,59.83 225.57,58.84 225.75,58.66 225.75,58.46 225.57,58.28 225.57,58.13 225.57,58.06 226.04,57.59 226.04,57.19 225.72,56.87 225.68,56.83 225.65,56.79 225.38,56.79 225.38,56.82 224.95,57.25 224.95,59.44 224.65,59.74 224.64,59.75 224.59,59.82 224.52,59.88 224.51,59.88 224.24,60.15 224.24,60.89 224.11,61.02 223.25,61.02 222.94,61.32 222.94,62.03 222.94,62.72 222.99,62.77 223.07,62.77
+1.0VSUS on IN1 (solid shape): 210.85,59.72 210.85,58.81 210.67,58.63 209.35,58.63 209.07,58.91 209.07,59.85 209.44,60.22 210.36,60.22
+1.0VSUS on IN2 (solid shape): outline of 8027 points within 208.44,51.75 233.21,77.32
+1.0VSUS on IN4 (solid shape): outline of 393 points within 223.03,56.06 231.27,62.77
+1.2VO_DDR on TOP (solid shape): 29.27,56.49 29.27,55.84 28.98,55.54 28.34,55.54 28,55.89 27.16,55.89 27.11,55.94 27.11,56.5 27.27,56.66 29.1,56.66
+1.2VO_DDR on TOP (solid shape): outline of 430 points within 25.89,80.37 43.03,113.65
+1.5VO on TOP (solid shape): 218.52,29.95 218.52,24.92 218.57,24.87 220.2,24.87 220.54,25.21 221.97,25.21 222.26,25.5 222.26,26.18 222.49,26.41 223.55,26.41 223.8,26.16 223.8,23.4 223.63,23.22 217.91,23.22 217.66,23.48 217.66,24.24 217.4,24.49 216.64,24.49 216.39,24.75 216.39,25.81 215.68,26.52 215.68,28.71 215.37,29.01 215.09,29.01 214.89,29.22 214.89,30.11 214.97,30.18 218.29,30.18
+1.5VS on TOP (solid shape): 217.4,32.09 217.4,30.56 217.3,30.46 216.07,30.46 216.07,30.4 214.71,30.4 214.66,30.45 214.66,32.14 214.84,32.32 217.18,32.32
+1.5VS on BOTTOM (solid shape): 49.59,22.05 49.59,20.91 49.31,20.63 48.22,20.63 47.78,21.06 47.78,21.75 48.32,22.28 49.36,22.28
+1.5VS on BOTTOM (solid shape): 57.44,33.74 57.44,32.54 57.11,32.21 55.71,32.21 55.38,32.54 55.38,33.48 56.01,34.12 57.05,34.12
+1.5VS on IN2 (solid shape): 216.07,31.92 216.07,31.03 215.79,30.75 213.3,30.75 213.14,30.92 213.14,32.06 213.19,32.11 215.88,32.11
+1.5VS on IN2 (solid shape): 28.3,17.89 28.3,16.62 28.11,16.43 25.7,16.43 25.51,16.62 25.51,17.89 25.76,18.14 28.05,18.14
+1.5VS on IN2 (solid shape): 49.55,21.25 49.55,20.05 48.99,19.49 48.04,19.49 47.68,19.84 47.68,20.77 48.36,21.44 49.36,21.44
+1.5VS on IN2 (solid shape): 58.02,35.8 58.02,34.63 58.11,34.54 58.11,34.14 57.3,33.33 56.43,33.33 56.13,33.64 56.13,35.81 56.24,35.92 57.89,35.92
+1.8VO_VGA on TOP (solid shape): 130.44,78.34 130.44,77.25 130.26,77.07 129.98,77.07 129.64,76.74 129.53,76.72 129.47,76.82 128.73,76.98 129.38,76.6 129.4,76.62 129.47,76.62 129.47,76.45 128.79,75.77 128.1,75.77 127.37,75.03 127.37,75.03 127.28,74.94 127.28,71.9 127.28,71.9 127.28,69.81 126.34,68.87 119.74,68.87 119.49,69.12 119.49,71.32 119.76,71.59 121.68,71.59 122.21,72.11 122.21,79.41 122.32,79.52 122.84,79.52 122.93,79.48 122.94,79.39 123.35,78.88 123.61,79.48 123.6,79.58 123.69,79.64 126.17,79.64 126.4,79.86 128.91,79.86
+1V8_AON on TOP (solid shape): 130.03,121.9 130.03,119.23 129.77,118.98 125.84,118.98 125.71,119.11 125.71,121.9 125.96,122.16 129.77,122.16
+1V8_AON on TOP (solid shape): 149.08,77.71 149.08,76.31 148.95,76.18 148.19,76.18 148.06,76.31 148.06,77.71 148.19,77.83 148.95,77.83
+1V8_AON on TOP (solid shape): 184.85,46.28 184.85,44.15 184.35,43.65 182.91,43.65 182.82,43.74 182.82,46.27 183.22,46.66 184.48,46.66
+1V8_AON on TOP (solid shape): 195.84,113.27 195.84,113.01 195.61,112.78 193.4,112.78 193.35,112.83 193.35,113.52 193.38,113.55 195.56,113.55
+1V8_AON on TOP (solid shape): 168.68,142.91 168.68,141.52 169.13,141.07 169.13,140.79 169.06,140.72 168.75,140.72 167.95,141.52 167.63,141.52 167.14,142.02 167.14,142.78 167.53,143.18 168.41,143.18
+1V8_AON on TOP (solid shape): 194.57,104.5 194.57,103.94 194.88,103.64 195.61,103.64 195.81,103.44 195.81,103.18 195.71,103.08 194.44,103.08 193.99,103.54 193.2,103.54 193.17,103.56 193.17,103.99 193.83,104.66 194.42,104.66
+1V8_AON on TOP (solid shape): 169.73,127.8 169.73,124.88 169.88,124.74 170.71,124.74 170.95,124.5 170.95,124.17 170.72,123.94 169.34,123.94 168.96,124.32 168.96,125.63 168.7,125.89 168.7,127.93 168.82,128.06 169.47,128.06
+1V8_AON on TOP (solid shape): 160.03,45.96 160.46,45.96 160.48,45.93 160.48,45.04 160.46,45.02 159.92,45.02 159.75,45.19 159.01,45.19 158.98,45.22 158.98,46.34 158.5,46.82 158.5,47.02 158.63,47.15 158.83,47.15
+1V8_AON on TOP (solid shape): 179.12,142.58 179.12,141.33 178.97,141.18 178.97,140.6 178.87,140.49 178.61,140.49 178.54,140.59 178.43,140.66 177.6,141.49 177.6,142.75 177.91,143.06 178.64,143.06
+1V8_AON on TOP (solid shape): 187.26,61.5 187.26,60.64 187.23,60.61 186.7,60.61 186.67,60.64 186.67,60.95 186.54,61.07 184.84,61.07 184.75,60.99 184.33,60.57 184.33,59.82 184.21,59.7 183.95,59.7 183.9,59.76 183.9,60.87 184.62,61.59 187.17,61.59
+1V8_AON on TOP (solid shape): 178.72,127.94 178.72,126.97 178.78,126.91 178.78,126.63 179.48,125.93 179.48,125.21 178.54,124.28 178.31,124.28 178.2,124.39 178.2,124.58 178.45,124.83 178.45,124.99 178.45,124.99 178.45,126.11 178.43,126.14 178.43,126.15 178.08,126.5 178.08,128.1 178.19,128.2 178.46,128.2
+1V8_AON on TOP (solid shape): 158.81,62.97 158.81,62.03 158.25,61.48 158.25,60.76 158.29,60.72 158.37,60.61 158.47,60.54 158.6,60.41 158.68,60.41 158.81,60.28 158.81,60.08 158.68,59.95 158.48,59.95 157.84,60.59 157.84,61.88 158.27,62.31 158.27,62.97 158.4,63.1 158.68,63.1
+1V8_AON on TOP (solid shape): 195.31,78.49 195.46,78.49 195.69,78.26 195.69,78.11 195.53,77.95 193.37,77.95 192.74,77.32 192.74,77.09 192.44,76.79 192.14,76.79 191.97,76.96 191.97,78.13 192.97,79.13 194.67,79.13
+1V8_AON on TOP (solid shape): 151.97,85.35 151.97,84.05 151.92,84 151.73,84 151.36,83.64 151.36,81.69 151.21,81.54 150.88,81.54 150.82,81.61 150.82,83.74 150.79,83.77 150.79,84.19 150.72,84.23 150.68,84.3 150.62,84.36 150.62,84.37 150.53,84.46 150.2,84.46 150.09,84.56 150.09,84.94 150.22,85.07 150.63,85.07 150.96,85.4 151.92,85.4
+1V8_AON on TOP (solid shape): 210.82,78.96 210.82,78.29 210.82,78.26 210.67,77.93 210.88,77.62 210.88,76.66 210.85,76.64 209.99,76.64 209.96,76.66 209.96,77.25 209.99,77.27 209.99,79.17 210.04,79.23 210.55,79.23
+1V8_AON on TOP (solid shape): 143.39,143.54 144.79,143.54 145.01,143.31 145.01,142.7 144.53,142.22 144.53,140.54 144.39,140.4 144.12,140.4 143.77,140.75 143.58,140.75 143.21,141.11 142.85,141.11 142.7,141.26 142.7,141.56 142.42,141.84 142.42,142.76 142.32,142.86 141.66,142.86 141.56,142.76 141.56,142.06 141.42,141.92 140.09,141.92 139.64,141.46 137.38,141.46 137.27,141.57 137.27,143.87 137.53,144.13 142.81,144.13
+1V8_AON on TOP (solid shape): 132.95,95.49 132.95,94.06 132.73,93.85 128.06,93.85 126.76,92.54 126.76,83.51 127.05,83.22 127.72,83.22 128.34,82.6 128.34,81.22 128.33,81.21 128.33,80.35 128.05,80.07 125.81,80.07 125.74,79.99 123.98,79.99 123.93,79.94 122.2,79.94 121.35,79.09 119.91,79.09 119.68,79.32 119.68,80.01 120.03,80.36 120.03,82.29 120.85,83.11 122.43,83.11 122.62,82.92 123.9,82.92 124,83.02 124,94.5 125.49,95.99 132.44,95.99
+1V8_AON on TOP (solid shape): 213.34,114.59 213.34,111.97 210.96,109.58 210.96,104.88 211.07,104.77 211.07,103.36 210.93,103.23 210.62,103.23 210.28,103.12 210.17,102.78 210.01,102.62 208.57,102.62 208.11,103.08 207.88,103.08 207.78,103.18 207.78,103.38 207.81,103.41 207.86,103.48 207.9,103.52 207.96,103.54 208.03,103.54 208.04,103.54 208.43,103.54 208.7,103.28 209.28,103.28 209.38,103.38 209.38,104.15 209.46,104.23 209.46,104.84 209.78,105.16 210.45,105.16 210.62,105.34 210.62,106.13 210.45,106.31 209.45,106.31 209.01,106.75 209.01,107.14 208.93,107.22 208.51,107.22 208.36,107.37 208.36,108.36 208.51,108.52 209.25,108.52 209.66,108.92 209.66,111.26 210.8,112.4 210.8,113.03 210.65,113.19 210.62,113.21 209.3,113.21 208.92,112.83 208.72,112.83 208.59,112.96 208.59,113.39 209,113.8 209.18,113.8 210.14,114.76 213.16,114.76
+1V8_AON on TOP (solid shape): outline of 89 points within 142.89,125.94 144.25,128.13
+1V8_AON on BOTTOM (solid shape): 151.39,85 151.39,84.41 151.62,84.18 151.62,82.31 151.49,82.17 151.44,81.99 151.44,81.97 151.39,81.92 151.38,81.92 151.25,81.85 151.18,81.72 151.18,81.71 150.98,81.52 150.09,81.52 149.84,81.77 149.84,83.38 149.88,83.46 149.97,83.48 150.18,83.5 150.31,83.66 150.32,83.67 150.39,83.74 150.41,83.74 150.74,84.11 150.38,84.45 150.34,84.47 150.33,84.5 150.27,84.63 150.15,84.71 150.14,84.71 150.04,84.81 149.95,84.81 149.84,84.92 149.84,85.2 149.97,85.33 151.06,85.33
+1V8_AON on IN1 (solid shape): 125.08,82.05 125.08,80.17 124.87,79.97 122.56,79.97 122.47,80.05 122.47,82.2 122.58,82.3 124.82,82.3
+1V8_AON on IN1 (solid shape): 126.82,120.78 126.82,115.26 126.6,115.04 125.23,115.04 125.05,115.22 125.05,117.95 125.71,117.95 125.72,117.9 125.73,117.84 125.75,117.79 125.78,117.74 125.82,117.7 125.86,117.66 125.9,117.63 125.96,117.61 126.01,117.59 126.06,117.58 126.12,117.58 126.18,117.59 126.23,117.61 126.28,117.63 126.33,117.66 126.37,117.7 126.4,117.74 126.43,117.79 126.45,117.84 126.47,117.9 126.47,117.95 126.47,118.01 126.46,118.06 126.44,118.11 126.42,118.16 126.39,118.21 126.35,118.25 126.3,118.28 126.25,118.31 126.2,118.33 126.15,118.34 126.09,118.35 126.04,118.34 125.98,118.33 125.93,118.31 125.88,118.28 125.84,118.25 125.8,118.21 125.77,118.16 125.74,118.11 125.72,118.06 125.71,118.01 125.71,117.95 125.05,117.95 125.05,120.75 125.31,121.01 126.58,121.01
+1V8_AON on IN1 (solid shape): outline of 534 points within 143.9,56.15 147.92,68.76
+1V8_AON on IN1 (solid shape): outline of 1284 points within 140.32,125.66 194.41,143.11
+1V8_AON on IN1 (solid shape): outline of 1370 points within 207.75,77.32 215.75,114.28
+1V8_AON on IN1 (solid shape): outline of 2194 points within 149.46,46.21 159.24,85.45
+1V8_AON on IN2 (solid shape): 126.28,120.69 126.28,118.78 125.91,118.41 124.97,118.41 124.72,118.66 124.72,120.15 125.46,120.89 126.09,120.89
+1V8_AON on IN2 (solid shape): 125.08,82.28 125.08,80.3 124.72,79.94 122.62,79.94 122.47,80.1 122.47,82.3 122.7,82.53 124.82,82.53
+1V8_AON on IN2 (solid shape): outline of 3378 points within 143.11,55.9 155.43,85.58
+1V8_AON on IN2 (solid shape): outline of 8580 points within 141.46,45.45 214.49,143.36
+1V8_AON on IN3 (solid shape): outline of 367 points within 143.62,141.72 207.65,146.03
+1V8_AON on IN4 (solid shape): outline of 1290 points within 132.46,70.09 151.39,95.51
+1V8_AON on IN4 (solid shape): outline of 9004 points within 140.44,46.11 214.94,143.44
+1V8_MAIN on TOP (solid shape): 149.21,62.79 149.54,62.2 149.86,62.79 150.8,62.79 150.86,62.78 150.92,62.79 153.07,62.79 153.07,61.56 152.55,61.04 151.49,61.04 151.11,61.45 150.73,61.04 149.29,61.04 149.13,60.87 149.13,60.48 149.16,60.45 149.16,60.12 148.98,59.95 147.59,59.95 147.43,60.1 147.07,60.1 146.84,60.33 146.84,61.22 146.95,61.32 147.45,61.32 147.5,61.37 147.5,62.41 147.68,62.59 147.97,62.59 148.16,62.79
+1V8_MAIN on TOP (solid shape): outline of 210 points within 149.47,92.97 152.18,98.37
+1V8_MAIN on TOP (solid shape): outline of 293 points within 127.03,77.87 137.96,94.43
+1V8_MAIN on IN1 (solid shape): 151.34,97.52 151.34,97.18 151.25,97.09 151.15,97.09 151.14,97.08 150.92,97.02 150.78,96.84 150.75,96.75 150.74,96.66 150.74,96.64 150.57,96.48 149.65,96.48 149.52,96.6 149.52,96.88 149.68,97.04 149.95,97.16 150.04,97.44 150.24,97.64 151.21,97.64
+1V8_MAIN on IN1 (solid shape): outline of 1153 points within 133.28,87.79 151.44,95.51
+1V8_MAIN on IN3 (solid shape): 127.9,87.28 127.9,84.99 127.34,84.43 127.34,83.83 127.21,83.7 125.74,83.7 125.58,83.85 125.58,87.26 125.76,87.43 127.74,87.43
+1V8_MAIN on IN3 (solid shape): outline of 254 points within 149.41,92.56 151.95,97.82
+1V8_MAIN on IN3 (solid shape): outline of 913 points within 132.24,58.45 148.77,67.6
+1V_PRIM_W12MIL on TOP (solid shape): outline of 1238 points within 211.05,56.44 232.03,63.68
+1V_PRIM_W12MIL on BOTTOM (solid shape): 231.63,60.61 231.63,59.94 231.8,59.77 232.07,59.77 232.26,59.58 232.26,58.86 232.12,58.73 231.8,58.73 231.63,58.56 231.63,58.2 231.5,58.07 230.99,58.07 230.79,58.27 230.77,58.32 230.74,58.36 230.74,58.78 230.8,58.96 230.74,59.14 230.74,59.55 230.8,59.73 230.74,59.91 230.74,60.33 230.76,60.36 230.78,60.4 231.12,60.74 231.5,60.74
+1V_PRIM_W12MIL on BOTTOM (solid shape): 229.14,59.13 229.14,58.74 228.87,58.47 228.81,58.45 228.75,58.39 228.69,58.29 228.67,58.22 228.67,58.13 228.7,58.06 228.76,57.97 228.85,57.9 228.86,57.9 229.17,57.59 229.17,57.27 228.38,56.48 227.41,56.48 227.34,56.56 227.34,56.57 227.15,56.76 226.88,57.03 226.88,57.09 226.91,57.12 226.91,57.19 226.91,57.25 226.92,57.26 226.96,57.41 226.92,57.56 226.91,57.57 226.91,57.65 226.85,57.7 226.48,58.08 226.48,59 226.6,59.12 226.67,59.12 226.72,59.07 226.79,59.01 227.09,58.96 227.35,59.12 227.46,59.12 227.55,59.03 227.55,58.75 227.26,58.47 227.26,58.44 227.24,58.42 227.2,58.39 227.18,58.36 227.15,58.32 227.14,58.28 227.12,58.19 227.13,58.09 227.14,58.06 227.21,57.97 227.31,57.88 227.34,57.88 227.57,57.88 227.61,57.94 227.65,58 227.71,58.03 227.92,58.03 227.98,58 228.03,57.94 228.07,57.88 228.29,57.88 228.34,57.88 228.38,57.96 228.4,57.96 228.44,57.99 228.47,58.03 228.51,58.19 228.46,58.34 228.42,58.4 228.35,58.45 228.3,58.47 228.08,58.69 228.08,59.05 228.28,59.25 228.28,59.38 228.48,59.58 228.69,59.58
+1V_PRIM_W12MIL on IN1 (solid shape): outline of 2528 points within 211.34,52.15 232.21,62.39
+1V_PRIM_W12MIL on VCC1 (solid shape): 224.3,63.14 224.34,63.11 224.39,63.1 231.45,63.1 231.63,62.92 231.63,60.05 231.64,60 231.67,59.96 232.14,59.49 232.14,57.69 228.78,54.34 227.95,54.34 227.9,54.33 227.86,54.3 227,53.45 226.8,53.45 226.75,53.44 226.71,53.41 226.37,53.07 225.2,53.07 225.11,53.16 225.07,53.19 225.02,53.19 224.06,53.19 223.84,53.41 223.8,53.44 223.75,53.45 223.37,53.45 223.33,53.44 223.28,53.41 222.56,52.69 216.31,52.69 215.97,53.03 215.93,53.06 215.88,53.07 215.37,53.07 215.32,53.06 215.28,53.03 214.94,52.69 211.62,52.69 211.05,53.25 211.05,63.43 212,64.37 217.53,64.37 217.58,64.38 217.62,64.41 217.84,64.62 222.81,64.62
+1V_PRIM_W12MIL on IN3 (solid shape): outline of 3869 points within 211.83,51 232.19,64.8
+2.5VO on TOP (solid shape): 111.11,13.19 111.11,8.64 110.98,8.52 107.27,8.52 106.99,8.24 105.19,8.24 104.3,7.35 101.33,7.35 100.56,8.11 100.56,11.54 101.45,12.43 107.04,12.43 107.17,12.3 107.17,12.05 107.3,11.92 108.31,11.92 108.31,11.92 109,11.92 109.2,12.12 109.2,13.19 109.33,13.32 110.98,13.32
+3V on TOP (solid shape): 258.5,83.67 258.5,82.94 258.93,82.51 258.93,81.87 258.86,81.8 257.84,81.8 257.69,81.95 256.44,81.95 256.39,82 256.39,83.61 256.77,83.99 258.19,83.99
+3V3_MAIN on TOP (solid shape): 234.91,26.68 235.06,26.4 235.38,26.33 235.95,25.76 236.58,25.76 236.71,25.64 236.71,23.6 237.27,23.04 238.16,23.04 238.28,23.17 238.28,23.78 238.43,23.93 240.44,23.93 240.49,23.88 240.49,22.29 240.38,22.18 236.31,22.18 234.17,24.32 234.17,26.65 234.3,26.78 234.81,26.78
+3V3_MAIN on IN1: 260.88,39.38 262.35,39.38 262.52,39.21 262.52,38.19 262.46,38.13 261.17,38.13 260.73,38.56 260.73,39.24
+3V_WLAN on TOP (solid shape): 292.97,103.11 292.97,100.5 292.53,100.06 292.53,99.31 292.37,99.15 288.49,99.15 287.51,100.13 287.51,100.57 287.64,100.69 288.52,100.69 288.65,100.82 288.65,101.01 290.87,101.01 290.88,100.95 290.89,100.9 290.91,100.85 290.94,100.8 290.97,100.76 291.01,100.72 291.06,100.68 291.11,100.66 291.16,100.64 291.21,100.63 291.27,100.63 291.32,100.63 291.38,100.65 291.43,100.67 291.48,100.7 291.52,100.74 291.56,100.78 291.59,100.82 291.61,100.87 291.63,100.93 291.64,100.98 291.64,101.04 291.63,101.09 291.61,101.15 291.59,101.2 291.56,101.24 291.52,101.29 291.48,101.32 291.43,101.35 291.38,101.37 291.32,101.39 291.27,101.39 291.21,101.39 291.16,101.38 291.11,101.36 291.06,101.34 291.01,101.3 290.97,101.27 290.94,101.22 290.91,101.17 290.89,101.12 290.88,101.07 290.87,101.01 288.65,101.01 288.65,101.2 288.78,101.33 290.81,101.33 290.94,101.45 290.94,103.23 291.06,103.36 292.72,103.36
+3V_WLAN on BOTTOM (solid shape): 288.78,100.57 288.78,100.18 288.63,100.03 288.63,98.56 288.6,98.53 288.4,98.53 288.37,98.56 288.37,100.01 288.32,100.06 288.19,100.06 288.14,100.01 288.14,98.56 288.12,98.53 287.89,98.53 287.86,98.56 287.86,100.01 287.81,100.06 287.64,100.06 287.56,100.13 287.56,100.62 287.64,100.69 288.65,100.69
+3V_WLAN on BOTTOM (solid shape): outline of 102 points within 305.09,97.64 308.08,100.95
+3V_WLAN on IN2 (solid shape): outline of 423 points within 287.51,96.5 306.36,100.82
+3VO on TOP (solid shape): 258.93,80.53 258.93,79.64 259.07,79.5 259.07,78.65 258.81,78.39 258.04,78.39 257.66,78.01 257.33,78.01 257.08,78.26 257.08,78.72 257.44,79.08 257.44,79.33 257.97,79.86 258.2,79.86 258.32,79.99 258.32,80.55 258.91,80.55
+3VO on TOP (solid shape): 226.55,27.16 226.55,25.89 226.29,25.64 225.39,25.64 225.18,25.73 224.96,25.7 224.94,25.72 224.95,25.75 224.84,26.21 224.37,26.32 224.34,26.31 224.01,26.65 224.01,27.16 224.14,27.29 226.42,27.29
+3VO on TOP (solid shape): outline of 131 points within 241.42,13.23 260.4,29.57
+3VO on BOTTOM (solid shape): 119.19,23.99 119.19,23.88 119.21,23.53 119.51,23.35 119.56,23.3 120.1,23.3 120.34,23.06 120.34,22.17 119.71,21.55 119.51,21.55 119.03,21.06 118.42,21.06 118.01,21.47 118.01,23.81 118.32,24.11 119.07,24.11
+3VO on BOTTOM (solid shape): outline of 102 points within 240.78,16.4 259.69,40.23
+3VO on BOTTOM (solid shape): outline of 177 points within 254.72,47.3 257.89,51.57
+3VO on BOTTOM (solid shape): outline of 480 points within 254.13,57.45 260.58,79.66
+3VO on IN1 (solid shape): 123.09,8.95 123.09,6.89 122.79,6.59 120.22,6.59 119.51,7.3 119.51,9 119.67,9.15 122.89,9.15
+3VO on IN1 (solid shape): 256.34,60.21 256.34,59.65 256.27,59.42 256.34,59.19 256.34,58.1 256.01,57.77 255.33,57.77 255.1,58 255.1,60.13 255.43,60.46 256.09,60.46
